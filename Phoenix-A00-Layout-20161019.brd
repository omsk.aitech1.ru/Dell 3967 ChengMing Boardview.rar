# Allegro board Phoenix-A00-Layout-20161019.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
X_EXP_A_TX_C_DP4: length 9.6
  TOP w0.102: v1(86.19,205.21) 86.47,204.93 86.76,204.93 86.89,205.06 CX27.2
  BOTTOM w0.102: v1(86.19,205.21) 85.9,204.92 84.43,204.92 83.4,203.89 80.03,203.89 79.76,204.15 79.76,204.54 80,204.78 SLOT1.B33
X_EXP_A_TX_C_DP5: length 9.6
  TOP w0.102: CX29.2 86.84,200.99 86.74,200.89 86.3,200.89 v1(86.02,201.17)
  BOTTOM w0.102: SLOT1.B37 80,200.78 79.76,200.54 79.76,200.15 80.01,199.9 83.65,199.9 84.64,200.89 85.74,200.89 v1(86.02,201.17)
X_EXP_A_TX_C_DP6: length 9.6
  TOP w0.102: CX31.2 86.8,197.03 86.7,196.92 86.19,196.92 v1(85.91,197.21)
  BOTTOM w0.102: SLOT1.B41 80,196.78 79.76,196.54 79.76,196.15 80.05,195.86 83.45,195.86 84.51,196.92 85.63,196.92 v1(85.91,197.21)
X_EXP_A_TX_C_DP7: length 9.5
  TOP w0.102: v1(86.11,193.17) 86.37,192.91 86.65,192.91 86.81,193.08 CX33.2
  BOTTOM w0.102: v1(86.11,193.17) 85.83,192.89 84.51,192.89 83.5,191.87 80.04,191.87 79.76,192.15 79.76,192.54 80,192.78 SLOT1.B45
X_EXP_A_TX_C_DP8: length 9.5
  TOP w0.102: v1(86,187.23) 86.28,186.95 86.71,186.95 86.81,187.05 CX35.2
  BOTTOM w0.102: v1(86,187.23) 85.72,186.94 84.46,186.94 83.47,187.93 80.11,187.93 79.63,187.45 78.98,187.45 SLOT1.B50
X_EXP_A_TX_C_DP9: length 9.5
  TOP w0.102: CX37.2 86.8,182.93 86.7,182.83 86.27,182.83 v1(85.99,183.11)
  BOTTOM w0.102: v1(85.99,183.11) 85.71,182.83 84.62,182.83 83.55,183.9 80.07,183.9 79.63,183.45 78.98,183.45 SLOT1.B54
X_EXP_A_TX_C_DP10: length 9.4
  TOP w0.102: v1(86.09,179.17) 86.37,178.89 86.61,178.89 86.8,179.08 CX39.2
  BOTTOM w0.102: v1(86.09,179.17) 85.81,178.89 84.53,178.89 83.53,179.88 80.06,179.88 79.63,179.45 78.98,179.45 SLOT1.B58
X_EXP_A_TX_C_DP11: length 9.5
  TOP w0.102: CX41.2 86.8,175.07 86.69,174.95 86.22,174.95 v1(85.94,175.23)
  BOTTOM w0.102: SLOT1.B62 78.98,175.45 79.63,175.45 80.11,175.93 83.36,175.93 84.35,174.95 85.66,174.95 v1(85.94,175.23)
X_EXP_A_TX_C_DP12: length 9.6
  TOP w0.102: CX43.2 86.93,171.07 86.76,170.9 86.44,170.9 86.16,171.18 v3(86.16,171.19)
  BOTTOM w0.102: SLOT1.B66 78.98,171.45 79.63,171.45 80.11,171.93 83.34,171.93 84.39,170.89 85.87,170.89 v3(86.16,171.19)
X_EXP_A_TX_C_DP13: length 9.5
  TOP w0.102: v1(85.97,167.23) 86.25,166.95 86.7,166.95 86.8,167.05 CX45.2
  BOTTOM w0.102: v1(85.97,167.23) 85.69,166.95 84.46,166.95 83.48,167.93 80.11,167.93 79.63,167.45 78.98,167.45 SLOT1.B70
X_EXP_A_TX_C_DP14: length 9.8
  TOP w0.102: CX47.2 86.65,163.27 86.39,163.27 86.23,163.43 v3(86.23,163.57)
  BOTTOM w0.102: SLOT1.B74 78.98,163.45 79.63,163.45 80.11,163.93 83.4,163.93 84.43,162.91 85.34,162.91 85.7,163.27 85.93,163.27 v3(86.23,163.57)
X_EXP_A_TX_C_DP15: length 9.9
  TOP w0.102: CX100.2 87.09,159.54 86.99,159.44 86.63,159.44 v1(86.35,159.72)
  BOTTOM w0.102: SLOT1.B78 78.98,159.45 79.63,159.45 80.11,159.93 83.84,159.93 84.72,159.05 85.46,159.05 85.85,159.44 86.07,159.44 v1(86.35,159.72)
X_PCI1_ACK64#_R: length 10.7
  TOP w0.102: SLOT4.B60 20.11,168.01 21.37,166.75 22.32,166.75 23.71,165.35 25.5,165.35 RK50.2
X_PCI1_K_AD17_R: length 15.2
  TOP w0.102: RK55.1 27.69,203.3 26.35,203.3 v1(25.89,202.84)
  BOTTOM w0.102: v1(25.89,202.84) 25.89,210.28 24.98,211.19 SLOT4.A26
X_PCI1_REQ64#_R: length 5.6
  TOP w0.102: SLOT4.A60 22.06,167.33 23.78,165.61 RK54.1
X_PCI1_SMBCLK_R: length 4.3
  TOP w0.102: SLOT4.A40 22.9,193.41 26.28,193.41 RK51.1
X_PCI1_SMBDATA_R: length 1.8
  TOP w0.102: RK52.1 26.28,192.14 SLOT4.A41
X_PCI_ACK64#_B60: length 12.2
  TOP w0.102: RK4.2 46.97,170.45 44.5,170.45 43.39,169.34 41.13,169.34 40.17,170.31 39.6,170.31 SLOT3.B60
X_PCI_REQ64#_A60: length 5.1
  TOP w0.102: SLOT3.A60 44.59,170.22 46.18,170.22 RK5.1
X_PCI_SMBCLK_R: length 7.5
  TOP w0.102: RK10.1 36.04,192.41 37.75,192.41 38.76,193.41 SLOT3.A40
X_PCI_SMBDATA_R: length 10.3
  TOP w0.102: SLOT3.A41 41.95,192.14 40.93,193.17 38.9,193.17 37.9,192.18 35.81,192.18 RK19.1
X_PLTRST_PCIE_SLOT#: length 452.5
  TOP w0.102: v1(209.08,27.29) 209.08,28.01 209.66,28.6 209.66,31.06 212.5,33.91 RO13.2 ; v1(232.32,44.96) 231.68,44.96 231.17,45.47 RO166.1 ; v1(91.09,107.72) 91.78,107.72 92.97,108.92 92.97,122.11 92.59,122.49 92.59,127.49 92.5,127.58 92.5,129.78 91.6,130.68 v1(91.6,132.84) 91.6,134.85 91.17,135.28 91.17,137.32 90.76,137.73 90.76,144.42 89.85,145.33 89.85,146.82 88.49,148.18 87,148.18 85.54,149.64 80.01,149.64 76.88,152.76 76.88,155.19 71.45,160.63 70.17,160.63 v1(69.7,161.1) ; v1(100.74,132.72) 101.14,132.31 M.2_SSD.50 ; v1(221.9,27.29) RO188.2 ; v1(92.24,51.18) 91.96,50.9 88.46,50.9 85.07,54.29 85.07,56.95 78.32,63.7 78.32,80.39 77.55,81.15 77.38,81.15 v1(77.12,81.41) ; SLOT2.A11 63.11,228.35 65.63,228.35 CX54.1 66.77,228.22 75.73,228.22 v1(77.57,230.06) 78.01,230.5 79.15,230.5 80.14,229.51 83.57,229.51 83.98,229.11 83.98,228.47 84.55,227.9 RX6.2
  BOTTOM w0.102: v1(91.6,132.84) 91.6,132.94 92.01,133.35 94.59,133.35 96.12,131.83 98.08,131.83 99.73,133.48 100.36,133.48 100.74,133.1 v1(100.74,132.72) ; v1(77.12,81.41) 77.38,81.15 84.31,81.15 88.53,85.37 88.53,89.81 86.14,92.2 83.63,92.2 78.75,97.08 78.75,101.47 82.99,105.71 89.19,105.71 91.09,107.62 v1(91.09,107.72) ; v1(232.32,44.96) 231.94,44.96 230.59,43.61 230.59,41.62 227.65,38.68 227.65,38.1 226.88,37.33 226.88,32.04 227.24,31.68 227.24,29.84 224.68,27.29 v1(221.9,27.29) v1(209.08,27.29) 205.73,27.29 202.85,30.18 197.66,30.18 187.6,40.23 185.82,40.23 182.36,43.7 176.9,43.7 173.66,40.46 154.4,40.46 153.36,41.5 151.25,41.5 150.29,42.47 146.1,42.47 145.06,41.44 139.69,41.44 138.66,42.47 136.6,42.47 135.88,43.18 120.43,43.18 118.75,44.86 115.5,44.86 109.86,50.5 97.4,50.5 96.06,49.15 94.27,49.15 v1(92.24,51.18) ; v1(69.7,161.1) 71.03,162.43 71.03,163.83 70.14,164.72 70.14,166.12 76.46,172.44 76.46,174.09 76.49,174.12 76.49,209.65 76.26,209.88 76.26,226.01 77.57,227.32 v1(77.57,230.06)
X_RST_SLOT_PEG#: length 63
  TOP w0.102: v1(49.82,248.28) 49.82,250 RX181.2 ; v1(52.61,231.65) 53.37,230.89 58.71,230.89 59.72,229.87 62.64,229.87 63.66,228.85 65.18,228.85 65.82,229.49 67.98,229.49 69.02,228.45 75.32,228.45 77.6,230.73 79.25,230.73 80.24,229.74 83.73,229.74 84.23,229.23 84.23,228.6 84.36,228.47 86.96,228.47 RX7.2
  BOTTOM w0.102: v1(49.82,248.28) 49.33,248.28 47.63,246.59 47.63,244.86 v2(48.06,244.43) 48.67,243.81 48.67,240.44 47.63,239.39 47.63,236.12 52.1,231.65 v1(52.61,231.65)
X_RST_SLOT_PEG#_R: length 2.1
  TOP w0.102: RX181.1 50.58,250.7 v1(50.96,251.08) 50.96,251.89 UX1.4
XCLK_RCOMP: length 5.7
  TOP w0.089: U4.E1 66.27,135.48 v1(66.56,135.76)
  TOP w0.102: R6464.2 v1(67.98,139.51)
  BOTTOM w0.089: 66.81,135.79 66.78,135.76 v1(66.56,135.76)
  BOTTOM w0.102: 66.81,135.79 67.67,136.65 67.67,139.2 v1(67.98,139.51)
XDP_CPU_HOOK6: length 28
  TOP w0.102: R96.1 129.99,208.08 130.37,208.46 130.37,208.98 129.96,209.39 129.15,209.39 v1(128.68,209.85) ; v1(116.11,201.68) 116.11,199.71 RH1.1 115.67,198.56 116.68,197.55 RS169.1 116.68,196.47 RS16.1 RH2.1
  BOTTOM w0.102: v1(116.11,201.68) 116.24,201.68 119.08,204.52 v2(119.08,205.84) 121.37,208.13 122.71,208.13 124.37,209.78 128.61,209.78 v1(128.68,209.85)
XDP_CPU_HOOK6_R: length 3.6
  TOP w0.102: XDP_CPU.46 130.16,205.82 v1(129.8,206.18) 129.8,206.25 R87.2 R96.2
XDP_FP_RST#: length 5
  TOP w0.102: XDP_CPU.48 130.66,206 130.45,206.22 130.45,207.4 C75.2 130.88,207.86 131.33,208.31 v1(131.33,208.43) 131.33,208.5 R6659.2
XDP_HOOK2: length 11.8
  TOP w0.102: RX21.2 127.16,193.04 127.35,193.23 R6682.2 129.83,193.23 131.24,194.64 131.53,194.64 131.87,194.98 131.87,196.38 132.3,196.8 v1(132.3,196.8) 132.3,197 131.92,197.38 130.88,197.38 130.64,197.62 130.46,197.62 130.16,197.92 XDP_CPU.45
XDP_PCH_JTAGX: length 11.1
  TOP w0.089: U4.AR3 51.44,134.69 v1(51.44,136.12) 51.44,136.37 50.59,137.22 49.87,137.22 48.82,138.28 47.24,138.28 RS225.1 46.53,139.01
  TOP w0.102: RS227.2 47.02,141.03 47.02,139.51 46.53,139.01
XDP_PRESENT#_CPU: length 4.5
  TOP w0.102: XDP_CPU.1 119.15,197.05 R6681.1 119.72,196.48 R97.2 v1(118.68,195.77)
XDP_PRESENT#_R: length 312.2
  TOP w0.102: v1(32.55,111) 32.55,112.27 34.37,114.09 36.95,114.09 37.72,114.87 37.72,117.51 R102.2 ; v1(84.74,68.45) 84.74,84.94 81.95,87.73 81.95,93.93 79.76,96.11 79.76,102.4 81.82,104.46 81.82,111.33 86.6,116.11 86.6,123.37 85.39,124.57 85.39,131.86 85.15,132.11 85.15,132.77 v1(85.35,132.97) ; XDP_CPU.60 133.66,205.61 134.07,206.02 134.07,206.53 134.41,206.87 135.34,206.87 R121.1 136.53,208.06 136.53,208.94 135.16,210.31 134.15,210.31 131.11,213.35 114.92,213.35 111.23,209.66 111.23,202.14 94.55,185.45 94.55,164.52 97.69,161.37 97.69,156.49 97.01,155.81 97.01,155.15 92.55,150.69 92.55,146.75 95.28,144.02 95.28,142.06 v1(95.31,142.03)
  BOTTOM w0.102: v1(84.74,68.45) 83.78,68.45 79.64,72.59 68.71,72.59 68.33,72.97 65.86,72.97 65.27,73.56 63.04,73.56 62.3,74.29 60.8,74.29 60.17,74.93 53.3,74.93 52.71,74.35 48.66,74.35 48.12,74.89 48.12,76.5 45.49,79.13 45.49,79.92 43.78,81.63 43.78,89.62 44.03,89.87 44.03,102.07 40.47,105.62 28.79,105.62 25.1,109.31 25.1,109.89 25.6,110.39 27.7,110.39 28.31,111 v1(32.55,111) ; v1(95.31,142.03) 94.97,142.03 92.56,139.62 90.89,139.62 90.23,138.96 87.79,138.96 87.54,138.71 86.56,138.71 86.05,138.2 84.77,138.2 v2(84.49,137.92) 84.49,137.41 83.85,136.78 83.85,134.3 85.18,132.97 v1(85.35,132.97)
XDP_PWRBTN_OUT#: length 13.5
  TOP w0.102: R88.2 123.74,193.1 R92.2 124.11,193.6 125.7,193.6 v1(126.15,194.06) 126.71,193.5 127.54,193.5 127.92,193.88 128.81,193.88 129.08,194.14 129.08,194.46 129.58,194.97 129.63,195.02 129.63,195.59 C74.2 129.16,197.08 XDP_CPU.41
XDP_RSMRST#: length 3.3
  TOP w0.102: XDP_CPU.39 128.66,197.86 128.39,197.59 v1(128.39,196.86) R89.2
XDP_SPI_MOSI: length 7.2
  TOP w0.102: R93.2 R86.2 132.88,196.5 v1(133.18,196.8) 132.37,197.61 131.05,197.61 130.66,198 XDP_CPU.47
  BOTTOM w0.102: v1(133.18,196.8) 133.79,196.19 v2(134.23,196.19)
XTAL_24M_IN: length 12.7
  TOP w0.089: U4.A6 69.39,134.18 69.39,134.48
  TOP w0.102: 69.39,134.48 69.91,135 v1(70.39,135) 71.09,135 R6469.1 71.34,134.87 72.23,134.87 73.85,133.25 73.92,133.25 C1642.1 74.36,132.81 75.47,132.81 76.07,132.21 77,132.21 Y1.3
XTAL_24M_OUT: length 10.5
  TOP w0.089: 69.04,134.82 69.04,134.82 69.04,134.79 69.02,134.77 69.02,134.49 v1(68.66,134.14) 68.66,133.96 U4.A5
  TOP w0.102: 69.04,134.82 69.92,135.7 R6469.2 72.09,135.7 73.8,133.99 C1643.1 74.07,133.99 74.75,133.31 Y1.1
XTAL_IN: length 14.2
  TOP w0.102: RTK_LAN.28 113.44,227 113.9,226.54 114.82,226.54 115.04,226.31 117,226.31 117.51,226.82 CL36.1 118.71,227.33 123.86,227.33 124.24,226.95 124.24,225.17
XTAL_OUT: length 2.9
  TOP w0.102: RTK_LAN.29 113.75,227.4 114.13,227.03 v1(114.49,227.03) 115.08,227.03 RL12.1
XTAL_OUT_R: length 11.2
  TOP w0.102: XL1.1 124.24,228.09 123.99,227.84 120.43,227.84 119.92,228.35 118.71,228.35 CL35.1 117.76,227.84 116.75,226.82 RL12.2
N120560027: length 2.7
  TOP w0.102: M.2_SSD.53 100.39,123.12 100.25,122.97 100.25,122.8 100.72,122.33 100.72,121.83 100.82,121.73 RM15.2
N120560030: length 2.7
  TOP w0.102: RM16.2 100.32,121.73 100.52,121.92 100.52,122.24 100.04,122.71 100.04,123 99.89,123.15 M.2_SSD.55
N120811996: length 3.5
  TOP w0.102: v1(222.54,27.94) 223.55,28.96 Q3.G 222.03,29.27 RO188.1
N120812085: length 4.2
  TOP w0.102: QV22.G v1(219.38,244.46) 219.38,243.22 218.35,242.19 RI1.1
N120812204: length 1.8
  TOP w0.102: RI2.1 216.82,238.25 v1(217.2,237.87) Q99.G
N120812265: length 3.8
  TOP w0.102: Q104.G v1(222.92,237.87) 222.92,238.12 223.48,238.68 225.09,238.68 RI3.1
N120812340: length 1.7
  TOP w0.102: RI4.1 v1(227.12,239.9) 227.12,240.05 QV49.G
N120964019: length 1.9
  TOP w0.102: RIO11.2 195.42,11.9 HDD_LED.1
N121283078: length 6.7
  TOP w0.102: UA1.12 183.38,27.14 182.72,27.8 v1(182.29,27.8) 181.77,28.32 181.67,28.32 180.07,29.93 179.04,29.93 CA17.1
N121341151: length 7.1
  TOP w0.089: v1(59.72,115.82) 59.98,115.82 60.18,115.62 U4.U41
  TOP w0.102: v1(60.87,110.74) 60.99,110.62 RH9.2
  BOTTOM w0.089: v1(59.72,115.82) 59.72,114.21 60.42,113.52 v2(60.42,112.59) 60.42,111.25
  BOTTOM w0.102: 60.42,111.25 60.42,111.19 v1(60.87,110.74)
N121341154: length 8.7
  TOP w0.089: U4.M44 62.9,114.04 63.14,113.81 63.14,113.42 63.73,112.83 63.73,112.32 64.8,111.25
  TOP w0.102: RH10.2 64.8,107.38 64.8,110.43 v1(65.08,110.71) 64.9,110.9 64.9,111.16 64.8,111.25
N121428079: length 5.6
  TOP w0.508: RL44.2 118.52,232.85 118.52,236.56 NIC_USB.18
N121488357: length 4.5
  TOP w0.102: v1(154.47,229.92) 154.23,229.68 RG31.1 153.83,228.66 RG32.2 153.58,228.6 152.68,227.71 RTK_VGA.18
  BOTTOM w0.102: v1(154.47,229.92) 153.72,229.92 v2(153.68,229.88)
N121515008: length 19.3
  TOP w0.508: RF12.2 223.93,231.14 222.28,232.79 218.07,232.79 216.85,231.57 216.85,229.31 217.82,228.34 v1(217.82,227.29) 217.82,225.11 217.31,224.6 RF15.2 216.82,223.39 216.17,222.74 QF2.B
N121515022: length 6.7
  TOP w0.102: RF14.1 220.82,229.86 220.82,229.43 221.39,228.85 UF147.3 221.39,227.2 220.89,226.69 220.25,226.69 219.84,226.29 v1(219.54,226.29) 219.32,226.29 RF13.1
N121515024: length 4.5
  TOP w0.102: v1(223.32,226.8) 223.07,226.8 222.66,227.21 UF147.2 222.66,228.88 222.79,229.01 CF6.1 222.78,229.68 RF11.2
N121515291: length 3.2
  TOP w0.102: UF147.6 221.39,223.3 221.86,223.77 v1(221.98,223.77) 222.08,223.77 222.66,223.19 UF147.7
N121515335: length 2.4
  TOP w0.102: RF12.1 223.93,229.44 v1(223.39,228.89) 223.93,228.35 UF147.1

## Copper pours and planes (outline as drawn)
+3V_5V_EN_3V on TOP (solid shape): 53.56,63.82 54.18,63.82 54.34,63.66 54.34,62.61 53.58,61.85 52.3,61.85 51.94,62.21 51.94,63.37 51.81,63.49 51.09,63.49 50.93,63.65 50.93,64.05 51.07,64.19 53.2,64.19
+3V_5V_EN_R on TOP (solid shape): 37.59,61.78 38.75,61.78 39.13,61.4 39.13,60.94 38.77,60.58 37.17,60.58 36.38,61.37 36.38,62.28 36.52,62.42 36.96,62.42
+3V_BATT on TOP (solid shape): 40.94,69.46 40.94,69.15 40.72,68.92 39.59,68.92 39.4,69.11 39.4,69.44 39.64,69.69 40.71,69.69
+3V_BATT on TOP (solid shape): 170.48,56.47 170.48,56.14 170.25,55.91 167.38,55.91 167.32,55.97 167.32,56.54 167.49,56.72 170.23,56.72
+3V_BATT on TOP (solid shape): 72.81,68.59 72.81,66.81 72.66,66.66 72.14,66.66 71.67,67.13 71.67,68.18 71.66,68.19 71.66,68.89 71.81,69.03 72.36,69.03
+3V_BATT on BOTTOM (solid shape): 40.94,69.46 40.94,69.15 40.72,68.92 39.59,68.92 39.4,69.11 39.4,69.44 39.64,69.69 40.71,69.69
+3V_BATT on BOTTOM (solid shape): 74,67.94 74,66.86 73.76,66.62 72.33,66.62 72.11,66.85 72.11,67.95 72.17,68.02 73.92,68.02
+3V_BATT on BOTTOM (solid shape): 168.72,56.56 168.72,56.2 168.41,55.88 168.01,55.88 167.5,55.37 166.59,55.37 166.47,55.49 166.47,55.69 167.45,56.67 168.61,56.67
+3V_LAN on TOP (solid shape): 104.5,230.25 104.55,230.25 104.62,230.25 105.44,229.43 106.37,229.43 107.92,227.89 108.96,227.89 108.99,227.86 108.99,227.75 108.95,227.7 107.99,227.7 107.8,227.52 107.5,227.52 106.87,228.14 104.79,228.14 103.74,229.19 103.74,229.84 103.92,230.02 103.92,230.14 104.04,230.26 104.45,230.26
+3V_LAN on TOP (solid shape): 74.52,254.24 74.52,253.6 73.71,252.79 73.48,252.79 73.47,252.8 73.18,252.88 72.89,252.79 71.8,252.79 71.63,252.62 71.63,252.34 71.31,252.03 70.13,252.03 69.95,252.21 69.95,254.23 70.38,254.66 74.09,254.66
+3V_LAN on TOP (solid shape): 117.25,232.16 117.25,229.46 117.15,229.36 114.99,229.36 114.23,228.6 113.22,228.6 113.11,228.5 112.93,228.5 112.93,228.5 112.35,228.5 112.28,228.57 112.28,228.64 112.8,229.16 113.75,229.16 114.08,229.48 114.08,229.72 114.56,230.2 115.04,230.2 116.14,231.29 116.14,232.16 116.31,232.33 117.08,232.33
+3V_LAN on TOP (solid shape): 111.55,225.53 111.56,225.57 111.6,225.58 111.69,225.58 111.74,225.53 111.74,224.92 111.82,224.84 111.82,224.84 111.89,224.76 111.92,224.73 112.25,224.41 112.25,224.41 112.75,223.91 112.75,223.57 113.28,223.04 113.8,223.04 114.51,222.33 114.51,222.11 114.46,221.94 114.49,221.77 114.5,221.74 114.41,221.64 113.88,221.64 113.57,221.34 113.57,221.23 113.42,221.08 112.12,221.08 112,221.21 112,223.16 111.63,223.53 111.63,224.73 111.54,224.82 111.54,224.92 111.55,224.92
+3V_LAN on BOTTOM (solid shape): 109.05,227.71 109.05,226.19 109.58,225.65 112.02,225.65 114.43,223.24 114.43,222.23 114.41,222.19 114.39,222.15 114.26,222.02 111.99,224.29 110.39,224.29 109.89,224.79 109.61,224.79 109.25,225.15 108.26,225.15 107.4,226.01 107.4,226.88 107.54,227.01 107.54,227.48 107.4,227.62 107.4,227.76 107.39,227.77 107.47,227.86 108.9,227.86
+3V_LAN on BOTTOM (solid shape): outline of 678 points within 98.52,229.46 129.32,243.76
+3V_LAN on L2_VCC: 94.37,238.38 85.12,247.63 85.12,251.18 82.82,253.49 71.26,253.49 70.65,254.11 70.65,257.2 70.75,257.3 90.86,257.3 91.22,256.94 91.22,255.63 90.71,255.12 90.71,246.15 94.8,242.06 100.77,242.06 101,241.83 101,240.14 99.24,238.38
+3V_VA on TOP (solid shape): 181.86,30.61 182.89,30.61 183.12,30.39 183.12,29.4 182.84,29.11 182.01,29.11 181.22,29.9 181.22,30.38 181.46,30.62 181.86,30.62
+3V_VA on TOP (solid shape): 190.09,32.08 190.09,28.94 190.31,28.72 190.34,28.69 190.53,28.5 190.53,28.29 190.38,28.15 189.79,28.15 189.79,28.15 189.72,28.15 188.66,27.09 188.66,26.58 188.36,26.27 188.19,26.27 188.19,26.28 187.85,26.62 187.68,26.62 187.68,27.12 188.29,27.73 188.29,28.78 188.57,29.06 188.57,30.23 188.34,30.45 188.34,30.95 188.88,31.49 188.88,32.04 189.13,32.29 189.88,32.29
+3V_VA on TOP (solid shape): 189.27,20.06 189.67,19.65 189.73,19.56 189.8,19.49 189.8,19.24 189.67,19.12 189.47,19.12 189.46,19.11 189.26,19.11 189.2,19.13 189.14,19.13 189.01,19.13 188.79,19.06 188.65,18.87 188.63,18.85 188.2,18.85 188.05,19 188.05,19.58 188.17,19.92 187.96,20.21 187.95,20.22 187.68,20.49 187.68,21.27 187.7,21.29 187.7,21.3 187.76,21.36 187.96,21.36
+3V_VA on BOTTOM (solid shape): outline of 236 points within 186.22,18.77 189.93,29.11
+5V_AUX on TOP (solid shape): 218.07,18.87 218.07,17.07 217.74,16.74 216.78,16.74 216.51,17.02 216.51,18.77 216.94,19.19 217.75,19.19
+5V_AUX on TOP (solid shape): 224.56,18.69 224.56,17.06 224.35,16.84 223.13,16.84 222.97,17.01 222.97,18.87 223.07,18.97 224.28,18.97
+5V_AUX on TOP (solid shape): 19.46,33.27 19.46,31.5 19.34,31.37 11.41,31.37 11.03,31.75 11.03,32.56 11.87,33.4 19.34,33.4
+5V_AUX on TOP (solid shape): 106.72,35.18 106.72,27.06 106.33,26.67 100.11,26.67 99.59,27.19 99.59,35.14 100.54,36.09 105.81,36.09
+5V_AUX on TOP (solid shape): 4.61,43.28 5.27,43.28 6.56,41.98 6.56,41.55 7.68,40.44 7.68,38.96 7.55,38.84 7.15,38.84 7.04,38.94 7.04,40.08 5.88,41.25 4.5,41.25 4.21,40.95 4.2,40.95 2.92,39.67 1.84,39.67 1.53,39.98 1.53,44.48 1.61,44.55 3.33,44.55
+5V_AUX on TOP (solid shape): outline of 315 points within 9.34,46.12 29.56,61.59
+5V_AUX on TOP (solid shape): outline of 415 points within 5.8,239.09 94.8,257.33
+5V_AUX on BOTTOM (solid shape): outline of 126 points within 216.52,16.53 224.71,19.56
+5V_AUX on BOTTOM (solid shape): outline of 150 points within 17.59,57.84 29.94,61.49
+5V_AUX on BOTTOM (solid shape): outline of 632 points within 10.55,32.16 22.39,56.01
+5V_AUX on L2_VCC: 11.13,26.35 10.7,26.78 10.7,32.28 11.82,33.4 35.19,33.4 37.35,35.56 63.38,35.56 70.5,42.67 106.1,42.67 107.86,40.92 107.86,40.36 106.71,39.22 106.71,26.78 106.29,26.35
+5V_AUX on L2_VCC: 11.57,46.1 9.3,48.37 9.3,54.76 10.43,55.88 15.12,55.88 16.54,57.3 16.54,61.24 16.9,61.59 28.76,61.59 29.52,60.83 34.47,60.83 34.7,60.6 34.7,55.1 34.47,54.86 32.52,54.86 30.36,57.02 24.57,57.02 23.78,56.24 23.78,46.97 22.91,46.1
+5V_DUAL_USB on TOP (solid shape): 75.06,41.81 75.06,40.59 74.8,40.33 69.3,40.33 68.99,40.64 68.99,41.17 70.56,42.74 74.14,42.74
+5V_DUAL_USB on TOP (solid shape): 156.2,239.64 156.2,238.89 155.94,238.63 152.72,238.63 152.46,238.89 152.46,239.62 152.73,239.9 155.94,239.9
+5V_DUAL_USB on TOP (solid shape): 165.81,240.8 165.81,238.42 165.62,238.24 164.41,238.24 164.24,238.4 164.24,241 164.33,241.09 165.52,241.09
+5V_DUAL_USB on TOP (solid shape): 206.38,256.81 206.38,253.73 205.04,252.39 167.15,252.39 166.57,252.96 166.57,256.68 167.18,257.29 205.9,257.29
+5V_DUAL_USB on TOP (solid shape): 68.46,71.9 68.46,70.11 67.53,69.19 65.61,69.19 65.26,69.53 65.26,71.29 66.1,72.14 68.22,72.14
+5V_DUAL_USB on TOP (solid shape): 147.94,243.59 147.94,241.45 146.43,239.94 144.28,239.94 143.97,240.25 143.97,242.47 145.3,243.79 147.73,243.79
+5V_DUAL_USB on TOP (solid shape): outline of 84 points within 91.98,38.95 98.08,42.67
+5V_DUAL_USB on TOP (solid shape): outline of 273 points within 219.22,64.78 240.85,237.36
+5V_DUAL_USB on TOP (solid shape): outline of 518 points within 107.56,4.3 202.04,59.94
+5V_DUAL_USB on BOTTOM (solid shape): 73.01,48.51 73.01,44.52 69.46,40.97 68.78,40.97 67.22,42.54 67.22,44.7 69.38,46.86 69.38,48.64 69.58,48.84 72.67,48.84
+5V_DUAL_USB on BOTTOM (solid shape): 221.14,67.56 221.14,66.55 218.73,64.13 216.57,64.13 215.68,63.25 212,63.25 206.03,57.28 201.48,57.28 200.31,58.45 198.76,58.45 198.53,58.67 198.53,60.76 198.71,60.93 204.22,60.93 210.35,67.06 215.3,67.06 216.06,67.82 220.89,67.82
+5V_DUAL_USB on BOTTOM (solid shape): 99.16,41.46 99.15,41.43 99.41,40.29 100.56,40.06 101.63,38.99 105.01,38.99 106.08,37.92 114.33,37.92 115.13,37.12 115.13,35.67 114.87,35.41 105.11,35.41 104.25,36.27 99.52,36.27 95.98,39.82 95.96,39.92 96.05,39.99 96.73,41.83 94.89,41.15 94.82,41.06 94.71,41.08 94.39,41.4 94.39,43.05 94.9,43.56 97.06,43.56
+5V_DUAL_USB on BOTTOM (solid shape): outline of 444 points within 132.49,3.7 173.88,26.28
+5V_DUAL_USB on BOTTOM (solid shape): outline of 1950 points within 144.48,234.02 227.49,257.3
+5V_DUAL_USB on L2_VCC: 68.27,48.01 67.85,48.43 67.85,50.19 68.99,51.33 68.99,58.4 66.58,60.81 66.58,63.48 65.82,64.24 65.82,72.28 66.31,72.77 68.38,72.77 68.74,72.41 68.74,71.01 69.52,70.23 70.16,70.23 70.52,69.87 70.52,60.98 73.19,58.31 73.19,48.37 72.83,48.01
+5V_DUAL_USB on L2_VCC: outline of 108 points within 107.22,2.95 241.21,237.36
+5V_HDMI on TOP (solid shape): 225.41,253.37 225.41,252.86 225.79,252.48 226.68,252.48 226.81,252.35 226.81,250.7 226.68,250.57 224.1,250.57 223.29,251 222.49,250.57 219.7,250.57 219.57,250.7 219.57,253.24 219.82,253.49 225.28,253.49
+5V_MAIN on TOP (solid shape): 28.25,240.92 28.25,239.28 28.06,239.08 27.19,239.08 27.06,239.21 27.06,240.94 27.19,241.07 28.1,241.07
+5V_MAIN on TOP (solid shape): 66.41,242.91 66.41,242.25 66.21,242.05 64.53,242.05 64.29,242.29 64.29,242.88 64.5,243.1 66.22,243.1
+5V_MAIN on TOP (solid shape): 203.08,25.48 203.08,23.65 202.94,23.51 202.32,23.51 201.73,24.1 201.73,25.6 201.96,25.83 202.73,25.83
+5V_MAIN on TOP (solid shape): 49.14,28.98 49.14,27.09 48.37,26.31 44,26.31 43.67,26.64 43.67,28.5 44.91,29.74 48.38,29.74
+5V_MAIN on TOP (solid shape): 93.67,234.8 93.67,234.41 93.28,234.02 92.73,234.02 92.55,234.2 92.55,234.21 91.05,235.71 91.05,235.97 91.56,236.48 91.99,236.48
+5V_MAIN on TOP (solid shape): 58.83,208.5 58.94,208.48 59.04,208.5 59.62,208.5 59.85,208.26 59.85,206.63 59.72,206.5 56.8,206.5 56.68,206.63 56.68,208.38 56.79,208.5
+5V_MAIN on TOP (solid shape): 190.81,236.55 190.81,235.41 189.78,234.38 189.78,233.05 189.2,232.46 186.05,232.46 185.93,232.59 185.93,233.57 186.32,233.96 186.32,234.34 186.58,234.61 186.93,234.61 188.98,236.66 190.7,236.66
+5V_MAIN on TOP (solid shape): 49.94,244.73 49.94,243.97 49.94,243.96 49.95,243.95 49.95,241.18 45.81,237.03 44.6,237.03 43.94,237.69 43.94,238.6 44.26,238.91 45.23,238.91 47.77,241.45 47.77,243.98 47.79,243.99 47.79,244.73 47.91,244.86 49.82,244.86
+5V_MAIN on TOP (solid shape): 199.7,25.82 199.7,25.1 199.28,24.68 198.96,24.68 198.57,24.3 198.57,24.3 197.71,23.44 195.98,23.44 195.47,23.94 195.47,25.01 195.74,25.27 196.47,25.27 197.07,25.87 197.41,25.87 197.87,26.33 199.19,26.33
+5V_MAIN on TOP (solid shape): 71.28,203.91 71.28,195.96 70.65,195.33 70.65,191.64 70.52,191.52 69.5,191.52 69.38,191.64 69.38,195.58 70.26,196.47 70.26,200.53 69.38,201.42 69.38,204.09 68.61,204.85 67.22,204.85 67.09,204.98 67.09,206.12 67.22,206.25 68.94,206.25
+5V_MAIN on TOP (solid shape): 102.91,41.73 102.91,39.86 103.03,39.75 104.11,39.75 104.53,39.33 104.53,37.56 104.12,37.15 100.89,37.15 99.08,35.33 92.84,35.33 91.22,36.96 84.19,36.96 83.68,37.47 83.68,39.96 84.24,40.51 89.97,40.51 90,40.49 92.19,40.49 94.11,38.56 97.03,38.56 97.56,39.09 97.56,39.12 98.46,40.01 98.46,41.78 99.27,42.6 102.04,42.6
+5V_MAIN on TOP (solid shape): 12.61,65.28 12.61,57.15 12.48,57.02 7.27,57.02 7.04,57.25 7.04,62.88 10.85,62.88 10.85,62.81 10.86,62.73 10.88,62.65 10.9,62.58 10.94,62.51 10.98,62.44 11.02,62.38 11.08,62.32 11.14,62.27 11.2,62.22 11.27,62.18 11.34,62.15 11.42,62.13 11.49,62.11 11.57,62.1 11.65,62.1 11.73,62.11 11.8,62.13 11.88,62.15 11.95,62.18 12.02,62.22 12.08,62.27 12.14,62.32 12.2,62.38 12.24,62.44 12.28,62.51 12.32,62.58 12.34,62.65 12.36,62.73 12.37,62.81 12.37,62.88 12.37,62.96 12.35,63.04 12.33,63.12 12.3,63.19 12.26,63.26 12.22,63.32 12.17,63.38 12.11,63.44 12.05,63.49 11.99,63.53 11.92,63.56 11.84,63.59 11.77,63.61 11.69,63.62 11.61,63.63 11.53,63.62 11.45,63.61 11.38,63.59 11.3,63.56 11.23,63.53 11.17,63.49 11.11,63.44 11.05,63.38 11,63.32 10.96,63.26 10.92,63.19 10.89,63.12 10.87,63.04 10.85,62.96 10.85,62.88 7.04,62.88 7.04,65.18 7.27,65.41 12.48,65.41
+5V_MAIN on TOP (solid shape): outline of 164 points within 23.4,163.58 31.15,172.21
+5V_MAIN on BOTTOM (solid shape): 66.41,242.91 66.41,242.25 66.21,242.05 64.53,242.05 64.29,242.29 64.29,242.88 64.5,243.1 66.22,243.1
+5V_MAIN on BOTTOM (solid shape): 76.61,241.55 76.61,241.17 76.23,240.79 75.85,240.79 74.84,241.81 74.84,242.19 75.09,242.44 75.73,242.44
+5V_MAIN on BOTTOM (solid shape): 189.22,232.69 189.22,231.59 188.96,231.33 185.9,231.33 185.81,231.42 185.81,232.66 185.81,232.67 185.83,232.77 185.83,232.87 185.82,232.9 185.94,233.02 188.89,233.02
+5V_MAIN on BOTTOM (solid shape): 202.91,25.29 202.91,23.62 202.17,22.87 199.61,22.87 198.28,24.21 199.68,24.21 199.68,24.15 199.69,24.1 199.71,24.05 199.74,24 199.77,23.95 199.81,23.92 199.86,23.88 199.91,23.86 199.96,23.84 200.02,23.83 200.07,23.83 200.13,23.83 200.18,23.85 200.23,23.87 200.28,23.9 200.32,23.93 200.36,23.98 200.39,24.02 200.42,24.07 200.43,24.13 200.44,24.18 200.44,24.24 200.43,24.29 200.42,24.35 200.39,24.4 200.36,24.44 200.32,24.49 200.28,24.52 200.23,24.55 200.18,24.57 200.13,24.59 200.07,24.59 200.02,24.59 199.96,24.58 199.91,24.56 199.86,24.54 199.81,24.5 199.77,24.47 199.74,24.42 199.71,24.37 199.69,24.32 199.68,24.27 199.68,24.21 198.28,24.21 197.57,24.92 197.57,25.37 197.96,25.77 202.43,25.77
+5V_MAIN on BOTTOM (solid shape): outline of 13796 points within 1.51,26.34 47.02,240.31
+5V_MAIN on L2_VCC: 11.42,82.12 11.16,82.38 11.16,83.1 11.42,83.36 13.2,83.36 19.03,89.2 19.03,98.26 16.62,100.67 16.62,105.49 12.05,110.07 12.05,118.45 9.76,120.73 9.76,121.33 9.9,121.46 10.09,121.46 12.94,118.59 12.94,110.56 17.69,105.81 17.69,100.86 19.85,98.7 19.85,88.75 13.21,82.12
+5V_PS2 on TOP (solid shape): outline of 238 points within 157.96,238.24 164.91,253.03
+5V_SMART_USB on TOP (solid shape): outline of 259 points within 93.26,243.08 117.21,255.02
+5VAUX_BOOT_20 on TOP (solid shape): 41.91,54.89 41.92,54.89 42.03,54.78 42.03,54.38 42.82,53.58 42.82,53.2 43.57,52.44 43.57,52.18 43.51,52.11 43.01,52.11 42.95,52.17 42.95,52.17 42.07,53.05 42.07,53.06 41.48,53.64 40.67,53.64 40.5,53.82 40.5,54.6 41.09,55.19 41.6,55.19
+5VAUX_LG_25 on TOP (solid shape): 36.51,53.99 36.51,53.19 36.25,52.93 35.37,52.93 35.3,52.99 35.3,54.03 35.35,54.08 36.42,54.08
+5VAUX_LG_25 on TOP (solid shape): 44.92,53.75 44.92,53.01 44.86,52.95 44.71,52.95 44.59,53.07 44.59,53.57 44.39,53.77 43.29,53.77 43.15,53.91 43.15,54.31 43.24,54.39 44.29,54.39
+5VAUX_LG_25 on BOTTOM (solid shape): 44.48,54.22 44.48,53.89 44.2,53.6 42.78,53.6 42.46,53.72 42.13,53.61 42.12,53.6 42.06,53.6 41.75,53.3 39.09,53.3 38.76,52.96 36.28,52.96 36.25,52.93 35.37,52.93 35.3,52.99 35.3,54.03 35.38,54.1 38.29,54.1 38.29,54.1 38.65,54.45 44.25,54.45
+5VAUX_PHASE_25 on TOP (solid shape): 42.86,51.97 43.46,51.97 43.47,51.95 43.47,51.66 43.34,51.53 42.52,51.53 42.19,51.86 41.72,51.86 41.13,52.45 41.01,52.45 40.93,52.54 40.77,52.54 40.63,52.68 40.63,53.27 40.79,53.43 41.39,53.43
+5VAUX_PHASE_25 on TOP (solid shape): 32.7,53.97 34.34,53.97 34.7,53.62 34.7,48.92 35.36,48.26 35.87,48.26 36.1,48.03 36.1,46.71 35.87,46.48 31.51,46.48 31.28,46.71 31.28,47.6 30.75,48.13 29.65,48.13 28.12,46.61 24.65,46.61 24.29,46.96 24.29,56.03 24.77,56.51 30.16,56.51
+5VAUX_PHASE_25 on BOTTOM (solid shape): 29.99,56.41 32.09,54.31 32.93,54.31 34.07,53.17 34.07,49.57 32.59,48.1 29.69,48.1 28.23,46.64 24.68,46.64 24.36,46.95 24.36,55.99 24.81,56.44 29.99,56.44
+5VAUX_PHASE_25 on BOTTOM (solid shape): 42,52.98 42.12,52.83 42.29,52.73 42.5,52.52 42.5,52.08 42.15,51.74 41.23,51.74 40.33,50.84 40.33,50.83 37.12,47.63 34.43,47.63 34.22,47.84 34.22,48.25 34.75,48.78 36.53,48.78 38.26,50.51 38.26,50.55 40.7,52.98
+5VAUX_PHASE_25 on L2_VCC: 31.31,46.48 31.22,46.57 31.22,47.58 30.72,48.08 29.67,48.08 28.19,46.61 24.65,46.61 24.29,46.97 24.29,56.03 24.78,56.51 30.15,56.51 32.31,54.36 34.47,54.36 34.7,54.12 34.7,49.04 35.23,48.51 35.87,48.51 36.15,48.23 36.15,46.95 35.69,46.48
+5VAUX_PHASE_R on TOP (solid shape): 39.48,48.91 39.48,48.67 38.95,48.14 38.95,47.93 38.62,47.59 36.57,47.59 36.5,47.67 36.5,48.3 36.91,48.71 38.46,48.71 38.74,48.99 38.74,49 38.8,49.05 39.34,49.05
+5VAUX_UG_25 on TOP (solid shape): 40.47,47.6 40.47,46.06 40.2,45.79 39.61,45.79 39.35,46.05 39.35,47.68 39.48,47.81 40.27,47.81
+5VAUX_UG_25 on TOP (solid shape): 44.36,53.31 44.36,52.83 44.5,52.69 44.5,52.59 44.43,52.51 43.77,52.51 43.34,52.95 43.34,53.35 43.51,53.52 44.15,53.52
+5VAUX_UG_25 on BOTTOM (solid shape): 44.45,53.41 44.45,51.98 44.45,51.98 44.45,51.02 42.84,49.42 42.18,49.42 40.67,47.9 40.67,47.41 40.34,47.08 39.55,47.08 39.23,47.4 39.23,47.74 41.86,50.37 42.55,50.37 43.12,50.93 43.12,53.3 43.29,53.47 44.39,53.47
+5VAUX_UGR_25 on TOP (solid shape): 30.79,47.27 30.79,46.62 30.5,46.32 29.7,46.32 29.56,46.46 29.56,47.38 29.7,47.52 30.54,47.52
+5VAUX_UGR_25 on TOP (solid shape): 38.96,46.9 38.96,46.17 38.59,45.8 36.58,45.8 36.4,45.98 36.4,46.47 36.48,46.54 36.48,47.03 36.67,47.22 38.63,47.22
+5VAUX_UGR_25 on BOTTOM (solid shape): 31.06,47.06 31.33,46.8 38.52,46.8 38.79,46.53 38.79,46.21 38.52,45.94 30.08,45.94 29.56,46.46 29.56,47.38 29.7,47.52 30.6,47.52
+12V_CPU on TOP (solid shape): outline of 302 points within 218.98,203.13 231.15,217.17
+12V_CPU on BOTTOM (solid shape): outline of 303 points within 218.98,203.15 231.15,217.3
+12V_CPU on L2_VCC: 222.77,203.07 222.16,203.69 222.16,211.43 220.86,212.72 218.96,212.72 218.6,213.08 218.6,216.81 219.21,217.42 222.56,217.42 231.17,208.81 231.17,203.43 230.81,203.07
+12V_CPU_VIN on TOP (solid shape): outline of 85 points within 146.08,192.15 150.85,207.39
+12V_CPU_VIN on TOP (solid shape): outline of 642 points within 162.21,141.73 236.89,220.34
+12V_CPU_VIN on BOTTOM (solid shape): 233.56,153.64 233.56,147.09 233.28,146.81 226.6,146.81 226.09,147.32 226.09,152.65 227.36,153.92 233.28,153.92
+12V_CPU_VIN on BOTTOM (solid shape): 232.39,169.72 232.39,163.91 232.29,163.81 229.84,163.81 229.77,163.88 226.68,163.88 225.97,164.6 225.97,169.23 226.78,170.05 232.06,170.05
+12V_CPU_VIN on BOTTOM (solid shape): outline of 1387 points within 145.83,192.15 218.47,220.17
+12V_CPU_VIN on L2_VCC: 146.67,192.09 146.15,192.61 146.15,197.41 146.42,197.68 146.92,197.68 147.42,198.17 147.42,198.96 146.53,199.85 146.53,206.02 146.54,206.04 146.54,206.56 147.31,207.33 150.49,207.33 150.55,207.26 150.85,207.26 150.85,202.14 150.08,201.37 150.08,199.85 149.88,199.64 148.9,199.64 148.37,199.11 148.37,192.89 147.57,192.09
+12V_CPU_VIN on L2_VCC: outline of 93 points within 161.2,146.69 236.89,220.34
+12V_DUAL on TOP (solid shape): 73.46,76.8 73.46,74.37 73.32,74.23 71.16,74.23 70.93,74.46 70.93,76.44 71.32,76.83 73.44,76.83
+12V_DUAL on TOP (solid shape): 113.7,74.52 113.7,72.63 113.48,72.42 111.08,72.42 110.7,72.8 110.7,74.4 111.06,74.75 113.47,74.75
+12V_DUAL on TOP (solid shape): 63.53,43.36 63.53,42.75 63.55,42.73 62.71,41.89 60.91,40.09 60.1,40.09 59.89,40.29 59.89,43.33 60.12,43.56 63.33,43.56
+12V_DUAL on TOP (solid shape): outline of 85 points within 54.26,29.46 66.75,35.54
+12V_DUAL on TOP (solid shape): outline of 242 points within 153.83,28.73 165.7,65.27
+12V_DUAL on BOTTOM (solid shape): outline of 210 points within 147.99,61.95 163.61,65.28
+12V_DUAL on BOTTOM (solid shape): outline of 985 points within 54.73,24.69 159.88,48.7
+12V_DUAL on L2_VCC: 74.05,48.01 73.69,48.37 73.69,58.53 71.03,61.19 71.03,76.35 71.39,76.71 74.98,76.71 75.73,75.97 75.73,73.77 74.71,72.75 74.71,63.14 78.52,59.33 78.52,48.24 78.29,48.01
+12V_DUAL on L2_VCC: 59.96,39.88 59.85,39.98 59.85,43.33 60.08,43.56 63.3,43.56 63.53,43.33 63.53,42.65 60.76,39.88
+12V_DUAL on L2_VCC: 161.94,62.23 161.7,62.46 161.7,64.66 162.32,65.28 165.41,65.28 165.9,64.79 165.9,62.72 165.41,62.23
+12V_DUAL on L2_VCC: 146.06,62.23 145.19,63.1 145.19,69.83 143.52,71.5 137.81,71.5 137.17,72.14 111.14,72.14 110.65,72.62 110.65,74.44 112.15,75.95 138.48,75.95 138.72,75.71 138.72,74.7 139.37,74.04 146.1,74.04 149.77,70.38 149.77,62.59 149.41,62.23
+12V_DUAL_3V5V_VIN on TOP (solid shape): outline of 119 points within 27.82,39.88 59.34,45.99
+12V_DUAL_3V5V_VIN on BOTTOM (solid shape): 57.08,43.96 57.08,40.8 56.72,40.43 49.34,40.43 49.16,40.61 49.16,41.96 49.97,42.77 51.64,42.77 53.41,44.53 56.51,44.53
+12V_DUAL_3V5V_VIN on BOTTOM (solid shape): outline of 161 points within 28.03,40.13 43.04,45.29
+12V_DUAL_3V5V_VIN on L2_VCC: 41.67,39.12 40.91,39.88 28.33,39.88 27.85,40.36 27.85,43.58 30.24,45.97 36.12,45.97 37.14,44.96 40.69,44.96 41.2,44.45 49.8,44.45 50.3,44.96 57.2,44.96 57.44,44.73 57.44,44.09 57.97,43.56 59.11,43.56 59.34,43.33 59.34,39.98 59.24,39.88 43.29,39.88 42.52,39.12
+12V_MAIN on TOP (solid shape): 198.66,223.9 198.66,221.23 198.53,221.11 195.97,221.11 195.78,221.3 195.78,223.69 196.12,224.03 198.53,224.03
+12V_MAIN on TOP (solid shape): 215.93,234.28 215.93,233.17 215.81,233.04 211.74,233.04 211.23,233.55 211.23,234.26 211.45,234.48 215.73,234.48
+12V_MAIN on TOP (solid shape): 231.86,132.28 231.86,130.61 231.81,130.56 230.54,130.56 230.28,130.3 229.27,130.3 229.14,130.43 229.14,132.08 229.65,132.59 231.55,132.59
+12V_MAIN on TOP (solid shape): 185.07,236.6 185.07,231.65 185.58,231.14 185.58,224.28 184.82,223.52 183.68,223.52 183.55,223.65 183.55,230.12 182.53,231.14 182.53,233.96 182.61,234.04 182.61,234.29 182.53,234.37 182.53,236.6 182.66,236.73 184.95,236.73
+12V_MAIN on TOP (solid shape): outline of 89 points within 75.6,221.95 95.6,239.27
+12V_MAIN on TOP (solid shape): outline of 368 points within 47.79,235.2 74.15,246.2
+12V_MAIN on TOP (solid shape): outline of 464 points within 15.91,33.91 106.57,48.51
+12V_MAIN on TOP (solid shape): outline of 546 points within 5.11,213.49 43.52,245.86
+12V_MAIN on BOTTOM (solid shape): 185.99,235.03 185.99,234.4 185.4,233.81 184.54,233.81 184.33,234.02 184.33,235.18 184.64,235.48 185.54,235.48
+12V_MAIN on BOTTOM (solid shape): 229.78,133.99 229.78,130.3 229.65,130.18 228.89,130.18 228.76,130.3 228.76,133.99 228.89,134.11 229.65,134.11
+12V_MAIN on BOTTOM (solid shape): 97.82,220.73 97.82,220.47 97.59,220.24 97.59,220.22 96.73,219.35 96.32,219.35 93.33,222.35 93.33,223.14 94.09,223.9 94.65,223.9
+12V_MAIN on BOTTOM (solid shape): 212.63,233.24 212.63,232.64 212.4,232.41 211.85,232.41 211.85,232.46 211.53,233.03 210.89,233.15 210.86,233.14 210.57,233.43 209.65,233.43 209.52,233.55 209.52,234.57 209.6,234.64 211.22,234.64
+12V_MAIN on BOTTOM (solid shape): outline of 125 points within 178.21,221.11 221.75,225.17
+12V_MAIN on BOTTOM (solid shape): outline of 125 points within 4.86,210.69 15.53,235.97
+12V_MAIN on L2_VCC: outline of 142 points within 1.52,26.35 106.59,247.4 ; 1 cut-out
+12V_SB on TOP (solid shape): 51.91,56.34 51.91,54.72 51.79,54.6 50.45,54.6 49.88,55.18 49.88,56.31 50.02,56.45 51.81,56.45
+12V_SB on TOP (solid shape): 7.02,70.78 7.02,68.33 7.4,67.94 7.4,67.44 6.89,66.93 6.26,66.93 6.13,67.06 6.13,70.72 6.31,70.91 6.89,70.91
+12V_SB on TOP (solid shape): 35.49,58.3 35.49,57.58 35.05,57.15 32.84,57.15 32.51,57.49 32.51,58.49 32.86,58.84 34.94,58.84
+12V_SB on TOP (solid shape): 54.01,33.05 54.01,29.57 53.91,29.46 49.41,29.46 49.03,29.46 48.39,30.1 48.39,32.05 48.57,32.23 50.8,32.23 50.95,32.08 52.11,32.08 52.12,32.09 52.75,32.09 53.09,32.43 53.09,32.99 53.3,33.2 53.86,33.2
+12V_SB on TOP (solid shape): outline of 118 points within 27.54,27.71 45.2,34.63
+12V_SB on BOTTOM (solid shape): 34.23,57.61 34.23,57.36 33.51,56.64 32.91,56.64 32.07,57.47 32.07,58.21 32.58,58.72 33.13,58.72
+12V_SB on BOTTOM (solid shape): outline of 232 points within 40.81,29.35 54.26,36.07
+VCCGT on TOP (solid shape): outline of 2722 points within 171.86,142.62 217.58,176.78
+VCCGT on BOTTOM (solid shape): outline of 2453 points within 172.7,142.11 216.57,173.35
+VCCIO on TOP (solid shape): 159.67,142.37 159.67,141.35 157.89,139.57 157.89,139.56 157.75,139.42 157.75,138.56 158.23,138.08 158.25,138.04 158.28,138.01 158.28,137.8 158.08,137.6 158.01,137.57 157.93,137.6 157.74,137.72 157.51,137.7 156.91,138.3 156.91,140.07 157.92,141.07 157.92,141.1 158.4,141.58 158.4,142.37 158.53,142.49 159.55,142.49
+VCCIO on TOP (solid shape): 173.52,142.11 173.52,141.49 171.65,139.63 170.82,139.63 170.73,139.65 170.65,139.65 170.35,139.56 170.21,139.29 170.18,139.22 170.11,139.19 169.99,139.19 169.8,139 169.8,139 169.67,138.63 169.97,138.38 170.1,138.38 170.23,138.25 170.23,137.69 170.17,137.64 170.13,137.59 169.75,137.59 169.39,137.96 169.38,137.96 169.32,138.05 169.24,138.11 169.23,138.11 169.03,138.32 169.03,138.33 168.98,138.46 168.9,138.56 168.7,138.76 168.7,139.73 169.31,140.35 170.22,140.35 171.23,141.35 172.25,141.35 172.5,141.6 172.5,142.24 172.63,142.37 173.26,142.37
+VCCIO on TOP (solid shape): outline of 100 points within 114.08,142.37 122.3,151.81
+VCCIO on TOP (solid shape): outline of 87 points within 152.95,148.47 162.97,155.42
+VCCIO on BOTTOM (solid shape): 172.6,142.54 172.6,140.84 171.41,139.65 170.04,139.65 169.86,139.83 169.86,140.13 170.09,140.36 170.57,140.36 171.1,140.89 171.1,142.37 171.36,142.62 172.52,142.62
+VCCIO on BOTTOM (solid shape): outline of 774 points within 153.88,139.03 160.28,154.07
+VCCIO on L2_VCC: outline of 87 points within 113.7,127.66 172.85,156.31 ; 6 cut-outs
+VCCSA on TOP (solid shape): outline of 278 points within 141.89,177.04 154.85,186.94
+VCCSA on TOP (solid shape): outline of 275 points within 151.05,144.53 163.05,154.56
+VCCSA on BOTTOM (solid shape): outline of 223 points within 142.43,177.09 155.68,187.07
+VCCSA on L2_VCC: outline of 100 points within 120.2,144.81 156.34,187.07 ; 13 cut-outs
+VCCSA_PHASE_25 on TOP (solid shape): 152.15,199.67 152.15,199.4 151.59,198.84 151.59,198.69 151.52,198.62 151.52,194.08 151.73,193.87 151.73,192.72 151.93,192.53 151.93,192.53 152.4,192.06 153.73,192.06 154.54,191.25 154.54,188.54 154.34,188.34 148.12,188.34 147.99,188.47 147.99,191.77 148.88,192.66 148.88,198.88 149.09,199.1 151.12,199.1 151.8,199.78 152.05,199.78
+VCCSA_PHASE_25 on L2_VCC: 148.35,187.58 147.99,187.94 147.99,191.79 148.88,192.68 148.88,198.9 149.11,199.14 151.14,199.14 151.78,199.77 152.07,199.77 152.31,199.54 152.31,199.24 151.54,198.48 151.54,194.08 151.8,193.82 151.8,192.81 152.58,192.02 154.49,192.02 154.72,191.79 154.72,188.07 154.23,187.58
+VCCSA_VCC_20 on TOP (solid shape): 145.96,202.41 145.96,201.63 145.69,201.36 145.36,201.36 145.12,201.12 143.01,201.12 142.02,200.13 142.02,199.44 141.94,199.36 141.82,199.36 141.77,199.42 141.77,200.3 141.87,200.41 141.87,200.71 142.11,200.95 142.12,200.95 142.9,201.73 142.9,201.74 143.42,202.26 145.35,202.26 145.63,202.54 145.83,202.54
+VDDQ on TOP (solid shape): 113.69,146.91 113.69,142.51 112.91,141.73 107.86,141.73 106.71,142.88 106.21,142.88 106.08,143 106.08,146.05 106.21,146.18 107.86,146.18 109.05,147.37 113.23,147.37
+VDDQ on TOP (solid shape): outline of 2140 points within 86.24,47.65 190.91,85.35
+VDDQ on BOTTOM (solid shape): outline of 407 points within 160.43,66.93 190.66,75.07
+VDDQ on L2_VCC: outline of 298 points within 81.82,47.62 219.68,147.07
-12V on TOP (solid shape): 178.04,225.73 178.04,225.2 178.09,225.15 178.09,223.27 177.96,223.14 174.53,223.14 174.4,223.27 174.4,225.68 174.53,225.81 177.96,225.81
-12V on TOP (solid shape): 15.78,239.52 15.78,238 14.77,236.98 14.77,236.09 14.13,235.46 13.5,235.46 13.37,235.59 13.37,236.47 13.11,236.73 9.69,236.73 5.24,232.28 4.99,232.28 4.73,232.03 4.73,225.93 4.99,225.68 5.37,225.68 5.49,225.55 5.49,224.66 5.75,224.41 6.51,224.41 6.64,224.28 6.64,221.87 5.11,220.34 4.61,220.34 4.48,220.47 4.48,224.16 3.72,224.92 3.72,232.66 9.56,238.51 11.56,238.51 12.35,237.72 12.66,237.72 12.96,238.02 13.51,238.02 14.13,238.63 14.64,238.63 14.89,238.89 14.89,239.52 15.02,239.65 15.65,239.65
-12V on BOTTOM (solid shape): 175.8,223.77 175.8,223.14 175.67,223.01 175.04,223.01 174.02,222 173.77,222 173.39,222.38 173.39,222.63 174.66,223.9 175.67,223.9
-12V on BOTTOM (solid shape): outline of 434 points within 9.05,236.22 27.59,247.27
-12V_COMP on TOP (solid shape): 6.76,219.96 6.76,217.3 6.64,217.17 5.62,217.17 5.49,217.3 5.49,218.06 5.24,218.31 4.61,218.31 4.48,218.44 4.48,219.96 4.61,220.09 6.64,220.09
-12V_SWC on TOP (solid shape): 10.96,224.41 10.96,216.53 10.19,215.77 9.18,215.77 9.05,215.9 9.05,216.79 8.54,217.3 8.54,219.2 8.67,219.33 9.56,219.33 9.81,219.58 9.81,224.41 9.94,224.54 10.83,224.54
-12V_SWE on TOP (solid shape): 9.86,233.38 9.86,232.36 10.12,232.11 11.13,232.11 11.51,231.72 11.51,225.86 11.23,225.58 9.96,225.58 9.35,224.97 9.35,222.43 9.23,222.3 8.62,222.3 8.49,222.43 8.49,225.48 9.13,226.11 9.13,231.44 8.11,232.46 8.11,233.86 8.24,233.98 9.25,233.98
-12V_TCAP on TOP (solid shape): 8.08,224.92 8.08,221.64 7.96,221.51 7.12,221.51 7.02,221.62 7.02,224.41 6.64,224.79 5.88,224.79 5.75,224.92 5.75,225.55 5.88,225.68 7.32,225.68
AVCC33 on TOP (solid shape): 146.48,232.27 146.48,229.74 147.28,228.95 147.9,228.95 148.62,228.22 149.4,228.22 149.78,227.84 149.78,227.08 148.34,227.08 147.39,228.03 146.67,228.03 146.39,228.31 146.39,228.4 146.16,228.63 145.85,228.63 145.82,228.6 145.35,228.6 145.17,228.78 145.17,229.53 144.84,229.86 144.84,229.87 144.31,230.4 144.31,232.28 144.43,232.41 146.34,232.41
AVDD2 on TOP (solid shape): 195.09,22.37 195.09,20.53 195.04,20.48 194.51,20.48 193.87,19.84 192.81,19.84 192.67,19.97 192.67,20.65 192.32,21.01 191.35,21.01 190.56,21.8 190.56,22.08 191.55,22.08 191.55,22.02 191.56,21.97 191.57,21.92 191.59,21.87 191.62,21.82 191.66,21.78 191.7,21.75 191.74,21.72 191.79,21.69 191.82,21.69 191.84,21.67 192.08,21.67 192.98,21.67 193.2,21.89 193.2,22.21 192.98,22.43 192.08,22.43 191.84,22.43 191.82,22.42 191.79,22.41 191.74,22.39 191.7,22.36 191.66,22.32 191.62,22.28 191.59,22.23 191.57,22.18 191.56,22.13 191.55,22.08 190.56,22.08 190.56,22.29 190.43,22.42 190.43,22.79 190.52,22.89 194.57,22.89
GND on TOP (solid shape): 23.33,154.87 20.67,154.87 20.67,157.55 23.33,157.55
GND on TOP (solid shape): 36.33,92.62 32.85,92.62 32.85,96.12 36.33,96.12
GND on TOP (solid shape): 112.01,225.84 109.27,225.84 109.27,228.57 112.01,228.57
GND on TOP (solid shape): 153.16,223.2 149.7,223.2 149.7,226.66 153.16,226.66
GND on TOP (solid shape): 224.61,188.69 220.05,188.69 220.05,193.27 224.61,193.27
GND on TOP (solid shape): 7.4,231.9 7.4,226.06 7.27,225.93 4.99,225.93 4.86,226.06 4.86,231.9 4.99,232.03 7.27,232.03
GND on TOP (solid shape): 7.65,213.74 7.65,211.96 7.53,211.84 5.62,211.84 5.49,211.96 5.49,213.74 5.62,213.87 7.53,213.87
GND on TOP (solid shape): 8.8,56.64 8.8,54.99 8.42,54.61 7.27,54.61 7.15,54.74 7.15,56.64 7.27,56.77 8.67,56.77
GND on TOP (solid shape): 13.75,48.26 13.75,46.86 13.62,46.74 11.97,46.74 11.84,46.86 11.84,48.26 11.97,48.39 13.62,48.39
GND on TOP (solid shape): 45.37,108.97 45.37,107.57 45.25,107.44 41.44,107.44 41.05,107.82 41.05,108.84 41.44,109.22 45.12,109.22
GND on TOP (solid shape): 46.39,52.45 46.39,51.18 46.26,51.05 44.99,51.05 44.8,51.25 44.8,52.46 44.92,52.58 46.26,52.58
GND on TOP (solid shape): 50.58,194.11 50.58,192.02 50.2,191.64 49.44,191.64 49.21,191.87 49.21,193.5 49.92,194.21 50.48,194.21
GND on TOP (solid shape): 67.97,110.9 67.97,107.62 67.7,107.35 66.67,107.35 66.39,107.62 66.39,110.76 66.75,111.12 67.74,111.12
GND on TOP (solid shape): 133.8,8.24 133.8,8.02 133.6,7.82 130.97,7.82 130.9,7.89 130.9,8.41 130.98,8.5 133.55,8.5
GND on TOP (solid shape): 154.85,197.61 154.85,194.18 154.72,194.06 152.05,194.06 151.93,194.18 151.93,197.61 152.05,197.74 154.72,197.74
GND on TOP (solid shape): 154.85,179.07 154.85,177.16 154.72,177.04 153.58,177.04 153.45,177.16 153.45,179.07 153.58,179.2 154.72,179.2
GND on TOP (solid shape): 155.1,71.62 155.1,68.06 154.98,67.95 152.67,67.95 152.56,68.06 152.56,71.57 152.88,71.89 154.83,71.89
GND on TOP (solid shape): 162.86,148.77 162.86,147.89 162.61,147.64 156.53,147.64 156.09,148.09 156.09,148.77 156.5,149.18 162.44,149.18
GND on TOP (solid shape): 164.87,147.17 164.87,144.93 164.57,144.62 163.92,144.62 163.6,144.94 163.6,147.15 163.91,147.46 164.58,147.46
GND on TOP (solid shape): 166.91,150.59 166.91,150.15 166.6,149.85 163.91,149.85 163.62,150.14 163.62,150.6 163.91,150.88 166.61,150.88
GND on TOP (solid shape): 166.91,147.18 166.91,144.94 166.6,144.63 165.96,144.63 165.64,144.95 165.64,147.16 165.95,147.47 166.62,147.47
GND on TOP (solid shape): 168.95,147.18 168.95,144.94 168.64,144.63 167.99,144.63 167.67,144.95 167.67,147.16 167.98,147.47 168.65,147.47
GND on TOP (solid shape): 170.96,150.59 170.96,150.16 170.66,149.85 167.97,149.85 167.68,150.14 167.68,150.6 167.97,150.88 170.67,150.88
GND on TOP (solid shape): 170.98,147.18 170.98,144.94 170.67,144.63 170.03,144.63 169.7,144.95 169.7,147.16 170.01,147.47 170.68,147.47
GND on TOP (solid shape): 171.61,216.41 171.61,214.63 171.48,214.5 167.8,214.5 167.67,214.63 167.67,216.41 167.8,216.53 171.48,216.53
GND on TOP (solid shape): 175.41,150.59 175.41,150.16 175.11,149.85 172.42,149.85 172.13,150.14 172.13,150.6 172.41,150.88 175.12,150.88
GND on TOP (solid shape): 175.41,147.16 175.41,146.73 175.11,146.42 172.42,146.42 172.13,146.71 172.13,147.17 172.41,147.45 175.12,147.45
GND on TOP (solid shape): 175.41,143.61 175.41,143.17 175.11,142.87 172.42,142.87 172.13,143.16 172.13,143.62 172.41,143.9 175.12,143.9
GND on TOP (solid shape): 178.35,75.19 178.35,74.87 177.91,74.43 176.32,74.43 176.03,74.72 176.03,75.41 176.33,75.71 177.82,75.71
GND on TOP (solid shape): 185.07,216.53 185.07,214.76 184.95,214.63 181.26,214.63 181.14,214.76 181.14,216.53 181.26,216.66 184.95,216.66
GND on TOP (solid shape): 187.68,26.07 187.68,21.71 187.66,21.69 183.5,21.69 183.29,21.9 183.29,26.09 183.32,26.11 187.64,26.11
GND on TOP (solid shape): 199.12,216.89 199.12,215.11 198.99,214.99 195.31,214.99 195.18,215.11 195.18,216.89 195.31,217.02 198.99,217.02
GND on TOP (solid shape): 205.9,167.89 205.9,166.75 205.77,166.62 203.61,166.62 203.49,166.75 203.49,167.89 203.61,168.02 205.77,168.02
GND on TOP (solid shape): 205.9,161.04 205.9,159.89 205.77,159.77 203.61,159.77 203.49,159.89 203.49,161.04 203.61,161.16 205.77,161.16
GND on TOP (solid shape): 206.03,154.18 206.03,153.03 205.9,152.91 203.74,152.91 203.61,153.03 203.61,154.18 203.74,154.31 205.9,154.31
GND on TOP (solid shape): 206.03,147.07 206.03,145.92 205.9,145.8 203.74,145.8 203.61,145.92 203.61,147.07 203.74,147.19 205.9,147.19
GND on TOP (solid shape): 233.21,154.94 233.21,153.42 232.82,153.03 231.55,153.03 231.17,153.42 231.17,154.94 231.3,155.07 233.08,155.07
GND on TOP (solid shape): 233.21,145.8 233.21,144.27 232.82,143.89 231.55,143.89 231.17,144.27 231.17,145.8 231.3,145.92 233.08,145.92
GND on TOP (solid shape): 143,199 143.29,199 143.29,197.49 143.16,197.36 139.61,197.36 139.48,197.49 139.48,199.01 139.61,199.14 142.86,199.14
GND on TOP (solid shape): 176.89,229.32 176.94,229.27 176.94,226.48 176.78,226.32 175.91,226.32 175.17,227.06 175.17,229.2 175.34,229.37 176.89,229.37
GND on TOP (solid shape): 20.75,65.91 20.75,65.49 21.44,64.8 21.44,64.33 21.34,64.23 20.73,64.23 19.44,65.51 19.44,65.77 19.7,66.04 20.63,66.04
GND on TOP (solid shape): 37.22,44.91 37.22,43.73 36.91,43.42 35.75,43.42 35.48,43.7 35.48,44.92 35.78,45.22 36.91,45.22
GND on TOP (solid shape): 38.9,50.78 38.9,49.57 38.35,49.03 35.46,49.03 35.29,49.19 35.29,52.34 35.4,52.44 37.23,52.44
GND on TOP (solid shape): 51.7,44.91 51.7,43.73 51.39,43.42 50.23,43.42 49.95,43.7 49.95,44.92 50.26,45.22 51.38,45.22
GND on TOP (solid shape): 60.98,56.94 60.98,55.49 61.13,55.33 61.13,54.97 60.83,54.67 60.41,54.67 58.94,56.13 58.94,57.26 59.11,57.43 60.49,57.43
GND on TOP (solid shape): 63.33,35.42 63.33,35.3 62.66,34.62 60.53,34.62 60.28,34.37 59.56,34.37 59.25,34.68 59.25,35.25 59.56,35.57 63.19,35.57
GND on TOP (solid shape): 168.83,142.27 168.83,141.8 168.48,141.45 166.55,141.45 166.23,141.77 166.23,142.23 166.42,142.41 168.69,142.41
GND on TOP (solid shape): 205.01,224.54 205.01,222 204.88,221.87 203.49,221.87 203.36,222 203.36,224.92 203.49,225.04 204.5,225.04
GND on TOP (solid shape): 233.08,172.36 233.08,170.43 232.95,170.31 231.17,170.31 231.05,170.43 231.05,172.47 231.15,172.57 232.87,172.57
GND on TOP (solid shape): 233.21,163.32 233.21,161.8 232.82,161.42 231.55,161.42 231.17,161.8 231.17,162.28 230.69,162.76 230.69,163.3 230.84,163.45 233.08,163.45
GND on TOP (solid shape): 53.5,187.96 53.5,187.68 53.7,187.48 54.01,187.48 54.14,187.35 54.14,186.97 52.97,185.8 52.36,185.8 52.23,185.93 52.23,188.21 52.41,188.39 53.07,188.39
GND on TOP (solid shape): 90.48,230.86 90.48,230.37 90.35,230.23 90.07,230.23 89.61,230.7 88.45,230.7 88.35,230.81 88.35,231.03 88.88,231.57 89.76,231.57
GND on TOP (solid shape): 101.7,76.07 105.85,76.07 106.76,75.16 107.65,75.16 107.73,75.08 107.73,74.47 107.45,74.19 101.25,74.19 100.87,74.57 100.87,75.82 101.25,76.2 101.58,76.2
GND on TOP (solid shape): 191.8,212.34 191.8,208.28 191.68,208.15 190.91,208.15 190.79,208.28 190.79,210.69 190.53,210.95 190.03,210.95 189.9,211.07 189.9,211.58 190.79,212.47 191.68,212.47
GND on TOP (solid shape): 199.34,27.84 199.34,27.27 199.03,26.96 198.23,26.96 197.37,26.09 196.89,26.09 196.23,25.43 195.78,25.43 195.4,25.81 195.4,28.38 195.57,28.54 198.63,28.54
