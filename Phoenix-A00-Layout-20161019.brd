# Allegro board Phoenix-A00-Layout-20161019.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+3P3V_SB_CS: length 2.3
  TOP w0.203: 46.43,49.95 PU16.5
  TOP w0.254: 46.43,49.95 46.52,49.86 46.52,49.28 v1(46.77,49.02) 47.59,49.02 PR274.1
+3P3V_SB_FB: length 8.7
  TOP w0.102: PR268.1 48.72,46.47 48.72,45.54 49.06,45.21 v1(49.44,45.21)
  TOP w0.203: 46.03,49.89 PU16.4
  TOP w0.254: PR268.1 PR267.1 PR265.2 PC334.2 46.52,47.88 46.03,48.37 46.03,49.89
+3P3V_SB_FB_R: length 44.5
  TOP w0.254: PJP31.2 66.96,57.15 68.23,55.88 v1(68.23,52.32) ; PC334.1 PR265.1 v1(47.4,45.31)
  BOTTOM w0.254: v1(68.23,52.32) 68.99,51.56 68.99,50.31 67.71,49.02 67.71,46.21 66.58,45.09 59.22,45.09 58.71,44.58 58.71,41.02 57.31,39.62 48.67,39.62 47.66,40.64 47.66,45.06 v1(47.4,45.31)
+3P3V_SB_LG_25:
  vias: v1(47.02,54.1) v1(47.66,54.1) v1(53.39,53.8) v1(53.39,53.17) v2(51.98,54.1)
+3P3V_SB_PHASE_25: length 1.2
  TOP w0.203: PU16.8 48.29,51.82
  vias: v1(49.79,51.56) v1(49.84,52.65) v1(54.39,51.56) v1(54.39,50.16) v1(54.39,48.51) v1(54.64,46.99) v1(55.28,46.99) v1(56.04,51.56) v1(56.04,50.14) v1(56.04,48.51) v1(57.69,51.56) v1(57.69,50.04) v1(57.69,48.51) v1(60.36,46.48) v1(61.37,48.13) v1(61.37,47.24) v1(61.37,46.35) v1(62.14,48.77) v1(63.03,48.77) v1(63.91,48.77)
+3P3V_SB_PHASE_R:
  vias: v1(58.82,53.42)
+3P3V_SB_UG25:
  vias: v1(47.02,53.21) v1(47.66,53.21) v1(51.98,48.26) v1(51.98,47.5) v2(50.45,47.75)
+3P3V_SB_UGR_25:
  vias: v1(52.1,46.43)
+5V/3P3V_VIN: length 1.2
  TOP w0.203: 46.03,54.57 PU16.12
  vias: v1(46.39,54.86)
+DDR_PGOOD: length 235.5
  TOP w0.102: v1(102.14,135.76) 102.14,134.95 101.46,134.26 97.43,134.26 97.33,134.16 93.17,134.16 92.03,133.02 92.03,130.83 92.91,129.95 92.91,127.75 93,127.66 93,122.65 93.38,122.27 93.38,117.63 v1(93.99,117.02) ; v1(214.18,69.72) 214.66,69.24 PR43.2 PC35.1 PU2.1 ; v1(104.48,135.51) 104.86,135.13 105.32,135.13 106,135.81 107.18,135.81 108.14,136.78 112.73,136.78 114.36,138.4 115.12,138.4 117.43,140.72 118.46,140.72 R6296.2
  BOTTOM w0.102: v1(104.48,135.51) 102.4,135.51 v1(102.14,135.76) ; v1(214.18,69.72) 214.05,69.6 210.86,69.6 209.48,68.21 208.73,68.21 207.3,66.78 207.3,65.51 203.56,61.77 195.94,61.77 194.72,62.99 191.27,62.99 182.38,62.99 178.66,66.72 160.52,66.72 159.34,67.89 155.94,67.89 155.63,67.59 152.97,67.59 152.92,67.64 151.49,67.64 151.16,67.31 151.16,66.88 150.93,66.65 150.32,66.65 148.7,68.28 148.7,69.29 148.88,69.47 148.88,70.89 147.45,72.31 132.89,72.31 130.83,70.26 129.88,70.26 124.47,75.67 111.68,75.67 110.76,74.75 107.78,74.75 107.09,74.07 102.1,74.07 99.58,76.58 97.01,76.58 96.58,77.02 96.58,82.19 98.23,83.85 98.23,86.79 97.44,87.58 97.44,88.47 98.23,89.26 98.23,90.63 98.84,91.24 98.84,92.82 102.52,96.5 102.52,98.96 102.09,99.39 102.09,99.39 101.84,99.64 101.84,101.35 102.09,101.6 102.09,102.11 101.63,102.56 101.63,103.31 102.4,104.07 102.4,105.33 101.89,105.84 101.89,112.1 100.03,113.95 100.03,115.32 98.72,116.62 v2(98.72,116.64) 98.5,116.87 94.14,116.87 v1(93.99,117.02)
+VCORE: length 106.1
  TOP w0.203: v1(202.21,201.31) 201.94,201.04 199.42,201.04 v1(199.09,200.71)
  TOP w0.254: v1(183.17,192.66) v1(181.32,192.66)
  TOP w0.508: PR150.1 211.27,188.5 v1(211.27,189.17)
  TOP w0.889: PCE17.1 172.21,179.32 ; PCE17.1 174.09,179.32 ; PCE17.1 173.15,178.38 ; PCE17.1 173.15,180.26 ; PCE18.1 168.07,184.84 ; PCE18.1 167.13,183.9 ; PCE18.1 169.01,183.9 ; PCE18.1 168.07,182.96 ; PCE19.1 180.01,178.38 ; PCE19.1 180.01,180.26 ; PCE19.1 179.07,179.32 ; PCE19.1 180.95,179.32 ; 163.68,179.32 PCE16.1 ; PCE16.1 161.8,179.32 ; PCE16.1 162.74,180.26 ; PCE16.1 162.74,178.38 ; PCE15.1 185.6,182.45 ; PCE15.1 184.66,183.39 ; PCE15.1 185.6,184.33 ; PCE15.1 186.54,183.39
  TOP w1.27: PL5.2 200.15,197.35 ; PL5.2 199.88,199.69 ; PL5.2 197.91,196.61 ; 164.92,189.48 PL8.2 ; PL8.2 162.69,188.73 ; PL8.2 162.42,191.07 ; 180.07,190.56 PL7.2 ; PL7.2 182.3,191.31 ; PL7.2 180.34,188.22 ; PL7.2 182.58,188.97
  BOTTOM w0.203: v1(202.21,201.31) 202.48,201.04 PJP10.1
  BOTTOM w0.254: v1(199.09,200.71) 198.9,200.51 PL5.2 ; PL8.2 163.67,190.45 PJP14.1 ; PL7.2 v1(181.32,192.66) ; PJP12.1 v1(183.17,192.66)
  BOTTOM w0.508: v1(187.36,173.23) 188.88,173.23 194.01,178.36 196.81,178.36 197.16,178 206.54,178 209.68,181.15 209.68,187.58 v1(211.27,189.17)
  BOTTOM w0.889: 162.74,178.38 PCE16.1 ; PCE16.1 162.74,180.26 ; PCE16.1 163.68,179.32 ; PCE16.1 161.8,179.32 ; PCE19.1 180.95,179.32 ; PCE19.1 179.07,179.32 ; PCE19.1 180.01,178.38 ; PCE19.1 180.01,180.26 ; 186.54,183.39 PCE15.1 ; PCE15.1 185.6,184.33 ; PCE15.1 185.6,182.45 ; PCE15.1 184.66,183.39 ; PCE18.1 169.01,183.9 ; PCE18.1 168.07,184.84 ; PCE18.1 167.13,183.9 ; PCE18.1 168.07,182.96 ; 173.15,178.38 PCE17.1 ; PCE17.1 173.15,180.26 ; PCE17.1 172.21,179.32 ; PCE17.1 174.09,179.32
  vias: v1(159.1,139.8) v1(159.99,139.8) v1(161.08,139.8) v1(161.45,179.45) v1(161.58,184.02) v1(161.7,186.94) v1(162.1,139.8) v1(162.59,177.93) v1(162.59,175.01) v1(162.59,174.12) v1(162.72,180.97) v1(163.11,139.8) v1(163.86,140.84) v1(163.99,179.32) v1(164.12,186.94) v1(164.12,184.02) v1(164.13,139.8) v1(165.14,139.8) v1(165.26,153.54) v1(165.26,152.53) v1(165.26,151.64) v1(165.26,148.84) v1(165.26,147.7) v1(165.26,144.14) v1(165.26,142.88) v1(165.51,140.72) v1(165.77,189.87) v1(166.16,139.8) v1(166.28,176.78) v1(166.53,191.64) v1(166.53,187.07) v1(166.66,184.02) v1(167.29,153.54) v1(167.29,152.53) v1(167.29,151.64) v1(167.29,148.84) v1(167.29,147.7) v1(167.29,144.14) v1(167.29,142.88) v1(167.3,139.8) v1(167.55,175.13) v1(167.55,173.99) v1(167.55,172.47) v1(167.55,170.94) v1(168.05,185.29) v1(168.05,182.63) v1(168.05,179.07) v1(168.05,140.72) v1(168.31,171.7) v1(168.82,189.1) v1(169.07,172.47) v1(169.07,170.94) v1(169.2,184.02) v1(169.32,153.54) v1(169.32,152.53) v1(169.32,151.64) v1(169.32,148.84) v1(169.32,147.7) v1(169.32,144.14) v1(169.32,142.88) v1(169.83,176.91) v1(169.83,171.7) v1(170.59,172.47) v1(170.59,170.94) v1(171.36,171.7) v1(171.36,153.42) v1(171.86,179.32) v1(172.12,172.47) v1(172.12,170.94) v1(172.37,175.13) v1(172.5,173.99) v1(172.88,171.7) v1(173.13,180.72) v1(173.13,178.05) v1(173.26,184.4) v1(173.64,172.47) v1(173.64,170.94) v1(174.28,179.32) v1(174.4,171.7) v1(175.17,172.47) v1(175.17,170.94) v1(176.31,181.23) v1(176.44,184.4) v1(176.69,172.47) v1(176.69,170.94) v1(177.45,171.7) v1(177.83,175.01) v1(177.83,174.12) v1(178.21,182.75) v1(178.21,172.47) v1(178.21,170.94) v1(178.72,179.32) v1(178.98,171.7) v1(179.74,184.66) v1(179.74,172.47) v1(179.74,170.94) v1(179.99,180.59) v1(179.99,177.93) v1(180.37,187.58) v1(180.5,171.7) v1(181.14,182.75) v1(181.14,179.32) v1(181.26,172.47) v1(181.26,170.94) v1(182.02,171.7) v1(182.53,187.83) v1(182.79,184.66) v1(182.79,175.01) v1(182.79,173.99) v1(182.79,172.47) v1(182.79,170.94) v1(183.29,191.13) v1(183.55,171.7) v1(183.68,189.61) v1(184.31,183.39) v1(184.31,172.47) v1(184.31,170.94) v1(185.58,184.66) v1(185.58,182.12) v1(185.83,190.75) v1(186.72,183.39) v1(187.61,177.55) v1(187.99,188.47) v1(188.12,185.93) v1(188.25,174.12) v1(189.77,183.64) v1(189.9,179.96) v1(190.03,175.89) v1(191.17,187.96) v1(191.73,179.7) v1(192.06,177.8) v1(192.18,184.66) v1(192.44,181.48) v1(194.22,189.36) v1(194.32,181.41) v1(194.85,186.06) v1(194.88,184.18) v1(194.98,183.01) v1(196.38,180.59) v1(196.88,191.9) v1(197.77,189.48) v1(198.03,195.83) v1(199.8,195.83) v1(200.82,198.88) v1(200.82,197.23) v1(200.95,193.68) v1(202.73,190.88) v1(203.23,196.47) v1(204.12,193.8) v1(205.01,194.69) v1(205.9,191.01) v1(207.47,189.84) v1(207.93,188.47) v1(208.06,186.44) v3(159.11,155.63) v3(159.62,154.13) v3(160.03,155.65) v3(160.02,154.72) v3(160.95,157.48) v3(160.94,155.63) v3(161.85,154.72) v3(162.76,157.45) v3(162.77,155.63) v3(163.68,154.72) v3(164.6,155.63) v3(165.49,157.45) v3(165.51,154.72) v3(165.52,158.39) v3(166.41,158.39) v3(166.42,159.29) v3(166.42,157.46) v3(166.42,155.63) v3(167.35,161.11) v3(167.34,160.2) v3(167.34,154.72) v3(168.25,161.11) v3(168.25,159.29) v3(168.25,157.46) v3(168.25,155.63) v3(169.17,164.78) v3(169.17,162.95) v3(169.17,154.72) v3(169.33,168.91) v3(170.08,165.69) v3(170.08,161.12) v3(170.08,159.29) v3(170.08,157.46) v3(170.08,155.63) v3(171,164.78) v3(171,162.95) v3(171,154.72) v3(171.37,168.91) v3(171.91,165.69) v3(171.91,161.12) v3(171.91,159.29) v3(171.91,157.46) v3(171.91,155.63) v3(172.83,164.78) v3(172.83,162.95) v3(172.83,154.72) v3(173.4,168.91) v3(173.8,164.8) v3(173.78,162.94) v3(173.74,161.12) v3(173.74,159.29) v3(173.74,157.46) v3(173.74,156.55) v3(175.18,168.91) v3(175.94,163.86) v3(175.94,161.12) v3(175.94,159.29) v3(175.94,157.43) v3(175.94,156.55) v3(176.85,162.95) v3(176.85,161.12) v3(176.85,159.29) v3(176.85,157.46) v3(177.21,168.91) v3(177.77,163.86) v3(177.77,159.28) v3(178.68,162.95) v3(178.68,161.12) v3(178.65,160.21) v3(178.99,168.91) v3(179.6,163.86) v3(180.51,162.95) v3(180.51,161.12) v3(180.76,168.91) v3(181.4,163.86) v3(181.41,162.94) v3(182.54,168.91)
+VPP: length 15.5
  TOP w0.254: PR386.1 105.82,64.96 v1(105.82,64.77) ; v1(99.98,65.28) 99.07,66.19 98.3,66.19 97.06,67.44 96.05,67.44 93.38,70.1
  BOTTOM w0.254: v1(105.82,64.77) 105.32,65.28 v1(99.98,65.28)
+VPP_BST: length 2.5
  TOP w0.406: PU18.5 104.43,68.7
  TOP w0.508: PR384.1 103.92,67.44 v1(104.55,68.07) 104.55,68.57 104.43,68.7
+VPP_BST_RC: length 2.6
  TOP w0.102: v1(102.52,67.56) 102.4,67.44 PR384.2
  TOP w0.508: PC234.1 100.62,67.26 101.46,67.26 PR384.2
+VPP_EN: length 9.4
  TOP w0.254: PU18.6 104.63,69.65 106.01,68.26 PC240.2 PR279.2 105.04,67.06 v1(103.97,65.99) 102.51,64.53 101.38,64.53
+VPP_FB: length 2.3
  TOP w0.254: PR385.1 105.13,70.99 v1(105.06,70.99) 105.02,70.95 PU18.8
+VPP_FB_R: length 29.4
  TOP w0.254: PJP32.1 89.06,69.96 90.19,68.83 v1(90.71,68.83) ; v1(108.49,64.26) 110.4,66.17 110.4,67.69 110.02,68.07 PR282.2 109.32,68.58 109.57,68.83 PC348.2
  BOTTOM w0.254: v1(90.71,68.83) 91.35,68.2 v2(91.6,68.2) 91.72,68.2 95.17,64.74 102.85,64.74 104.13,63.47 106.68,63.47 107.48,64.26 v1(108.49,64.26)
+VPP_FB_RC: length 6.6
  TOP w0.254: PR385.2 107.73,70.1 108.24,69.6 v1(109.13,69.6) 109.13,69.53 PC348.1 108.68,68.83 108.43,68.58 PR282.1 109.32,67.18 PR284.1 PR283.1
+VPP_LSN: length 1.8
  TOP w0.508: PC342.2 98.39,75.63 v1(98.84,75.18) 99.47,75.18 PR380.1
+VPP_PG: length 7.8
  TOP w0.203: PR358.2 108.07,71.6 106.5,71.6 PC241.1 105.51,71.62 103.66,71.62 v1(103.03,70.99) 102.99,70.95 PU18.1
+VPP_PVCC: length 3.1
  TOP w0.254: v1(106.46,69.6) 106.01,69.15 PC349.1 104.8,70.3 PU18.7
+VPP_SW:
  vias: v1(96.18,73.21) v1(96.17,72.26) v1(96.55,75.06) v1(96.55,74.04) v1(97.82,75.06) v1(97.82,74.04)
+VPP_VIN:
  vias: v1(100.87,72.14)
+VTT: length 4.3
  L3_GND w0.635: DIMM1.77 158.79,91.17 158.79,88.48 DIMM1.221
  vias: v1(157.77,73.33)
A_CBN: length 3.6
  TOP w0.178: UA1.35 187.38,20.48 187.8,20.06 v1(187.8,19.87)
  TOP w0.254: v1(187.8,19.87) 187.8,18.9 188.09,18.6 188.92,18.6 CA91.2
A_CBP: length 5
  TOP w0.178: UA1.37 188.84,21.63 v1(189.29,21.18)
  TOP w0.254: v1(189.29,21.18) 189.48,20.99 190.1,20.99 190.91,20.17 190.91,19.46 190.69,19.23 190.38,19.23 189.96,18.81 CA91.1
A_CPVEE: length 4.4
  TOP w0.178: 187.28,20.07 186.98,20.37 UA1.34
  TOP w0.254: CA90.2 188.5,17.58 v1(188.21,17.87) 187.28,18.8 187.28,20.07
A_EAPD_R: length 1.6
  TOP w0.254: R6538.1 v1(231.68,240.22) 231.82,240.08 U136.B1
A_FP_PRES#: length 14.4
  TOP w0.089: U4.R36 61.41,117.91 v1(61.81,117.5)
  TOP w0.102: RA69.2 62.39,105.86 v1(62.62,105.63)
  BOTTOM w0.089: 62.29,111.25 62.29,112.61 62.55,112.88 v2(62.55,114.67) 62.55,116.76 v1(61.81,117.5)
  BOTTOM w0.102: v1(62.62,105.63) 63.03,106.04 63.03,109.92 62.29,110.66 62.29,111.25
A_GND: length 30.9
  TOP w0.203: UA1.25 v1(182.9,20.89) ; v1(189.66,21.85) 189.59,21.85 189.41,22.03 UA1.38
  TOP w0.381: CA76.1 v1(222.54,12.02)
  TOP w0.406: v1(191.04,16.97) 191.61,17.54 RA42.1 ; CA6.2 181.47,19.89 v1(181.01,19.43) ; CA75.1 175.23,28.46 v1(175.04,28.27) ; CA108.1 233.27,241.43 v1(233.84,241.43) ; CA104.1 177.64,26.43 v1(177.2,26.88) ; CA106.1 v1(173.01,21.16) ; v1(192.57,9.78) 192.2,10.14 CA77.1 ; v1(173.01,22.18) CA103.2
  TOP w0.508: CA119.2 v1(190.15,6.56) ; v1(233.46,237.24) 233.46,237.74 233.4,237.81 CA116.1 ; CA120.2 188.56,13.61 v1(189.01,13.16) 189.45,13.61 CA121.2 ; RA1.2 181.64,14.69 v1(182.15,14.18) ; v1(235.43,242.25) 235.81,242.63 CA78.2 ; CA124.1 v1(240.06,110.49) ; QA4.S 171.8,27.51 v1(172.5,27.51) ; CA105.1 179.61,26.37 v1(179.1,26.88) ; CA109.1 232.38,235.65 v1(232.44,235.71) ; CA5.1 v1(184.44,14.18) ; CA7.2 179.05,14.61 v1(179.36,14.3) ; CA12.2 v1(177.58,23.19) ; v1(234.6,241.43) 234.48,241.3 CA117.2 ; RA44.1 232.38,233.49 v1(232.44,233.43) ; CA4.2 v1(193.33,18.07) ; CA125.1 v1(240.06,62.99) ; v1(235.87,245.24) 235.81,245.17 CA80.2 ; CA74.1 194.4,16.4 v1(193.84,15.83) ; CA126.1 v1(240.06,41.53) ; CA118.2 v1(174.91,6.56) ; CA102.2 v1(192.82,22.05) ; CA107.1 v1(227.49,254.25) ; v1(194.85,17.86) 194.91,17.92 RA43.1 ; CA3.2 v1(191.96,18.14) ; CA1.2 v1(182.79,14.18) ; CA110.1 v1(207.74,14.88)
  vias: v1(176.68,2.2) v1(181.24,2.21) v1(183.95,2.21) v1(188.73,2.19) v1(191.92,2.19) v1(196.38,3.81) v1(197,2.19) v1(202.12,2.19) v1(205.7,7.67) v1(207.5,10.4) v1(212.51,10.39) v1(217.59,10.39) v1(222.45,7.6) v1(227.49,258.06) v1(227.53,7.6) v1(232.57,258.06) v1(232.61,7.65) v1(234.22,19.94) v1(234.23,14.96) v1(235.95,25.6) v1(237.65,258.06) v1(242.73,256.57) v1(243.24,253.75) v1(243.23,248.67) v1(243.23,243.59) v1(243.24,233.48) v1(243.23,218.19) v1(243.23,213.11) v1(243.23,208.03) v1(243.23,202.95) v1(243.23,197.87) v1(243.24,192.79) v1(243.23,187.71) v1(243.23,182.63) v1(243.23,177.55) v1(243.23,172.47) v1(243.23,167.39) v1(243.24,162.31) v1(243.23,157.23) v1(243.23,152.15) v1(243.23,147.07) v1(243.23,141.99) v1(243.23,136.91) v1(243.24,131.83) v1(243.23,126.75) v1(243.23,121.67) v1(243.23,116.59) v1(243.23,111.51) v1(243.23,106.43) v1(243.24,101.35) v1(243.23,96.27) v1(243.23,91.19) v1(243.23,86.11) v1(243.23,81.03) v1(243.23,75.95) v1(243.24,70.87) v1(243.23,65.79) v1(243.23,60.71) v1(243.23,55.63) v1(243.23,50.55) v1(243.23,45.47) v1(243.24,40.39) v1(243.23,35.31) v1(243.23,30.23)
A_GND_C: length 1.4
  TOP w0.254: U136.A2 234.47,239.58 CA117.1
A_HPOUT-L_R: length 2.5
  TOP w0.254: v1(190.28,7.95) 189.52,8.72 RA74.2 189.64,8.91 IO_FBI9.1
A_HPOUT-R_R: length 1.7
  TOP w0.254: RA75.2 188.88,9.16 v1(188.88,9.35) 188.88,9.55 IO_FBI10.1
A_JD1: length 4.8
  TOP w0.203: UA1.13 182.29,26.03 182.08,26.24
  TOP w0.254: 182.08,26.24 181.95,26.37 CA105.2 RA16.1 180.56,27.61 v1(180.17,28) 179.71,28.46 RA18.1
A_JD2: length 6.5
  TOP w0.203: 182.15,25.63 UA1.14
  TOP w0.254: RA17.1 178.53,28.4 RA15.1 CA104.2 179.04,25.86 180.93,25.86 v1(181.16,25.63) 182.15,25.63
A_LDO1_C: length 9
  TOP w0.203: 184.09,20.17 184.18,20.27 UA1.27
  TOP w0.254: RA1.1 182.27,16.39 CA1.1 ; CA1.1 182.79,17.73 183.55,18.49 183.55,19.63 184.09,20.17 ; CA1.1 183.55,15.62 183.55,14.75 183.57,14.72 v1(183.57,14.2)
A_LDO3_C: length 4
  TOP w0.203: 185.33,27.8 185.38,27.74 ; 185.38,27.39 UA1.7
  TOP w0.254: 185.38,27.74 185.38,27.39
  TOP w0.508: CA18.2 184.31,29.29 v1(184.99,28.61) 185.33,28.27 185.33,27.8
  BOTTOM w0.102: v1(184.99,28.61) 184.7,28.61 v2(184.24,29.07)
A_LINE1-L_C: length 2.6
  TOP w0.254: v1(175.17,20.02) 175.67,19.51 CA123.2 176.06,18.75 RA41.1
A_LINE1-R_C: length 2
  TOP w0.254: RA40.1 174.59,17.8 v1(174.28,18.11) 174.02,18.37 CA122.2
A_LINE2_L_C: length 313.5
  TOP w0.254: v1(179.36,18.41) 178.52,18.41 CA85.2 ; v1(195.92,4.95) 196.47,4.4 203.11,4.4 204.5,5.8 204.5,10.24 205.65,11.38 220.89,11.38 223.43,8.84 231.89,8.84 233.08,10.03 233.08,25.06 234.69,26.67 239.26,26.67 242.68,30.09 242.68,214.81 v1(240.06,217.42) 235.75,217.42 230.39,222.78 230.39,229.04 233.97,232.61 233.97,234 RA71.1
  BOTTOM w0.254: v1(179.36,18.41) 179.87,18.92 184.09,18.92 184.98,18.03 186.39,18.03 188.29,16.13 189.01,16.13 191.55,13.59 191.55,6.98 193.58,4.95 v1(195.92,4.95)
A_LINE2_R_C: length 309.6
  TOP w0.254: v1(180.25,18.41) 179.74,17.91 CA83.2 ; RA70.1 233.46,232.87 229.85,229.26 229.85,222.55 235.87,216.53 238.81,216.53 v1(240.05,215.3) 242.17,213.18 242.17,30.3 239.05,27.18 234.48,27.18 232.57,25.27 232.57,10.24 231.68,9.35 223.68,9.35 221.14,11.89 205.14,11.89 203.87,10.62 203.87,5.92 203.02,5.07 v1(196.84,5.07)
  BOTTOM w0.254: v1(180.25,18.41) 183.88,18.41 184.77,17.53 186.18,17.53 188.08,15.62 188.79,15.62 191.04,13.37 191.04,6.77 193.37,4.44 196.21,4.44 v1(196.84,5.07)
A_MIC_C: length 3.1
  TOP w0.203: UA1.19 181.9,23.63 181.85,23.67 v1(181.77,23.67)
  TOP w0.254: CA12.1 180.1,23.19 180.58,23.67 v1(181.77,23.67)
A_PCBEEP_C: length 4.9
  TOP w0.102: RA5.1 RA4.1 RA6.1 CA92.1 CA17.2 v1(177.97,31.89)
A_PVDD1: length 1.4
  TOP w0.203: UA1.41 189.14,23.23
  TOP w0.254: 189.14,23.23 189.87,23.23
  vias: v1(189.95,23.47) v1(190.66,26.88) v1(190.66,24.08) v1(191.8,28.66) v1(191.8,28.02) v1(194.82,25.23)
A_QA3_G: length 4.4
  TOP w0.102: RA58.2 R6540.2 174.13,31.51 v1(173.64,32) 173.53,32 CS69.1 173.09,32.99 QA3.G
A_QA4_G: length 5.7
  TOP w0.508: QA3.D 171.61,33.72 v1(171.55,33.66) R6539.2 R6541.2 171.48,30.24 QA4.G
A_SET: length 1.2
  TOP w0.254: CA116.2 232.51,238.32 232.57,238.38 v1(232.57,238.51) 232.57,238.63 232.57,238.64 U136.B3
A_SPEAKER_C: length 2
  TOP w0.102: v1(178.21,34.45) 178.1,34.56 CA19.1 RA5.2
A_SPKR_C: length 2
  TOP w0.102: v1(175.67,34.45) 175.79,34.56 CA20.1 RA4.2
A_USB2_COMP: length 9.9
  TOP w0.089: 56.25,137.57 55.46,136.78 55.46,135.05 55.37,134.96 55.37,134.55 55.13,134.31 U4.AG3
  TOP w0.102: 56.25,137.57 56.55,137.87 56.55,141.92 R6466.2 v1(57.06,143.26)
A_VD33_STB: length 12.4
  TOP w0.203: UA1.20 182.14,23.23 182.07,23.16 181.36,23.16
  TOP w0.254: 181.36,23.16 180.79,23.16 180.11,22.48 v1(178.85,22.48) 174.9,22.48 CA103.1 174.09,21.67 172.69,21.67 RA2.1
  BOTTOM w0.102: v2(178.47,23.37) 178.85,22.99 v1(178.85,22.48)
A_VREF: length 4.7
  TOP w0.203: UA1.28 184.58,20.13 184.49,20.03
  TOP w0.254: 184.49,20.03 184.05,19.6 184.05,17.98 v1(183.68,17.61) CA5.2
APS_PIN1: length 2.4
  TOP w0.102: RB1.2 12.03,185.8 APS/PETS.1
APS_PIN2: length 5
  TOP w0.102: 7.65,185.8 8.36,185.8 9.43,184.73 10.69,184.73 RB8.1
APS_PIN3: length 7.5
  TOP w0.102: RB2.2 v1(8.22,182.31)
  BOTTOM w0.102: APS/PETS.3 9.2,187.35 9.2,185.57 8.22,184.59 v1(8.22,182.31)
APS_PIN4: length 6.3
  TOP w0.102: 7.65,188.34 8.8,187.2 RB7.1 RB9.1
APS_PIN5: length 2.2
  TOP w0.102: 10.19,190.88 RB3.2
APS_PIN6: length 5.2
  TOP w0.102: RB10.1 8.67,191.9 7.65,190.88
APS_PIN9: length 7.7
  TOP w0.102: RB4.2 11.91,199.77 9.56,199.77 8.92,199.14 8.92,197.23 APS/PETS.9
APS_PIN11: length 2.5
  TOP w0.102: RB5.2 11.65,198.5 10.19,198.5
APS_PIN13: length 2.3
  TOP w0.102: RB6.2 10.45,201.29 APS/PETS.13
APU_PCI_BCLK: length 126.3
  TOP w0.089: v3(146.29,149.18) 146.37,149.18 CPU.W1 ; 65.88,137.29 65.87,137.28 65.86,137.28 64.34,135.76 64.34,135.5 64.42,135.41 64.42,135.14 64.23,134.94 U4.J2
  TOP w0.102: 65.88,137.29 66.46,137.87 68.56,137.87 68.74,138.05 72.91,138.05 74.53,136.43 78.36,136.43 80.65,134.14 80.65,122.56 81.65,121.56 81.65,121.08 81.55,120.98 81.55,120.68 81.65,120.57 81.65,120.27 81.55,120.17 81.55,119.86 81.65,119.76 81.65,119.14 81.03,118.52 81.03,117.88 81.33,117.59 v1(81.33,117.32)
  BOTTOM w0.102: v1(81.33,117.32) 81.44,117.43 82.67,117.43 84.56,119.32 86.19,119.32 86.66,118.85 98.51,118.85 99.75,120.09 106.45,120.09 110.16,123.8 112.66,123.8 124.59,135.74 v2(124.59,140.08) 124.59,141.36 124.98,141.74 124.98,142.23 124.59,142.61 124.59,147.34 128.46,151.21 141.22,151.21 142.42,150.01 146.02,150.01 146.48,149.54 146.48,149.37 v3(146.29,149.18)
APU_PCI_BCLK#: length 126.3
  TOP w0.089: 65.74,137.44 65.72,137.42 65.72,137.41 65.53,137.23 65.39,137.23 65.2,137.04 65.2,136.89 65.01,136.7 64.87,136.7 64.68,136.52 64.68,136.37 64.15,135.84 U4.J1 ; v3(147.22,149.23) CPU.W2
  TOP w0.102: 65.74,137.44 66.37,138.07 68.48,138.07 68.66,138.25 73,138.25 74.61,136.63 78.44,136.63 80.86,134.22 80.86,122.64 81.85,121.65 81.85,119.05 81.24,118.44 81.24,117.97 81.46,117.75 81.75,117.75 v1(81.87,117.87)
  BOTTOM w0.102: v3(147.22,149.23) 147.08,149.23 146.1,150.21 142.51,150.21 141.31,151.41 128.37,151.41 124.39,147.43 v2(124.39,141.99) 124.39,140.7 124.01,140.32 124.01,139.84 124.39,139.46 124.39,135.82 112.57,124 110.08,124 106.37,120.29 99.67,120.29 98.42,119.05 86.75,119.05 86.28,119.52 84.48,119.52 82.59,117.63 82.1,117.63 v1(81.87,117.87)
APU_RST: length 59.9
  TOP w0.102: R6575.2 v1(115.73,192.79) ; CPU.E7 v3(151.79,162.04)
  BOTTOM w0.102: v1(115.73,192.79) 115.73,191.9 117.43,190.2 129.58,190.2 130.09,189.68 130.52,189.68 133.48,186.72 133.48,178.11 134.15,177.45 134.15,176.71 135.69,175.16 136.21,175.16 143.01,168.36 v2(143.01,166.9) 143.09,166.9 144.47,165.51 148.05,165.51 148.31,165.25 151.94,165.25 152.25,164.93 152.25,163.68 151.96,163.38 151.62,163.38 151.36,163.13 151.36,162.47 v3(151.79,162.04)
AUD_BITCLK: length 283.5
  TOP w0.102: v1(15.63,109.96) 14.16,111.43 14.16,119.07 11.41,121.82 11.41,129.61 17.52,135.71 17.76,135.71 21.01,138.96 23.44,138.96 30.35,145.87 34.45,145.87 36.58,143.74 36.58,140.95 38.53,139 R6339.1 ; RA19.1 185.58,34.05 v1(185.58,36.19)
  BOTTOM w0.102: v1(15.63,109.96) 15.63,105.53 23.68,97.48 23.68,89.76 21.22,87.3 21.22,78.61 27.52,72.32 27.52,71.63 36.82,62.33 39.89,62.33 42.16,60.06 46.39,60.06 46.89,60.55 55.79,60.55 56.17,60.17 68.28,60.17 75.52,52.93 80.26,52.93 83.45,49.75 85.14,49.75 91.05,43.83 97.3,43.83 98.58,42.56 101.07,42.56 102.29,41.33 102.29,39.92 103.04,39.17 106.61,39.17 107.68,38.1 114.48,38.1 116.46,36.11 136.08,36.11 138.45,33.74 151.58,33.74 152.08,34.24 173.08,34.24 174.53,35.69 185.07,35.69 v1(185.58,36.19)
AUD_BITCLK_R: length 7.8
  TOP w0.102: v1(184.93,33.79) 184.96,33.79 RA19.2 185.71,32.82 185.2,32.31 185.2,30.12 CA29.1 185.78,29.53 UA1.6
AUD_LINK_RESET#: length 295.8
  TOP w0.102: v1(189.77,32.9) 190.53,32.13 RA36.1 ; v1(175.17,33.86) 175.17,32.66 RA58.1 ; UA1.11 183.78,27.13 182.32,28.59 181.73,28.59 179.82,30.5 CA25.1 178.98,31 178.98,33.23 v1(179.61,33.86) ; v1(18.7,136.02) 19.34,136.02 21.67,138.35 23.69,138.35 30.6,145.26 34.19,145.26 35.97,143.48 35.97,140.7 37.63,139.05 R6341.1
  BOTTOM w0.102: v1(18.7,136.02) 18.29,136.02 17.42,135.15 17.42,133.25 18.09,132.57 18.09,126.14 17.28,125.32 17.28,121.39 15.53,119.64 15.53,110.89 14.79,110.15 14.79,105.19 22.77,97.21 22.77,90.03 20.39,87.65 20.39,78.26 26.68,71.97 26.68,71.28 37.62,60.34 39.78,60.34 40.58,59.54 41.3,59.54 41.62,59.22 47.69,59.22 48.06,58.85 57.29,58.85 57.77,59.33 67.92,59.33 75.16,52.1 79.91,52.1 83.1,48.91 84.79,48.91 90.7,43 92.07,43 100.06,35.01 116.1,35.01 116.37,35.28 135.73,35.28 138.11,32.9 151.93,32.9 152.35,33.32 170.58,33.32 171.16,32.74 171.93,32.74 172.23,33.05 173.48,33.05 174.29,33.86 v1(175.17,33.86) v1(179.61,33.86) 180.96,33.86 181.9,34.8 187.87,34.8 v1(189.77,32.9)
AUD_LINK_SDI0: length 291.7
  TOP w0.089: 44.09,134.22 44.51,134.22 46.38,132.35 U4.BE7
  TOP w0.102: v1(18.58,137.16) 18.58,138.02 20.13,139.57 23.19,139.57 30.09,146.48 34.7,146.48 37.19,143.99 37.19,141.21 40.11,138.28 40.11,137.37 39.61,136.86 39.61,135.43 39.86,135.18 40.73,135.18 41.69,134.22 44.09,134.22 ; RA20.2 182.68,34.29 v1(182.28,34.29)
  BOTTOM w0.102: v1(18.58,137.16) 18.58,136.63 17.19,135.24 17.19,133.15 17.86,132.48 17.86,126.29 17.05,125.48 17.05,121.48 15.3,119.73 15.3,110.98 14.56,110.25 14.56,105.09 22.54,97.12 22.54,90.12 20.16,87.74 20.16,78.16 26.45,71.87 26.45,71.19 37.53,60.11 39.68,60.11 40.49,59.31 41.2,59.31 41.52,58.99 47.6,58.99 47.97,58.62 57.38,58.62 57.87,59.11 67.82,59.11 75.06,51.87 79.82,51.87 83,48.68 84.69,48.68 90.6,42.77 91.97,42.77 99.97,34.78 116.19,34.78 116.46,35.05 135.64,35.05 138.01,32.67 152.02,32.67 152.44,33.1 170.49,33.1 171.07,32.51 172.02,32.51 172.33,32.82 173.57,32.82 174.16,33.4 181.39,33.4 v1(182.28,34.29)
AUD_LINK_SDIO_R: length 7.5
  TOP w0.102: UA1.8 184.98,27.53 183.33,29.18 183.33,31.33 183.86,31.87 v1(183.86,32.15) 183.86,32.22 RA20.1
AUD_SYNC: length 280.6
  TOP w0.102: R6348.1 36.23,140.12 35.74,140.61 35.74,143.39 34.1,145.03 30.69,145.03 23.79,138.13 22.08,138.13 19.21,135.25 v1(18.65,135.25) ; v1(180.35,34.77) 180.35,33.71 179.99,33.35 179.99,31 CA24.1 180.5,30.14 181.82,28.82 182.47,28.82 184.18,27.11 UA1.10
  BOTTOM w0.102: v1(18.65,135.25) 19.02,134.88 19.02,133.82 18.32,133.12 18.32,125.98 17.51,125.17 17.51,121.3 15.76,119.54 15.76,110.79 15.02,110.06 15.02,105.28 22.99,97.3 22.99,89.93 20.61,87.55 20.61,78.35 26.91,72.06 26.91,71.38 37.72,60.57 40.78,60.57 41.91,59.45 47.79,59.45 48.16,59.08 57.19,59.08 57.68,59.56 68.01,59.56 75.25,52.32 80.01,52.32 83.19,49.14 84.88,49.14 90.79,43.23 92.16,43.23 100.15,35.23 116,35.23 116.27,35.5 135.83,35.5 138.2,33.13 151.83,33.13 152.26,33.55 170.68,33.55 171.26,32.97 171.83,32.97 172.33,33.47 173.25,33.47 174.84,35.05 180.07,35.05 v1(180.35,34.77)
AUX_N: length 7.9
  TOP w0.102: v1(144.05,226.31) 144,226.31 ; 144,226.31 RG7.1 ; 144,226.31 CG2.2 143.49,227.13 143.6,227.23 144.31,227.23 144.74,226.8 147.07,226.8 148.06,225.81 148.5,225.81 148.64,225.67 RTK_VGA.27
AUX_P: length 7.9
  TOP w0.102: v1(144.05,228.35) 144,228.35 ; 144,228.35 RG8.1 ; 144,228.35 CG1.2 143.49,227.53 143.6,227.43 144.39,227.43 144.82,227 147.15,227 148.14,226.01 148.47,226.01 148.63,226.17 RTK_VGA.26
B_ATX_PWROK: length 217.9
  TOP w0.102: ATX_SYS.4 21.48,32.14 20.23,33.4 v1(20.23,34.54) 17.94,34.54 15.63,36.86 12.96,36.86 12.25,37.57 v1(11.34,37.57) 9.46,37.57 8.73,38.29 PC301.1 PR230.2 ; v1(45.23,34.86) 45.35,34.73 PQ57.G ; v1(15.78,71.12) 15.98,71.32 18.15,71.32 19.72,72.89 v1(19.72,73.15) 20.23,73.66 32.56,73.66 33.42,74.52 35.64,74.52 40.24,79.12 44.46,79.12 44.61,79.27 46.87,79.27 47.56,79.96 48.48,79.96 49.17,79.26 50.46,79.26 51.19,79.99 51.19,81.06 51.5,81.37 53.26,81.37 v1(54.56,80.07) ; PR65.2 93.81,66.67 v1(92.97,65.84) ; v1(40.67,58.42) 40.67,59.06 41.23,59.61 41.23,60.91 40.67,61.47 PQ52.G1
  BOTTOM w0.102: v1(20.23,34.54) 21.12,33.66 36.86,33.66 37.75,32.77 39.43,32.77 41.52,34.86 v1(45.23,34.86) ; v1(40.67,58.42) 40.6,58.5 37.73,58.5 30.88,65.34 26.08,65.34 22.36,69.07 22.36,70.34 v2(21.58,71.11) 20.97,71.11 19.97,72.11 19.97,72.9 v1(19.72,73.15) ; v1(15.78,71.12) 15.78,70.23 16.62,69.39 16.62,57.86 15.02,56.26 11.36,56.26 10.37,55.27 10.37,44.07 11.84,42.6 11.84,38.79 11.34,38.28 v1(11.34,37.57) ; v1(54.56,80.07) 54.56,79.86 56.14,78.28 60.05,78.28 60.13,78.21 60.79,78.21 61.07,77.93 62.01,77.93 62.36,78.28 63.5,78.28 64.35,77.44 64.35,76.51 64.63,76.23 65.44,76.23 65.87,76.66 68.57,76.66 69.28,77.37 73.78,77.37 74.41,78 75.24,78 76,77.24 76.91,77.24 77.32,77.65 78.5,77.65 79.34,76.81 85.26,76.81 86.53,78.08 88.07,78.08 88.58,77.57 88.58,71.02 89.52,70.08 89.52,69.01 92.67,65.86 92.95,65.86 v1(92.97,65.84)
BATT1: length 4.7
  TOP w0.762: R6453.1 175.34,50.65 BATTERY.1
BATT_R_2: length 7.8
  TOP w0.102: v1(174.66,55.75) 173.97,55.07 R6453.2
  TOP w0.762: D5.2 D1.1 173.97,52.21 R6453.2
BRG_CLK_F3: length 40.3
  TOP w0.102: v1(69.65,180.34) 68.03,178.71 v1(59.82,178.71) ; RK6.1 v1(57.56,185.17) ; BRIDGE.F3 v1(63.19,195.4)
  BOTTOM w0.102: v1(63.19,195.4) 63.19,195.5 63.79,196.09 v2(66.13,196.09) 67.09,196.09 68.24,194.94 68.24,182.4 69.65,180.98 v1(69.65,180.34) ; v1(59.82,178.71) 59.82,181.76 59.09,182.5 59.09,183.64 v1(57.56,185.17)
BRG_REF0_PCIE: length 8.4
  TOP w0.102: BRIDGE.K12 55.6,199.07 55.28,199.39 53.52,199.39 52.55,200.36 52.55,200.85 51.85,201.55 51.85,202.52 v1(51.39,202.99) 51.17,203.2 RK8.2
  BOTTOM w0.102: v2(50.96,202.35) 50.96,202.56 v1(51.39,202.99)
BRG_REF1_PCIE: length 5.4
  TOP w0.102: BRIDGE.K13 53.59,199 v1(52.07,200.52) 52.07,200.95 50.96,202.06 RK7.2
BRG_REF01_PCIE_R: length 2.8
  TOP w0.102: v1(49.01,203.2) RK8.1 49.75,202.3 RK7.1
  BOTTOM w0.102: v2(49.05,202.37) 49.05,203.16 v1(49.01,203.2)
BRG_RXN: length 7.9
  TOP w0.102: CX118.2 50.86,190.54 50.86,190.73 51.21,191.08 51.54,191.08 52.23,191.77 52.23,192.3 52.1,192.43 52.1,192.89 v1(52.37,193.15) 53.83,194.62 55.03,194.62 55.41,195 BRIDGE.E12
BRG_RXP: length 7.9
  TOP w0.102: BRIDGE.E13 54.62,194.82 53.75,194.82 52.53,193.6 52.18,193.6 51.9,193.32 51.9,192.35 52.03,192.22 52.03,191.85 51.69,191.52 v1(51.35,191.52) 50.66,190.82 50.66,190.53 50.44,190.31 CX119.2
BRG_TP_L10: length 1.7
  TOP w0.102: BRIDGE.L10 57.2,199.8 v1(56.8,200.2)
  BOTTOM w0.102: v1(56.8,200.2) 56.8,201.29 TPS108.1
BRG_TP_M11: length 3.2
  TOP w0.102: v1(55.99,201) 56.39,200.6 BRIDGE.M11
  BOTTOM w0.102: v1(55.99,201) 55.99,202.65 TPS107.1
BRG_TP_N12: length 1.8
  TOP w0.102: BRIDGE.N12 55.6,201.87 v1(55.28,202.18)
  BOTTOM w0.102: v1(55.28,202.18) 55.28,202.06 TPS106.1
BRG_TXN: length 5.4
  TOP w0.102: CX126.2 51.38,195.17 51.65,195.17 52.06,195.58 v1(52.13,195.58) 52.76,196.22 52.97,196.22 53.25,195.94 54.39,195.94 54.67,196.22 55.22,196.22 BRIDGE.G12
BRG_TXP: length 5.3
  TOP w0.102: CX127.2 51.15,195.48 51.25,195.38 51.57,195.38 51.67,195.48 51.67,195.76 51.93,196.01 52.27,196.01 52.68,196.42 53.05,196.42 53.33,196.14 53.5,196.14 v1(53.83,196.47) 54.16,196.14 54.3,196.14 54.76,196.6 BRIDGE.G13
BRG_VDD_15_COMB: length 10.3
  TOP w0.381: CK20.1 CK19.1 50.07,204.28 50.45,204.66 ; 50.45,204.66 50.83,204.28 CK16.1 52.36,202.88 52.36,201.68 52.93,201.1 52.93,200.5 53.63,199.8 BRIDGE.L13 ; 50.45,204.66 v1(50.45,204.72)
  BOTTOM w0.102: v2(49.47,205.04) 49.78,204.72 v1(50.45,204.72)
BRG_VDD_33_COMB: length 6.6
  TOP w0.356: BRIDGE.J13 54.69,198.2 54.33,198.56
  TOP w0.508: 54.33,198.56 52.93,198.56 51.91,199.58 CK8.1 CK10.1 50.13,199.58 v1(49.69,199.14) 49.63,199.14 CK11.1
BRG_VDD_33_COMBIO: length 11.7
  TOP w0.102: CK14.1 CK13.1 CK15.1 53.55,206.3 53.88,206.63 v1(53.88,206.76) ; BRIDGE.K11 56.39,199 v1(55.99,199.4)
  BOTTOM w0.102: v1(53.88,206.76) 53.88,203.96 54.14,203.71 54.14,201.29 55.99,199.44 v1(55.99,199.4)
BT_USB2_N6: length 146.6
  TOP w0.089: U4.AF2 55.65,134.85 55.77,134.85 55.83,134.91 55.83,135.6 55.93,135.69 55.93,136.56 56.57,137.2 57.43,137.2 57.6,137.37 57.6,137.54 57.6,137.55 57.6,137.57
  TOP w0.102: v1(40.46,74.94) 40.75,74.65 41.28,74.65 41.58,74.95 LU23.1 ; 57.6,137.57 57.6,143.87 57.69,143.97 57.69,144.17 57.56,144.3 57.42,144.3 v1(57.23,144.12)
  BOTTOM w0.102: v1(40.46,74.94) 40.46,74.75 40.27,74.57 39.25,74.57 37.63,76.2 37.63,79.12 36.69,80.06 36.69,87.14 35.21,88.62 35.21,90.15 34.68,90.69 34.68,91.39 34.09,91.97 34.09,98.35 32.91,99.53 31.04,99.53 29.76,100.81 27.55,100.81 20.6,107.76 20.6,112.66 23.89,115.95 23.89,116.61 25.04,117.76 25.04,123.95 24.73,124.25 24.73,135.55 29.9,140.72 32.14,140.72 33,141.58 34.12,141.58 35.8,143.25 35.8,150.92 42.22,157.34 52.77,157.34 v2(54.59,155.52) 55.15,155.52 56.21,154.46 56.77,154.46 57.03,154.2 57.03,151.21 56.7,150.88 56.7,149.94 56.04,149.28 56.04,148.31 57.56,146.79 57.56,144.54 57.69,144.42 57.69,144 57.56,143.87 57.39,143.87 57.23,144.02 v1(57.23,144.12)
BT_USB2_N8: length 143.6
  TOP w0.089: U4.AL8 53.24,131.66 52.99,131.42 v1(52.81,131.42)
  TOP w0.102: v1(39.72,76.09) 40.06,76.43 40.3,76.43 41.01,77.14 41.16,77.14 41.48,76.81 LU24.2
  BOTTOM w0.089: v1(52.81,131.42) 52.92,131.42 53.4,131.89 53.4,133.97 52.24,135.13 52.24,135.99 52.25,135.99 52.25,136.02
  BOTTOM w0.102: v1(39.72,76.09) 39.49,76.32 39.32,76.32 38.18,77.46 38.18,79.29 37.19,80.28 37.19,91.33 36.42,92.1 35.81,92.1 35.09,92.83 35.09,96.15 35.44,96.5 35.44,97.93 33.35,100.03 31.24,100.03 29.96,101.31 27.75,101.31 21.09,107.97 21.09,112.45 24.39,115.76 24.39,116.41 25.53,117.56 25.53,124.15 25.23,124.46 25.23,135.2 30.23,140.21 33.66,140.21 36.36,142.91 36.36,150.75 42.46,156.86 49.6,156.86 52.09,154.36 52.09,153.53 52.48,153.14 v2(52.48,150.62) 53.44,149.67 53.44,149.09 55.71,146.81 55.71,143.63 53.02,140.94 53.02,139.5 52.25,138.73 52.25,136.02
BT_USB2_P6: length 146.7
  TOP w0.089: 57.8,137.57 57.8,137.55 57.79,137.54 57.79,137.29 57.51,137.01 56.65,137.01 56.12,136.48 56.12,135.61 56.02,135.52 56.02,134.72 U4.AF3
  TOP w0.102: v1(58.12,144.14) 58.12,144.09 57.8,143.77 57.8,137.57 ; v1(40.46,74.18) 40.72,74.45 41.26,74.45 41.56,74.15 LU23.2
  BOTTOM w0.102: v1(40.46,74.18) 40.27,74.37 39.17,74.37 37.42,76.12 37.42,79.04 36.49,79.97 36.49,87.06 35.01,88.54 35.01,90.07 34.48,90.6 34.48,91.3 33.89,91.89 33.89,98.26 32.83,99.33 30.96,99.33 29.67,100.61 27.47,100.61 20.4,107.67 20.4,112.75 23.68,116.03 23.68,116.69 24.84,117.85 24.84,123.86 24.53,124.17 24.53,135.63 29.82,140.92 32.05,140.92 32.92,141.78 34.04,141.78 35.59,143.34 35.59,151 42.14,157.55 52.86,157.55 54.27,156.13 54.82,156.13 55.92,155.04 v2(56.47,155.04) 57.23,154.28 57.23,151.12 56.9,150.79 56.9,149.86 56.24,149.2 56.24,148.39 57.77,146.87 57.77,144.63 58.12,144.27 v1(58.12,144.14)
BT_USB2_P8: length 143.5
  TOP w0.089: U4.AL7 52.8,132.1 v1(52.78,132.1)
  TOP w0.102: LU24.1 41.41,77.62 41.13,77.34 40.93,77.34 40.22,76.63 40.05,76.63 v1(39.72,76.96)
  BOTTOM w0.089: 52.05,136.02 52.05,135.99 52.05,135.99 52.05,135.05 53.21,133.9 53.21,131.99 53.07,131.85 52.9,131.85 52.78,131.96 v1(52.78,132.1)
  BOTTOM w0.102: v1(39.72,76.96) 39.91,76.78 39.91,76.63 39.8,76.53 39.41,76.53 38.39,77.55 38.39,79.38 37.4,80.37 37.4,91.41 36.51,92.3 35.9,92.3 35.29,92.91 35.29,96.06 35.64,96.42 35.64,98.02 33.43,100.23 31.33,100.23 30.05,101.51 27.84,101.51 21.29,108.06 21.29,112.37 24.59,115.67 24.59,116.33 25.74,117.47 25.74,124.23 25.43,124.54 25.43,135.12 30.32,140.01 33.74,140.01 36.56,142.83 36.56,150.66 42.55,156.65 49.51,156.65 51.89,154.28 v2(51.89,152.9) 52.28,152.51 52.28,151.25 51.9,150.86 51.9,150.33 52.22,150.01 52.81,150.01 53.23,149.59 53.23,149 55.51,146.73 55.51,143.71 52.81,141.02 52.81,139.58 52.05,138.81 52.05,136.02
C_CLK_OUT0: length 6.6
  TOP w0.102: BRIDGE.B5 61.62,192.18 61.62,191.33 v1(61.5,191.21) 61.5,189.61 63.03,188.09 RK18.1
C_CLK_OUT1: length 6.2
  TOP w0.102: RK56.1 v1(60.61,187.58) 60.61,187.68 59.98,188.32 59.98,192.15 60.4,192.57 BRIDGE.B6
C_PCI_SL1: length 84.2
  TOP w0.102: v1(56.93,179.83) 57.11,180.01 60.43,180.01 62.06,181.64 62.06,184.32 63.03,185.28 RK18.2 ; v1(47.4,222.76) 46.01,224.16 44.06,224.16 42.9,222.99 41.4,222.99 40.6,223.79 37.4,223.79 SLOT3.B16
  BOTTOM w0.102: v1(47.4,222.76) 47.4,222.37 46.29,221.26 46.29,204.19 46.06,203.96 46.06,196.66 45.37,195.96 44.41,195.96 44,195.55 44,191.13 44.36,190.78 45.42,190.78 45.93,190.27 46.06,190.13 46.06,186.43 46.98,185.52 46.98,180.99 47.78,180.19 50.95,180.19 52.75,181.99 53.12,181.99 53.12,181.99 55.93,181.99 56.07,182.12 56.41,182.47 57.9,182.47 58.61,181.77 58.61,180.47 57.97,179.83 v1(56.93,179.83)
C_PCI_SL2: length 99
  TOP w0.102: v1(58.12,181.51) 58.71,180.92 60.05,180.92 61.12,181.99 61.12,184.02 60.61,184.53 RK56.2 ; v1(46.64,222.25) 45.83,223.06 45.83,223.14 45.07,223.9 44.13,223.9 42.99,222.76 41.31,222.76 40.51,223.56 38.55,223.56 37.88,222.88 34.12,222.88 32.93,221.69 27.01,221.69 25.31,223.39 25.31,223.42 25.2,223.52 23.78,223.52 23.15,222.88 21.62,222.88 20.62,223.89 SLOT4.B16
  BOTTOM w0.102: v1(58.12,181.51) 58.05,181.43 56.75,181.43 56.42,181.76 53.02,181.76 52.85,181.76 51.04,179.96 47.68,179.96 46.75,180.89 46.75,185.36 45.83,186.28 45.83,190.04 45.32,190.55 44.25,190.55 43.77,191.03 43.77,195.73 44.23,196.19 45.27,196.19 45.83,196.75 45.83,204.05 46.07,204.28 46.07,221.35 46.64,221.93 v1(46.64,222.25)
CFG0: length 72.2
  TOP w0.102: v1(129.22,192.65) 128.86,192.65 R6682.1 ; CPU.H15 159.58,158.84 v3(160.02,159.28) ; v3(123.49,194.15) 123.49,193.8 122.92,193.23 R39.2 122.27,193.81 122.27,194.61 122.29,194.64 122.29,196.06 121.43,196.93 121.43,197.44 121.15,197.71 XDP_CPU.9
  BOTTOM w0.102: v3(123.49,194.15) 123.89,194.15 124.54,193.5 125.59,193.5 126.31,192.77 v2(127.67,192.77) 127.79,192.65 v1(129.22,192.65) 129.57,192.65 131.29,194.37 132.7,194.37 133.41,193.66 134.42,192.65 134.42,190.63 136.84,188.22 136.84,182.69 147.87,171.65 156.9,171.65 160.13,168.43 160.13,167.04 159.14,166.05 159.14,165.18 159.27,165.05 159.27,161.58 159.57,161.28 159.57,160 160.02,159.54 v3(160.02,159.28)
CFG1: length 67.1
  TOP w0.102: CPU.F15 v3(160.01,161.11) ; v3(123.28,196.44) 123.28,196.3 R40.2 122.55,195.97 122.55,196.14 121.94,196.75 121.66,197.03 121.66,197.53 121.65,197.53 XDP_CPU.11
  BOTTOM w0.102: v3(160.01,161.11) 160.01,161.12 159.47,161.66 159.47,164.91 160.36,165.79 160.36,168.63 157.11,171.88 147.97,171.88 137.07,182.78 137.07,188.31 134.65,190.73 134.65,192.74 133.64,193.75 132.8,194.59 131.15,194.59 130.7,195.05 127.76,195.05 127.13,195.68 124.06,195.68 123.3,196.44 v3(123.28,196.44) v2(122.49,196.44)
CFG2: length 73.9
  TOP w0.102: CPU.F16 v3(160.94,161.12) ; R45.2 123.74,195.87 123.74,196.7 123.36,197.08 123.24,197.21 122.66,197.79 XDP_CPU.15 122.66,200.16 v1(122.96,200.46)
  BOTTOM w0.102: v3(160.94,161.12) 161.35,161.53 161.35,162.14 161.67,162.47 161.98,162.47 162.69,163.18 162.69,169 157.85,173.83 148.68,173.83 138.92,183.59 138.92,189.1 136.51,191.52 136.51,193.51 135.47,194.55 135.47,197.05 135.24,197.28 134.85,197.28 133.96,198.17 133.05,198.17 132.82,198.4 126.63,198.4 v2(126.37,198.66) 126.37,198.88 124.35,200.9 123.98,200.9 123.54,200.46 v1(122.96,200.46)
CFG3: length 88.2
  TOP w0.102: R46.2 123.99,196.31 123.99,196.78 123.16,197.61 XDP_CPU.17 123.16,199.89 123.4,200.13 v1(123.4,200.94) 122.82,200.94 122.28,200.41 119.15,200.41 117.67,198.93 117.67,195.54 118.33,194.88 R97.1 ; CPU.H16 v3(160.94,159.29)
  BOTTOM w0.102: v3(160.94,159.29) 161.42,159.78 161.42,161.28 161.73,161.59 162.01,161.59 162.3,161.87 162.3,162.41 162.92,163.03 162.92,169.09 157.95,174.06 148.82,174.06 139.15,183.73 139.15,189.2 136.74,191.61 136.74,193.6 136.13,194.21 v2(136.13,196.18) 136.13,196.72 134.45,198.39 133.15,198.39 132.91,198.63 127.68,198.63 126.95,199.36 126.21,199.36 124.44,201.13 123.58,201.13 v1(123.4,200.94)
CFG4: length 73.8
  TOP w0.102: R47.2 125.66,196.01 XDP_CPU.27 125.66,200.93 v1(126.43,201.7)
  TOP w0.254: CPU.F19 163.25,160.66 v3(163.71,161.12)
  BOTTOM w0.102: v1(126.43,201.7) 126.57,201.57 126.57,200.78 126.82,200.53 127.41,200.53 128.17,199.77 133.39,199.77 133.62,199.54 134.96,199.54 137.85,196.65 137.85,195.11 138.64,194.32 138.64,191.34 140.29,189.69 140.29,184.2 149.29,175.21 158.42,175.21 164.64,168.99 v2(164.64,168.24) 164.99,167.89 164.99,166.02 164.57,165.6 164.57,165.03 164.8,164.8 164.8,163.31 164.11,162.62 164.11,161.8 163.71,161.39 v3(163.71,161.12)
CFG5: length 76.1
  TOP w0.102: v1(127.11,201.7) 127.11,201.69 126.16,200.74 XDP_CPU.29 126.16,195.92 R38.2
  TOP w0.254: CPU.H18 v3(162.75,159.28)
  BOTTOM w0.102: v1(127.11,201.7) 127.12,201.7 127.7,201.12 127.7,200.56 128.26,200 133.48,200 133.72,199.77 135.06,199.77 135.86,198.97 v2(136.38,198.97) 136.38,198.45 138.11,196.73 138.11,195.18 138.87,194.41 138.87,191.43 140.52,189.78 140.52,184.3 149.39,175.43 158.52,175.43 165.22,168.73 165.22,165.92 164.8,165.5 164.8,165.18 165,164.98 165,163.19 164.36,162.54 164.36,161.76 164.17,161.56 164.17,160.97 163.86,160.66 163.53,160.66 163.24,160.38 163.24,159.77 v3(162.75,159.28)
CFG6: length 76
  TOP w0.102: R1.2 127.16,196.14 XDP_CPU.33 127.16,200.13 127.43,200.41 127.43,201 v1(128.29,201.85)
  TOP w0.254: CPU.G21 v3(165.51,160.21)
  BOTTOM w0.102: v3(165.51,160.21) 165.08,160.64 165.08,161.33 165.33,161.58 165.66,161.58 166.48,162.39 166.48,168.12 166.48,168.76 158.9,176.35 149.77,176.35 141.43,184.68 141.43,191.55 140.79,192.19 140.09,192.19 139.78,192.51 139.78,195.53 139.05,196.27 139.05,197.26 138.3,198 v2(138.3,198.62) 138.3,199.43 137.48,200.26 136.04,200.26 134.98,201.32 133.78,201.32 133.39,200.93 130.34,200.93 129.25,202.02 129.05,202.02 128.99,202.08 128.52,202.08 v1(128.29,201.85)
CFG7: length 75.2
  TOP w0.102: R12.2 127.66,196.65 XDP_CPU.35 127.66,200.9 128.18,201.42 128.68,201.42 128.88,201.62 v1(128.9,201.62)
  TOP w0.254: CPU.H20 v3(164.6,159.3)
  BOTTOM w0.102: v1(128.9,201.62) 129.33,201.62 130.25,200.7 133.49,200.7 133.88,201.09 134.79,201.09 135.85,200.03 136.84,200.03 137.43,199.44 137.43,198.55 138.82,197.16 138.82,196.17 139.56,195.44 139.56,192.36 v2(140.53,191.39) 141.21,190.71 141.21,184.58 149.67,176.12 158.8,176.12 166.25,168.67 166.25,163.39 165.05,162.18 165.05,161.58 164.88,161.41 164.88,160.54 165.03,160.39 165.03,159.72 v3(164.6,159.3)
CFG8: length 77.1
  TOP w0.102: R15.2 117.9,206.61 118.07,206.44 119.65,206.44 120.09,205.99 120.82,205.99 121.15,205.66 XDP_CPU.10 121.15,202.27 v1(120.94,202.06) ; CPU.G16 v3(160.94,160.21)
  BOTTOM w0.102: v3(160.94,160.21) 160.48,160.66 160.48,163.17 160.79,163.47 160.79,168.52 157.2,172.11 148.06,172.11 137.29,182.88 137.29,188.43 134.88,190.84 134.88,192.84 132.89,194.82 131.24,194.82 131.07,195 130.79,195.28 127.86,195.28 127.22,195.91 124.47,195.91 123.2,197.18 122.81,197.18 v2(121.3,198.7) 120.94,199.05 v1(120.94,202.06)
CFG9: length 74.7
  TOP w0.102: CPU.E16 160.48,161.59 v3(160.92,162.03) ; v1(121.65,202.06) XDP_CPU.12 121.65,205.61 121.28,205.98 121.16,205.98 120.91,206.22 120.29,206.22 119.82,206.69 118.94,206.69 118.79,206.84 R16.2
  BOTTOM w0.102: v1(121.65,202.06) 121.65,199.76 v2(123.19,198.23) 123.59,197.82 125.35,197.82 125.97,197.21 127.08,197.21 128.19,196.09 131.22,196.09 131.67,195.64 133.23,195.64 135.69,193.17 135.69,191.18 138.11,188.77 138.11,183.24 148.42,172.92 157.54,172.92 161.83,168.63 161.83,166.43 161.91,166.35 161.91,164.67 161.36,164.12 161.36,162.47 v3(160.92,162.03)
CFG10: length 76.1
  TOP w0.102: v1(123.17,202.97) 123.17,203.11 122.66,203.63 XDP_CPU.16 122.66,205.68 122.32,206.02 121.57,206.02 121.13,206.45 120.55,206.45 R17.2
  TOP w0.254: CPU.F17 161.42,160.66 v3(161.88,161.12)
  BOTTOM w0.102: v3(161.88,161.12) 161.88,161.16 162.55,161.83 162.55,162.38 163.15,162.98 163.15,169.19 158.04,174.29 148.91,174.29 139.38,183.82 139.38,189.29 136.96,191.7 136.96,193.81 136.78,194 136.78,196.4 134.56,198.62 133.24,198.62 133.01,198.86 127.78,198.86 127.04,199.59 126.3,199.59 124.37,201.52 123.6,201.52 v2(123.17,201.95) v1(123.17,202.97)
CFG11: length 77.1
  TOP w0.102: CPU.H17 v3(161.85,159.29) ; v1(124.05,202.34) 123.73,202.66 123.64,202.75 123.64,203.11 123.16,203.59 XDP_CPU.18 123.16,205.63 123.15,205.63 122.53,206.25 121.8,206.25 120.97,207.07 R21.2
  BOTTOM w0.102: v3(161.85,159.29) 162.32,159.76 162.32,161.31 162.78,161.77 162.78,162.32 163.38,162.92 163.38,169.28 158.14,174.52 149.01,174.52 139.61,183.92 139.61,189.39 137.19,191.8 137.19,193.54 v2(137.56,193.91) 137.56,194.27 137.03,194.8 137.03,196.48 134.66,198.85 133.34,198.85 133.1,199.09 127.89,199.09 127.12,199.85 126.45,199.85 124.05,202.25 v1(124.05,202.34)
CFG12: length 78.5
  TOP w0.102: v1(126.51,202.93) 126.29,202.93 125.66,203.56 XDP_CPU.28 125.66,205.61 125.02,206.25 v1(124.97,206.25) 124.26,206.25 123.61,206.89 R22.2
  TOP w0.254: v3(163.68,159.29) CPU.G20
  BOTTOM w0.102: v1(126.51,202.93) 127.54,201.89 127.54,201.63 127.93,201.24 127.93,200.66 128.36,200.23 133.58,200.23 133.81,199.99 135.24,199.99 135.66,199.57 136.65,199.57 136.97,199.25 136.97,198.26 138.33,196.9 138.33,195.65 139.1,194.89 139.1,191.55 140.75,189.9 140.75,184.39 149.48,175.66 158.61,175.66 165.79,168.48 165.79,163.65 164.59,162.45 164.59,161.7 164.4,161.51 164.4,160.64 164.14,160.38 CPU.G20 v3(163.68,159.29) ; v1(124.97,206.25) 124.44,205.72 v2(123.86,205.72)
CFG13: length 77.5
  TOP w0.102: XDP_CPU.30 126.16,205.85 v1(125.76,206.25) 125.64,206.25 124.88,207 R25.2 ; CPU.F20 v3(164.6,160.21)
  BOTTOM w0.102: v3(164.6,160.21) 164.62,160.23 164.62,161.44 164.82,161.64 164.82,162.24 166.02,163.45 166.02,168.58 158.71,175.89 149.58,175.89 140.98,184.49 140.98,190 139.33,191.65 139.33,195.31 138.59,196.04 138.59,196.97 137.2,198.36 137.2,199.35 136.74,199.8 135.76,199.8 135.33,200.22 133.91,200.22 133.67,200.46 128.45,200.46 128.16,200.75 128.16,201.34 127.77,201.72 127.77,202.75 127.7,202.82 127.7,203.13 127.41,203.43 126.23,203.43 125.76,203.89 v2(125.76,205.4) v1(125.76,206.25)
CFG14: length 75.9
  TOP w0.102: R26.2 125.9,206.87 v1(126.53,206.25) 126.65,206.25 127.16,205.74 XDP_CPU.34
  TOP w0.254: v3(165.51,161.15) 165.05,160.69 CPU.F21
  BOTTOM w0.102: v3(165.51,161.15) 165.52,161.15 166.71,162.33 166.71,168.03 166.71,168.86 158.99,176.58 149.86,176.58 141.66,184.77 141.66,191.64 140.72,192.58 140.72,192.83 140.01,193.54 140.01,195.62 139.27,196.36 139.27,197.35 138.99,197.64 138.99,199.07 137.57,200.49 136.14,200.49 135.08,201.55 133.68,201.55 133.28,201.16 130.44,201.16 129.34,202.25 129.14,202.25 128.64,202.75 128.64,202.94 128.64,203.28 127.87,204.05 v2(127.11,204.05) 126.53,204.64 v1(126.53,206.25)
CFG15: length 79.8
  TOP w0.102: CPU.H19 v3(163.68,158.38) ; XDP_CPU.36 127.66,205.88 127.28,206.25 v1(127.28,206.38) 127.09,206.57 R27.2
  BOTTOM w0.102: v3(163.68,158.38) 164.17,158.86 164.78,158.86 165.05,159.13 165.05,159.44 165.37,159.76 165.68,159.76 165.97,160.05 165.97,161.18 166.94,162.15 166.94,167.93 166.94,167.93 166.94,168.88 166.94,168.97 159.1,176.81 149.96,176.81 142,184.76 142,195.84 140.75,197.09 139.93,197.09 139.22,197.8 139.22,199.17 137.67,200.72 136.31,200.72 135.24,201.78 133.55,201.78 133.16,201.39 130.53,201.39 129.44,202.48 129.24,202.48 128.87,202.85 128.87,204.82 v2(127.9,205.79) 127.69,205.79 127.28,206.2 v1(127.28,206.38)
CFG16: length 83.9
  TOP w0.102: R30.2 116.88,206.71 117.38,206.21 119.55,206.21 120.15,205.61 XDP_CPU.6 120.15,203.05 119.38,202.28 v1(119.26,202.28) ; CPU.E14 v3(159.12,161.11)
  BOTTOM w0.102: v1(119.26,202.28) 119.41,202.12 119.41,199.83 v2(118.55,198.97) 118.07,198.48 118.07,193.72 118.63,193.16 123.8,193.16 124.51,192.46 126.85,192.46 127.18,192.13 129.41,192.13 131.36,194.08 132.67,194.08 133.19,193.56 133.19,193.56 134.2,192.55 134.2,190.54 136.61,188.12 136.61,182.59 147.78,171.42 156.81,171.42 159.9,168.33 159.9,167.14 158.91,166.15 158.91,165.01 159.06,164.86 159.06,161.17 v3(159.12,161.11)
CFG17: length 84.8
  TOP w0.102: v1(119.27,202.91) 119.65,203.3 XDP_CPU.4 119.65,205.69 119.36,205.98 117.21,205.98 R31.2 ; CPU.F14 158.7,160.66 159.1,160.26 v3(159.1,160.21)
  BOTTOM w0.102: v3(159.1,160.21) 159.1,160.53 159,160.63 158.99,160.63 158.69,160.93 158.69,161.29 158.86,161.47 158.86,164.78 158.71,164.93 158.71,166.27 159.67,167.23 159.67,168.12 156.6,171.2 147.68,171.2 136.38,182.5 136.38,188.03 133.97,190.44 133.97,192.46 132.57,193.85 131.46,193.85 129.5,191.9 127.08,191.9 126.75,192.23 124.41,192.23 123.98,192.66 118.81,192.66 117.84,193.63 117.84,200.56 v2(118.57,201.29) 118.57,202.21 v1(119.27,202.91)
CFG18: length 75.7
  TOP w0.102: v1(125.51,202.44) 125.5,202.44 125.5,202.45 125.26,202.69 125.06,202.89 125.06,203.13 124.66,203.53 XDP_CPU.24 124.66,205.66 124.3,206.02 124.16,206.02 123.96,206.22 123.45,206.22 R33.2
  TOP w0.254: CPU.G18 v3(162.75,160.19)
  BOTTOM w0.102: v3(162.75,160.19) 163.24,160.68 163.24,162.2 164.6,163.56 164.6,164.62 164.18,165.04 164.18,166.1 v2(164.36,166.28) 163.99,166.66 163.99,169.31 158.33,174.98 149.2,174.98 140.06,184.11 140.06,189.59 138.41,191.24 138.41,194.22 137.62,195.01 137.62,196.55 134.86,199.31 133.53,199.31 133.29,199.54 128.07,199.54 127.31,200.3 126.72,200.3 125.51,201.52 v1(125.51,202.44)
CFG19: length 75.4
  TOP w0.102: R37.2 122.31,206.48 122.62,206.48 123.11,205.99 123.86,205.99 124.16,205.7 XDP_CPU.22 124.16,203.55 124.68,203.02 v1(124.68,202.34)
  TOP w0.254: CPU.F18 v3(162.77,161.12)
  BOTTOM w0.102: v3(162.77,161.12) 163.02,161.38 163.02,162.28 164.39,163.65 164.39,164.44 163.74,165.1 163.74,169.24 158.23,174.75 149.1,174.75 139.83,184.01 139.83,189.48 137.81,191.51 v2(137.81,192.02) 138.18,192.4 138.18,194.13 137.38,194.93 137.38,196.46 134.76,199.08 133.43,199.08 133.2,199.31 127.98,199.31 127.22,200.08 126.63,200.08 124.68,202.02 v1(124.68,202.34)
CFG_RCOMP: length 5
  TOP w0.102: CPU.M11 155.79,155.05 155.79,154.28 157.46,152.6 v1(158.25,152.6) 158.78,152.07 R49.2
CIIC_SCL: length 3.8
  TOP w0.102: RTK_VGA.2 150.18,221.89 149.78,221.49 149.78,220.92 RG3.1 RG5.2 148.51,221.33 v1(148.58,221.4)
CIIC_SDA: length 3.1
  TOP w0.102: RTK_VGA.3 150.68,221.75 150.53,221.6 v1(150.53,221.49) 150.29,221.25 150.29,220.92 RG4.1 RG6.2
CK_100M_H_ITP: length 142.8
  TOP w0.089: U4.L2 63.34,135.02 63.34,135.47 63.27,135.53 63.27,136.01 63.03,136.26 63.03,136.74 63.11,136.83 63.42,136.83 v1(63.58,136.66)
  TOP w0.102: v1(95.85,151.31) 95.85,151.6 96.07,151.82 96.26,151.82 96.79,152.35 98.04,152.35 103.4,157.71 104.25,157.71 112.02,165.48 112.02,172.36 106.81,177.57 106.81,194.25 113.8,201.24 113.8,208.78 115.97,210.96 125.73,210.96 128.39,208.3 128.39,206.49 128.87,206.01 128.87,205.79 128.66,205.58 XDP_CPU.40 ; v1(69.5,145.54) 69.23,145.27 69.23,145.03 69.53,144.73 72.7,144.73 76.43,141 81.08,141 82.02,140.06 82.02,139.78 v1(82.3,139.5)
  BOTTOM w0.089: v1(63.58,136.66) 63.79,136.87 63.98,136.87 64.24,137.13 64.24,137.93 64.25,137.93 64.25,137.95
  BOTTOM w0.102: v1(95.85,151.31) 95.85,151.6 95.7,151.75 94.2,151.75 91.98,149.53 91.98,149.07 89.52,146.61 87.18,146.61 86.12,145.55 86.12,145.01 85.78,144.67 85.24,144.67 81.95,141.38 v2(81.95,140.67) 81.95,139.66 82.11,139.5 v1(82.3,139.5) ; 64.25,137.95 64.25,138.15 64.97,138.87 64.97,140.79 69.24,145.06 69.24,145.28 v1(69.5,145.54)
CK_100M_H_ITP#: length 142.7
  TOP w0.089: v1(63.58,137.52) 63.58,137.26 63.34,137.02 63.04,137.02 62.83,136.82 62.83,136.18 63.08,135.93 U4.L1
  TOP w0.102: v1(81.54,139.5) 81.82,139.78 81.82,139.97 80.99,140.8 76.34,140.8 72.62,144.53 69.45,144.53 69.03,144.95 69.03,145.25 v1(68.74,145.54) ; v1(95.85,152.2) 96.03,152.02 96.17,152.02 96.7,152.55 97.95,152.55 103.31,157.91 104.17,157.91 111.82,165.57 111.82,172.28 106.61,177.49 106.61,194.34 113.6,201.32 113.6,208.87 115.89,211.16 125.82,211.16 128.59,208.39 128.59,206.58 129.08,206.09 129.08,205.8 129.16,205.72 XDP_CPU.42
  BOTTOM w0.089: 64.05,137.95 64.05,137.93 64.05,137.93 64.05,137.21 63.9,137.06 63.74,137.06 63.58,137.22 v1(63.58,137.52)
  BOTTOM w0.102: v1(68.74,145.54) 69.04,145.24 69.04,145.14 64.77,140.87 64.77,138.95 64.05,138.23 64.05,137.95 ; v1(81.54,139.5) 81.75,139.7 81.75,140.04 81.37,140.42 81.37,140.91 81.75,141.29 81.75,141.46 v2(85.54,145.25) 87.1,146.81 89.43,146.81 91.78,149.16 91.78,149.61 94.12,151.96 95.61,151.96 v1(95.85,152.2)
CK_PE_100M_DMI: length 129.9
  TOP w0.089: 66.89,137.19 66.84,137.19 66.84,137.19 66.56,137.19 64.92,135.55 64.92,135.1 U4.G2 ; CPU.W5 v3(149.97,148.32)
  TOP w0.102: 66.89,137.19 68.87,137.19 69.04,137.36 72.63,137.36 74.25,135.74 78.05,135.74 79.97,133.82 79.97,122.25 80.65,121.57 80.65,120.14 80.09,119.58 80.09,118.9 80.3,118.69 80.3,118.41 v1(80.18,118.29)
  BOTTOM w0.102: v3(149.97,148.32) 149.67,148.62 149.39,148.62 149.27,148.5 142.95,148.5 140.93,150.52 128.92,150.52 125.69,147.28 v2(125.69,138.4) 125.69,137.1 126.07,136.72 126.07,136.23 112.95,123.11 110.47,123.11 106.76,119.41 100.04,119.41 98.8,118.16 86.28,118.16 85.82,118.62 84.91,118.62 82.47,116.19 80.61,116.19 80.22,116.58 80.22,117.2 80.65,117.63 80.65,118.19 80.55,118.29 v1(80.18,118.29)
