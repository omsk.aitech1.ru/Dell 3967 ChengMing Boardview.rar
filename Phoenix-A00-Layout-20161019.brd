# Allegro board Phoenix-A00-Layout-20161019.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
C0805
  oval 1.016x1.27 smd: 1(-0.889,0) 2(0.889,0)
C0805_H37
  oval 1.016x1.27 smd: 1(-0.889,0) 2(0.889,0)
C0805_H53
  oval 1.016x1.27 smd: 1(-0.889,0) 2(0.889,0)
C1206_H53
  oval 1.016x1.626 smd: 1(-1.524,0) 2(1.524,0)
C1206_H71
  oval 1.016x1.626 smd: 1(-1.524,0) 2(1.524,0)
C1206_H73
  oval 1.016x1.626 smd: 1(-1.524,0) 2(1.524,0)
CE25D63H95
  round 1.372 hole 0.965: 1(-1.25,0) 2(1.25,0)
CE25D63H125
  round 1.27 hole 0.864: 1(-1.25,0) 2(1.25,0)
CE35D80H90
  round 1.372 hole 0.965: 1(-1.75,0) 2(1.75,0)
CE35D80H130
  round 1.372 hole 0.965: 1(-1.75,0) 2(1.75,0)
CK45X44S90_H236
  round 1.422 hole 1.016: 1(-2.25,2.2) 2(2.25,-2.2)
CK_260X165_461X382
  round 2.21 hole 1.702: 1(-3.3,2.1)
  oval 2.464x3.15 hole 1.702x2.388 rot 57.5: 2(3.299,-2.1)
CK_272X185_461X382_H343
  round 1.905 hole 1.397: 1(-3.45,2.35)
  oval 2.159x2.87 hole 1.397x2.108 rot 55.7: 2(3.45,-2.35)
CL_LGA1151_PHOENIX
  round 5.004 hole 5.004 unplated: (-37.5,37.5) (-37.5,-37.5) (37.5,37.5) (37.5,-37.5)
  round 0.508 hole 0.305: 5(-37.5,41.2) 6(-35.325,40.493) 7(-33.981,38.643) 8(-33.981,36.356) 9(-35.325,34.506) 10(-37.5,33.8) 11(-39.675,34.506) 12(-41.019,36.356) 13(-41.019,38.643) 14(-39.675,40.493) 15(37.5,41.2) 16(39.675,40.493) 17(41.019,38.643) 18(41.019,36.356) 19(39.675,34.506) 20(37.5,33.8) 21(35.325,34.506) 22(33.981,36.356) 23(33.981,38.643) 24(35.325,40.493) 25(-37.5,-33.8) 26(-35.325,-34.506) 27(-33.981,-36.356) 28(-33.981,-38.643) 29(-35.325,-40.493) 30(-37.5,-41.2) 31(-39.675,-40.493) 32(-41.019,-38.643) 33(-41.019,-36.356) 34(-39.675,-34.506) 35(37.5,-33.8) 36(39.675,-34.506) 37(41.019,-36.356) 38(41.019,-38.643) 39(39.675,-40.493) 40(37.5,-41.2) 41(35.325,-40.493) 42(33.981,-38.643) 43(33.981,-36.356) 44(35.325,-34.506)
D0603_H31
  oval 0.914x0.762 smd: 1(-0.686,0) 2(0.686,0)
DDR4_288_67_5591X256
  oval 1.118x2.591 hole 1.118x2.591 unplated: (-5.65,2.7) (132.3,2.7)
  oval 1.194x2.438 hole 1.194x2.438 unplated: (68.9,2.7)
  rect 0.965x0.965 hole 0.66: 1(0,0)
  round 0.965 hole 0.66: 2(0.85,1.6) 3(1.7,0) 4(2.55,1.6) 5(3.4,0) 6(4.25,1.6) 7(5.1,0) 8(5.95,1.6) 9(6.8,0) 10(7.65,1.6) 11(8.5,0) 12(9.35,1.6) 13(10.2,0) 14(11.05,1.6) 15(11.9,0) 16(12.75,1.6) 17(13.6,0) 18(14.45,1.6) 19(15.3,0) 20(16.15,1.6) 21(17,0) 22(17.85,1.6) 23(18.7,0) 24(19.55,1.6) 25(20.4,0) 26(21.25,1.6) 27(22.1,0) 28(22.95,1.6) 29(23.8,0) 30(24.65,1.6) 31(25.5,0) 32(26.35,1.6) 33(27.2,0) 34(28.05,1.6) 35(28.9,0) 36(29.75,1.6) 37(30.6,0) 38(31.45,1.6) 39(32.3,0) 40(33.15,1.6) 41(34,0) 42(34.85,1.6) 43(35.7,0) 44(36.55,1.6) 45(37.4,0) 46(38.25,1.6) 47(39.1,0) 48(39.95,1.6) 49(40.8,0) 50(41.65,1.6) 51(42.5,0) 52(43.35,1.6) 53(44.2,0) 54(45.05,1.6) 55(45.9,0) 56(46.75,1.6) 57(47.6,0) 58(48.45,1.6) 59(49.3,0) 60(50.15,1.6) 61(51,0) 62(51.85,1.6) 63(52.7,0) 64(53.55,1.6) 65(54.4,0) 66(55.25,1.6) 67(56.1,0) 68(56.95,1.6) 69(57.8,0) 70(58.65,1.6) 71(59.5,0) 72(60.35,1.6) 73(61.2,0) 74(62.05,1.6) 75(62.9,0) 76(63.75,1.6) 77(64.6,0) 78(70.55,1.6) 79(71.4,0) 80(72.25,1.6) 81(73.1,0) 82(73.95,1.6) 83(74.8,0) 84(75.65,1.6) 85(76.5,0) 86(77.35,1.6) 87(78.2,0) 88(79.05,1.6) 89(79.9,0) 90(80.75,1.6) 91(81.6,0) 92(82.45,1.6) 93(83.3,0) 94(84.15,1.6) 95(85,0) 96(85.85,1.6) 97(86.7,0) 98(87.55,1.6) 99(88.4,0) 100(89.25,1.6) 101(90.1,0) 102(90.95,1.6) 103(91.8,0) 104(92.65,1.6) 105(93.5,0) 106(94.35,1.6) 107(95.2,0) 108(96.05,1.6) 109(96.9,0) 110(97.75,1.6) 111(98.6,0) 112(99.45,1.6) 113(100.3,0) 114(101.15,1.6) 115(102,0) 116(102.85,1.6) 117(103.7,0) 118(104.55,1.6) 119(105.4,0) 120(106.25,1.6) 121(107.1,0) 122(107.95,1.6) 123(108.8,0) 124(109.65,1.6) 125(110.5,0) 126(111.35,1.6) 127(112.2,0) 128(113.05,1.6) 129(113.9,0) 130(114.75,1.6) 131(115.6,0) 132(116.45,1.6) 133(117.3,0) 134(118.15,1.6) 135(119,0) 136(119.85,1.6) 137(120.7,0) 138(121.55,1.6) 139(122.4,0) 140(123.25,1.6) 141(124.1,0) 142(124.95,1.6) 143(125.8,0) 144(126.65,1.6) 145(0,3.8) 146(0.85,5.4) 147(1.7,3.8) 148(2.55,5.4) 149(3.4,3.8) 150(4.25,5.4) 151(5.1,3.8) 152(5.95,5.4) 153(6.8,3.8) 154(7.65,5.4) 155(8.5,3.8) 156(9.35,5.4) 157(10.2,3.8) 158(11.05,5.4) 159(11.9,3.8) 160(12.75,5.4) 161(13.6,3.8) 162(14.45,5.4) 163(15.3,3.8) 164(16.15,5.4) 165(17,3.8) 166(17.85,5.4) 167(18.7,3.8) 168(19.55,5.4) 169(20.4,3.8) 170(21.25,5.4) 171(22.1,3.8) 172(22.95,5.4) 173(23.8,3.8) 174(24.65,5.4) 175(25.5,3.8) 176(26.35,5.4) 177(27.2,3.8) 178(28.05,5.4) 179(28.9,3.8) 180(29.75,5.4) 181(30.6,3.8) 182(31.45,5.4) 183(32.3,3.8) 184(33.15,5.4) 185(34,3.8) 186(34.85,5.4) 187(35.7,3.8) 188(36.55,5.4) 189(37.4,3.8) 190(38.25,5.4) 191(39.1,3.8) 192(39.95,5.4) 193(40.8,3.8) 194(41.65,5.4) 195(42.5,3.8) 196(43.35,5.4) 197(44.2,3.8) 198(45.05,5.4) 199(45.9,3.8) 200(46.75,5.4) 201(47.6,3.8) 202(48.45,5.4) 203(49.3,3.8) 204(50.15,5.4) 205(51,3.8) 206(51.85,5.4) 207(52.7,3.8) 208(53.55,5.4) 209(54.4,3.8) 210(55.25,5.4) 211(56.1,3.8) 212(56.95,5.4) 213(57.8,3.8) 214(58.65,5.4) 215(59.5,3.8) 216(60.35,5.4) 217(61.2,3.8) 218(62.05,5.4) 219(62.9,3.8) 220(63.75,5.4) 221(64.6,3.8) 222(70.55,5.4) 223(71.4,3.8) 224(72.25,5.4) 225(73.1,3.8) 226(73.95,5.4) 227(74.8,3.8) 228(75.65,5.4) 229(76.5,3.8) 230(77.35,5.4) 231(78.2,3.8) 232(79.05,5.4) 233(79.9,3.8) 234(80.75,5.4) 235(81.6,3.8) 236(82.45,5.4) 237(83.3,3.8) 238(84.15,5.4) 239(85,3.8) 240(85.85,5.4) 241(86.7,3.8) 242(87.55,5.4) 243(88.4,3.8) 244(89.25,5.4) 245(90.1,3.8) 246(90.95,5.4) 247(91.8,3.8) 248(92.65,5.4) 249(93.5,3.8) 250(94.35,5.4) 251(95.2,3.8) 252(96.05,5.4) 253(96.9,3.8) 254(97.75,5.4) 255(98.6,3.8) 256(99.45,5.4) 257(100.3,3.8) 258(101.15,5.4) 259(102,3.8) 260(102.85,5.4) 261(103.7,3.8) 262(104.55,5.4) 263(105.4,3.8) 264(106.25,5.4) 265(107.1,3.8) 266(107.95,5.4) 267(108.8,3.8) 268(109.65,5.4) 269(110.5,3.8) 270(111.35,5.4) 271(112.2,3.8) 272(113.05,5.4) 273(113.9,3.8) 274(114.75,5.4) 275(115.6,3.8) 276(116.45,5.4) 277(117.3,3.8) 278(118.15,5.4) 279(119,3.8) 280(119.85,5.4) 281(120.7,3.8) 282(121.55,5.4) 283(122.4,3.8) 284(123.25,5.4) 285(124.1,3.8) 286(124.95,5.4) 287(125.8,3.8) 288(126.65,5.4)
DFN8C2
  oval 0.254x0.813 smd: 1(-0.75,-1.118) 2(-0.25,-1.118) 3(0.25,-1.118) 4(0.75,-1.118) 5(0.75,1.118) 6(0.25,1.118) 7(-0.25,1.118) 8(-0.75,1.118)
  rect 1.524x0.914 smd: 9(0,0)
DFN10C
  oval 0.254x0.813 smd: 1(-1,-1.524) 2(-0.5,-1.524) 3(0,-1.524) 4(0.5,-1.524) 5(1,-1.524) 6(1,1.524) 7(0.5,1.524) 8(0,1.524) 9(-0.5,1.524) 10(-1,1.524)
  rect 2.388x1.651 smd: 11(0,0)
DFN_7_50_205X219
  rect 0.508x0.508 smd: 1(-1.905,-2.825)
  custom 0.475x0.475 smd: 2(0,-1.825)
  rect 4.801x2.591 smd: 3(0,0.575)
  rect 0.508x0.66 smd: 4(1.905,2.8) 5(0.635,2.8) 6(-0.635,2.8) 7(-1.905,2.8)
DFN_8_50_238
  rect 0.508x0.66 smd: 1(-1.905,-2.755) 2(-0.635,-2.755) 3(0.635,-2.755) 4(1.905,-2.755)
  rect 4.597x4.674 smd: 5(0,0.735)
DFN_10_20_39
  oval 0.254x0.762 smd: 1(-1,-0.5) 2(-0.5,-0.5) 4(0.5,-0.5) 5(1,-0.5) 6(1,0.5) 7(0.5,0.5) 9(-0.5,0.5) 10(-1,0.5)
  oval 0.381x1.753 smd: 3(0,0)
DSUBX2_24_1220X887
  rect 1.321x1.321 hole 1.016: A1(0,0)
  round 1.321 hole 1.016: A2(2.77,0) A3(5.54,0) A4(8.31,0) A5(11.08,0) A6(1.385,-2.84) A7(4.155,-2.84) A8(6.925,-2.84) A9(9.695,-2.84) B1(9.87,-6.75) B2(7.58,-6.75) B3(5.29,-6.75) B4(3,-6.75) B5(0.71,-6.75) B6(11.015,-9.29) B7(8.725,-9.29) B8(6.435,-9.29) B9(4.145,-9.29) B10(1.855,-9.29) B11(9.87,-11.83) B12(7.58,-11.83) B13(5.29,-11.83) B14(3,-11.83) B15(0.71,-11.83)
  round 3.861 hole 3.251: H1(-6.955,-9.29) H2(18.035,-9.29) H3(-6.955,-1.42) H4(18.035,-1.42)
FD40
  round 1.016 smd: 1(0,0)
FS0805
  oval 1.016x1.524 smd: 1(-1.1,0) 2(1.1,0)
FS1311_H28
  oval 1.016x2.54 smd: 1(-1.5,0) 2(1.5,0)
FS_70_83X53
  oval 1.016x1.473 smd: 1(-1.1,0) 2(1.1,0)
FVS_DELL
  rect 1.422x1.422 hole 0.965: 1(0,0)
H2M-1
  rect 1.422x1.422 hole 1.016: 1(0,0)
  round 1.422 hole 1.016: 2(2.54,0)
H2X7MZ
  rect 1.422x1.422 hole 1.016: 1(0,0)
  round 1.422 hole 1.016: 2(2.54,0) 3(0,-2.54) 4(2.54,-2.54) 5(0,-5.08) 6(2.54,-5.08) 7(0,-7.62) 8(2.54,-7.62) 9(0,-10.16) 10(2.54,-10.16) 11(0,-12.7) 12(2.54,-12.7) 13(0,-15.24) 14(2.54,-15.24)
H2X7MZO9
  rect 1.524x1.524 hole 1.118: 1(0,0)
  round 1.524 hole 1.118: 2(2.54,0) 3(0,-2.54) 4(2.54,-2.54) 5(0,-5.08) 6(2.54,-5.08) 7(0,-7.62) 8(2.54,-7.62) 10(2.54,-10.16) 11(0,-12.7) 12(2.54,-12.7) 13(0,-15.24) 14(2.54,-15.24)
HB9003
  round 1.372 hole 0.965: 1(-2.54,0) 2(2.54,0)
HDMI_19_59_591X492
  round 1.702 hole 1.702 unplated: (-4.75,-6.5)
  rect 0.762x0.762 hole 0.559: 1(0,0)
  round 0.762 hole 0.559: 2(-0.75,-1.5) 3(-1.5,0) 4(-1.5,-3) 5(-2.25,-1.5) 6(-3,-3) 7(-3,0) 8(-3.75,-1.5) 9(-4.5,0) 10(-4.5,-3) 11(-5.25,-1.5) 12(-6,-3) 13(-6,0) 14(-6.75,-1.5) 15(-7.5,0) 16(-7.5,-3) 17(-8.25,-1.5) 18(-9,-3) 19(-9,0)
  oval 1.651x2.87 hole 0.889x2.108: 20(2.5,-1.25) 21(-12,-1.25) 22(2.5,-7.25) 23(-12,-7.25)
HF5504
  round 1.168 hole 1.168 unplated: (-3.016,1.8)
  rect 1.219x1.219 hole 0.813: 1(2.984,0)
  round 1.219 hole 0.813: 2(0.984,0) 3(-1.016,0) 4(-3.016,0)
HFAN_3_100_300X224_C2
  round 1.27 hole 1.27 unplated: (0,-2.16)
  rect 1.575x1.575 hole 1.168: 1(0,0)
  round 1.575 hole 1.168: 2(2.54,0) 3(5.08,0)
HFAN_4_100_400X225_P2
  round 1.27 hole 1.27 unplated: (2.54,-2.16)
  rect 1.549x1.549 hole 1.143: 1(0,0)
  round 1.549 hole 1.143: 2(2.54,0) 3(5.08,0) 4(7.62,0)
HH_2X7_79_O10
  rect 1.321x1.321 hole 0.914: 1(0,0)
  round 1.321 hole 0.914: 2(0,2) 3(2,0) 4(2,2) 5(4,0) 6(4,2) 7(6,0) 8(6,2) 9(8,0) 11(10,0) 12(10,2) 13(12,0) 14(12,2)
HMS2X30CZ_MVB_DELL
  round 1.016 hole 1.016 unplated: (-10.071,2.658) (10.071,2.658)
  oval 0.254x2.286 smd: 1(-7.256,-2.857) 2(-7.256,2.857) 3(-6.755,-2.857) 4(-6.755,2.857) 5(-6.255,-2.857) 6(-6.255,2.857) 7(-5.754,-2.857) 8(-5.754,2.857) 9(-5.254,-2.857) 10(-5.254,2.857) 11(-4.754,-2.857) 12(-4.754,2.857) 13(-4.253,-2.857) 14(-4.253,2.857) 15(-3.753,-2.857) 16(-3.753,2.857) 17(-3.252,-2.857) 18(-3.252,2.857) 19(-2.752,-2.857) 20(-2.752,2.857) 21(-2.252,-2.857) 22(-2.252,2.857) 23(-1.751,-2.857) 24(-1.751,2.857) 25(-1.251,-2.857) 26(-1.251,2.857) 27(-0.751,-2.857) 28(-0.751,2.857) 29(-0.25,-2.857) 30(-0.25,2.857) 31(0.25,-2.857) 32(0.25,2.857) 33(0.751,-2.857) 34(0.751,2.857) 35(1.251,-2.857) 36(1.251,2.857) 37(1.751,-2.857) 38(1.751,2.857) 39(2.252,-2.857) 40(2.252,2.857) 41(2.752,-2.857) 42(2.752,2.857) 43(3.252,-2.857) 44(3.252,2.857) 45(3.753,-2.857) 46(3.753,2.857) 47(4.253,-2.857) 48(4.253,2.857) 49(4.754,-2.857) 50(4.754,2.857) 51(5.254,-2.857) 52(5.254,2.857) 53(5.754,-2.857) 54(5.754,2.857) 55(6.255,-2.857) 56(6.255,2.857) 57(6.755,-2.857) 58(6.755,2.857) 59(7.256,-2.857) 60(7.256,2.857)
HS_2C_906X906
  round 0 smd: 1(0,0)
L4S12X20V_H43
  oval 0.762x0.406 smd: 1(-0.931,0.403) 2(-0.931,-0.403) 3(0.931,-0.403) 4(0.931,0.403)
L4540
  rect 3.505x4.013 smd: 1(-4.75,0) 2(4.75,0)
L_2_244_295X268
  rect 2.489x3.505 smd: 1(-3.1,0) 2(3.1,0)
L_2_244_299X268
  rect 2.489x3.505 smd: 1(-3.1,0) 2(3.1,0)
LED_2_90_201X260
  round 1.651 hole 1.651 unplated: (0,-2.8)
  round 1.346 hole 0.94: 1(-1.14,0) 2(1.14,0)
LGA1151
  round 0.508 smd: A4(-16.187,18.288) A5(-15.273,18.288) AT40(18.931,-14.63) AU1(-18.931,-14.63) AU39(18.016,-15.545) AU40(18.931,-15.545) AV1(-18.931,-15.545) AV2(-18.016,-15.545) AV38(17.102,-16.459) AV39(18.016,-16.459) AW2(-18.016,-16.459) AW3(-17.102,-16.459) AW37(16.187,-17.374) AW38(17.102,-17.374) AY3(-17.102,-17.374) AY4(-16.187,-17.374) B3(-17.102,17.374) B4(-16.187,17.374) B37(16.187,16.459) B38(17.102,16.459) B39(18.016,16.459) C2(-18.016,16.459) C3(-17.102,16.459) C39(18.016,15.545) C40(18.931,15.545) D1(-18.931,15.545) D2(-18.016,15.545) D40(18.931,14.63) E40(18.931,13.716)
  round 0.429 smd: A6(-14.359,18.288) A7(-13.444,18.288) A25(3.015,18.288) A26(3.929,18.288) A27(4.844,18.288) A28(5.758,18.288) A29(6.673,18.288) A30(7.587,18.288) AA5(-15.273,0) AA6(-14.359,0) AA7(-13.444,0) AA8(-12.53,0) AA33(12.53,-0.914) AA34(13.444,-0.914) AA35(14.359,-0.914) AA36(15.273,-0.914) AA37(16.187,-0.914) AA38(17.102,-0.914) AB5(-15.273,-0.914) AB6(-14.359,-0.914) AB7(-13.444,-0.914) AB8(-12.53,-0.914) AB33(12.53,-1.829) AB34(13.444,-1.829) AB35(14.359,-1.829) AB36(15.273,-1.829) AB37(16.187,-1.829) AC5(-15.273,-1.829) AC6(-14.359,-1.829) AC7(-13.444,-1.829) AC8(-12.53,-1.829) AC33(12.53,-2.743) AC34(13.444,-2.743) AC35(14.359,-2.743) AC36(15.273,-2.743) AC37(16.187,-2.743) AD3(-17.102,-2.743) AD4(-16.187,-2.743) AD5(-15.273,-2.743) AD6(-14.359,-2.743) AD7(-13.444,-2.743) AD8(-12.53,-2.743) AD33(12.53,-3.658) AD34(13.444,-3.658) AD35(14.359,-3.658) AD36(15.273,-3.658) AD37(16.187,-3.658) AE3(-17.102,-3.658) AE4(-16.187,-3.658) AE5(-15.273,-3.658) AE6(-14.359,-3.658) AE7(-13.444,-3.658) AE8(-12.53,-3.658) AE33(12.53,-4.572) AE34(13.444,-4.572) AE35(14.359,-4.572) AE36(15.273,-4.572) AE37(16.187,-4.572) AE38(17.102,-4.572) AF4(-16.187,-4.572) AF5(-15.273,-4.572) AF6(-14.359,-4.572) AF7(-13.444,-4.572) AF8(-12.53,-4.572) AF33(12.53,-5.486) AF34(13.444,-5.486) AF35(14.359,-5.486) AF36(15.273,-5.486) AF37(16.187,-5.486) AF38(17.102,-5.486) AG4(-16.187,-5.486) AG5(-15.273,-5.486) AG6(-14.359,-5.486) AG7(-13.444,-5.486) AG8(-12.53,-5.486) AG33(12.53,-6.401) AG34(13.444,-6.401) AG35(14.359,-6.401) AG36(15.273,-6.401) AG37(16.187,-6.401) AG38(17.102,-6.401) AH3(-17.102,-6.401) AH4(-16.187,-6.401) AH5(-15.273,-6.401) AH6(-14.359,-6.401) AH7(-13.444,-6.401) AH8(-12.53,-6.401) AH33(12.53,-7.315) AH34(13.444,-7.315) AH35(14.359,-7.315) AH36(15.273,-7.315) AH37(16.187,-7.315) AH38(17.102,-7.315) AJ3(-17.102,-7.315) AJ4(-16.187,-7.315) AJ5(-15.273,-7.315) AJ6(-14.359,-7.315) AJ7(-13.444,-7.315) AJ8(-12.53,-7.315) AJ9(-11.615,-7.315) AJ11(-7.587,-8.23) AJ12(-6.673,-8.23) AJ13(-5.758,-8.23) AJ14(-4.844,-8.23) AJ15(-3.929,-8.23) AJ16(-3.015,-8.23) AJ17(-2.101,-8.23) AJ18(-1.186,-8.23) AJ19(-0.272,-8.23) AJ20(0.643,-8.23) AJ21(1.557,-8.23) AJ22(2.471,-8.23) AJ23(3.386,-8.23) AJ24(4.3,-8.23) AJ25(5.215,-8.23) AJ26(6.129,-8.23) AJ27(7.043,-8.23) AJ28(7.958,-8.23) AJ29(8.872,-8.23) AJ30(9.787,-8.23) AJ31(10.701,-8.23) AJ32(11.615,-8.23) AJ33(12.53,-8.23) AJ34(13.444,-8.23) AJ35(14.359,-8.23) AJ36(15.273,-8.23) AJ37(16.187,-8.23) AJ38(17.102,-8.23) AK3(-17.102,-8.23) AK4(-16.187,-8.23) AK5(-15.273,-8.23) AK6(-14.359,-8.23) AK7(-13.444,-8.23) AK8(-12.53,-8.23) AK9(-11.615,-8.23) AK10(-10.701,-8.23) AK11(-7.587,-9.144) AK12(-6.673,-9.144) AK13(-5.758,-9.144) AK14(-4.844,-9.144) AK15(-3.929,-9.144) AK16(-3.015,-9.144) AK17(-2.101,-9.144) AK18(-1.186,-9.144) AK19(-0.272,-9.144) AK20(0.643,-9.144) AK21(1.557,-9.144) AK22(2.471,-9.144) AK23(3.386,-9.144) AK24(4.3,-9.144) AK25(5.215,-9.144) AK26(6.129,-9.144) AK27(7.043,-9.144) AK28(7.958,-9.144) AK29(8.872,-9.144) AK30(9.787,-9.144) AK31(10.701,-9.144) AK32(11.615,-9.144) AK33(12.53,-9.144) AK34(13.444,-9.144) AK35(14.359,-9.144) AK36(15.273,-9.144) AK37(16.187,-9.144) AK38(17.102,-9.144) AL3(-17.102,-9.144) AL4(-16.187,-9.144) AL5(-15.273,-9.144) AL6(-14.359,-9.144) AL7(-13.444,-9.144) AL8(-12.53,-9.144) AL9(-11.615,-9.144) AL10(-10.701,-9.144) AL11(-7.587,-10.058) AL12(-6.673,-10.058) AL13(-5.758,-10.058) AL14(-4.844,-10.058) AL15(-3.929,-10.058) AL16(-3.015,-10.058) AL17(-2.101,-10.058) AL18(-1.186,-10.058) AL19(-0.272,-10.058) AL20(0.643,-10.058) AL21(1.557,-10.058) AL22(2.471,-10.058) AL23(3.386,-10.058) AL24(4.3,-10.058) AL25(5.215,-10.058) AL26(6.129,-10.058) AL27(7.043,-10.058) AL28(7.958,-10.058) AL29(8.872,-10.058) AL30(9.787,-10.058) AL31(10.701,-10.058) AL32(11.615,-10.058) AL33(12.53,-10.058) AL34(13.444,-10.058) AL35(14.359,-10.058) AL36(15.273,-10.058) AL37(16.187,-10.058) AL38(17.102,-10.058) AM3(-17.102,-10.058) AM4(-16.187,-10.058) AM5(-15.273,-10.058) AM6(-14.359,-10.058) AM7(-13.444,-10.058) AM8(-12.53,-10.058) AM9(-11.615,-10.058) AM10(-10.701,-10.058) AM11(-7.587,-10.973) AM12(-6.673,-10.973) AM13(-5.758,-10.973) AM14(-4.844,-10.973) AM15(-3.929,-10.973) AM16(-3.015,-10.973) AM17(-2.101,-10.973) AM18(-1.186,-10.973) AM19(-0.272,-10.973) AM20(0.643,-10.973) AM21(1.557,-10.973) AM22(2.471,-10.973) AM23(3.386,-10.973) AM24(4.3,-10.973) AM25(5.215,-10.973) AM26(6.129,-10.973) AM27(7.043,-10.973) AM28(7.958,-10.973) AM29(8.872,-10.973) AM30(9.787,-10.973) AM31(10.701,-10.973) AM32(11.615,-10.973) AM33(12.53,-10.973) AM34(13.444,-10.973) AM35(14.359,-10.973) AM36(15.273,-10.973) AM37(16.187,-10.973) AM38(17.102,-10.973) AN3(-17.102,-10.973) AN4(-16.187,-10.973) AN5(-15.273,-10.973) AN6(-14.359,-10.973) AN7(-13.444,-10.973) AN8(-12.53,-10.973) AN9(-11.615,-10.973) AN10(-10.701,-10.973) AN11(-7.587,-11.887) AN12(-6.673,-11.887) AN13(-5.758,-11.887) AN14(-4.844,-11.887) AN15(-3.929,-11.887) AN16(-3.015,-11.887) AN17(-2.101,-11.887) AN18(-1.186,-11.887) AN19(-0.272,-11.887) AN20(0.643,-11.887) AN21(1.557,-11.887) AN22(2.471,-11.887) AN23(3.386,-11.887) AN24(4.3,-11.887) AN25(5.215,-11.887) AN26(6.129,-11.887) AN27(7.043,-11.887) AN28(7.958,-11.887) AN29(8.872,-11.887) AN30(9.787,-11.887) AN31(10.701,-11.887) AN32(11.615,-11.887) AN33(12.53,-11.887) AN34(13.444,-11.887) AN35(14.359,-11.887) AN36(15.273,-11.887) AN37(16.187,-11.887) AN38(17.102,-11.887) AP3(-17.102,-11.887) AP4(-16.187,-11.887) AP5(-15.273,-11.887) AP6(-14.359,-11.887) AP7(-13.444,-11.887) AP8(-12.53,-11.887) AP9(-11.615,-11.887) AP10(-10.701,-11.887) AP11(-7.587,-12.802) AP12(-6.673,-12.802) AP13(-5.758,-12.802) AP14(-4.844,-12.802) AP15(-3.929,-12.802) AP16(-3.015,-12.802) AP17(-2.101,-12.802) AP18(-1.186,-12.802) AP19(-0.272,-12.802) AP20(0.643,-12.802) AP21(1.557,-12.802) AP22(2.471,-12.802) AP23(3.386,-12.802) AP24(4.3,-12.802) AP25(5.215,-12.802) AP26(6.129,-12.802) AP27(7.043,-12.802) AP28(7.958,-12.802) AP29(8.872,-12.802) AP30(9.787,-12.802) AP31(10.701,-12.802) AP32(11.615,-12.802) AP33(12.53,-12.802) AP34(13.444,-12.802) AP35(14.359,-12.802) AP36(15.273,-12.802) AP37(16.187,-12.802) AP38(17.102,-12.802) AR3(-17.102,-12.802) AR4(-16.187,-12.802) AR5(-15.273,-12.802) AR6(-14.359,-12.802) AR7(-13.444,-12.802) AR8(-12.53,-12.802) AR9(-11.615,-12.802) AR10(-10.701,-12.802) AR11(-7.587,-13.716) AR12(-6.673,-13.716) AR13(-5.758,-13.716) AR14(-4.844,-13.716) AR15(-3.929,-13.716) AR16(-3.015,-13.716) AR17(-2.101,-13.716) AR18(-1.186,-13.716) AR19(-0.272,-13.716) AR20(0.643,-13.716) AR21(1.557,-13.716) AR22(2.471,-13.716) AR23(3.386,-13.716) AR24(4.3,-13.716) AR25(5.215,-13.716) AR26(6.129,-13.716) AR27(7.043,-13.716) AR28(7.958,-13.716) AR29(8.872,-13.716) AR30(9.787,-13.716) AR31(10.701,-13.716) AR32(11.615,-13.716) AR33(12.53,-13.716) AR34(13.444,-13.716) AR35(14.359,-13.716) AR36(15.273,-13.716) AR37(16.187,-13.716) AR38(17.102,-13.716) AT3(-17.102,-13.716) AT4(-16.187,-13.716) AT5(-15.273,-13.716) AT6(-14.359,-13.716) AT7(-13.444,-13.716) AT8(-12.53,-13.716) AT9(-11.615,-13.716) AT10(-10.701,-13.716) AT11(-7.587,-14.63) AT12(-6.673,-14.63) AT13(-5.758,-14.63) AT14(-4.844,-14.63) AT15(-3.929,-14.63) AT16(-3.015,-14.63) AT17(-2.101,-14.63) AT18(-1.186,-14.63) AT19(-0.272,-14.63) AT20(0.643,-14.63) AT21(1.557,-14.63) AT22(2.471,-14.63) AT23(3.386,-14.63) AT24(4.3,-14.63) AT25(5.215,-14.63) AT26(6.129,-14.63) AT27(7.043,-14.63) AT28(7.958,-14.63) AT29(8.872,-14.63) AT30(9.787,-14.63) AT31(10.701,-14.63) AT32(11.615,-14.63) AT33(12.53,-14.63) AT34(13.444,-14.63) AT35(14.359,-14.63) AT36(15.273,-14.63) AT37(16.187,-14.63) AT38(17.102,-14.63) AU3(-17.102,-14.63) AU4(-16.187,-14.63) AU5(-15.273,-14.63) AU6(-14.359,-14.63) AU7(-13.444,-14.63) AU8(-12.53,-14.63) AU9(-11.615,-14.63) AU10(-10.701,-14.63) AU11(-7.587,-15.545) AU12(-6.673,-15.545) AU13(-5.758,-15.545) AU14(-4.844,-15.545) AU15(-3.929,-15.545) AU16(-3.015,-15.545) AU17(-2.101,-15.545) AU18(-1.186,-15.545) AU19(-0.272,-15.545) AU20(0.643,-15.545) AU21(1.557,-15.545) AU24(4.3,-15.545) AU25(5.215,-15.545) AU26(6.129,-15.545) AU27(7.043,-15.545) AU28(7.958,-15.545) AU29(8.872,-15.545) AU30(9.787,-15.545) AU31(10.701,-15.545) AU32(11.615,-15.545) AU33(12.53,-15.545) AU34(13.444,-15.545) AU35(14.359,-15.545) AU36(15.273,-15.545) AU37(16.187,-15.545) AU38(17.102,-15.545) AV3(-17.102,-15.545) AV4(-16.187,-15.545) AV5(-15.273,-15.545) AV6(-14.359,-15.545) AV7(-13.444,-15.545) AV8(-12.53,-15.545) AV9(-11.615,-15.545) AV10(-10.701,-15.545) AV11(-7.587,-16.459) AV12(-6.673,-16.459) AV13(-5.758,-16.459) AV14(-4.844,-16.459) AV24(4.3,-16.459) AV25(5.215,-16.459) AV28(7.958,-16.459) AV29(8.872,-16.459) AV37(16.187,-16.459) AW4(-16.187,-16.459) AW9(-11.615,-16.459) AW10(-10.701,-16.459) AW11(-7.587,-17.374) AW12(-6.673,-17.374) AW13(-5.758,-17.374) AW14(-4.844,-17.374) AY10(-10.701,-17.374) B5(-15.273,17.374) B6(-14.359,17.374) B7(-13.444,17.374) B25(3.015,17.374) B26(3.929,17.374) B27(4.844,17.374) B28(5.758,17.374) B29(6.673,17.374) B30(7.587,17.374) B31(10.701,16.459) B32(11.615,16.459) B33(12.53,16.459) B34(13.444,16.459) B35(14.359,16.459) B36(15.273,16.459) C4(-16.187,16.459) C5(-15.273,16.459) C6(-14.359,16.459) C7(-13.444,16.459) C8(-12.53,16.459) C9(-11.615,16.459) C12(-8.872,16.459) C13(-7.958,16.459) C14(-7.043,16.459) C15(-6.129,16.459) C16(-5.215,16.459) C17(-4.3,16.459) C25(3.015,16.459) C26(3.929,16.459) C27(4.844,16.459) C28(5.758,16.459) C29(6.673,16.459) C30(7.587,16.459) C31(10.701,15.545) C32(11.615,15.545) C33(12.53,15.545) C34(13.444,15.545) C35(14.359,15.545) C36(15.273,15.545) C37(16.187,15.545) C38(17.102,15.545) D3(-17.102,15.545) D4(-16.187,15.545) D5(-15.273,15.545) D6(-14.359,15.545) D7(-13.444,15.545) D8(-12.53,15.545) D9(-11.615,15.545) D10(-10.701,15.545) D11(-9.787,15.545) D12(-8.872,15.545) D13(-7.958,15.545) D14(-7.043,15.545) D15(-6.129,15.545) D16(-5.215,15.545) D17(-4.3,15.545) D18(-3.386,15.545) D24(2.101,15.545) D25(3.015,15.545) D26(3.929,15.545) D27(4.844,15.545) D28(5.758,15.545) D29(6.673,15.545) D30(7.587,15.545) D31(10.701,14.63) D32(11.615,14.63) D33(12.53,14.63) D34(13.444,14.63) D35(14.359,14.63) D36(15.273,14.63) D37(16.187,14.63) D38(17.102,14.63) D39(18.016,14.63) E3(-17.102,14.63) E4(-16.187,14.63) E5(-15.273,14.63) E6(-14.359,14.63) E7(-13.444,14.63) E8(-12.53,14.63) E9(-11.615,14.63) E10(-10.701,14.63) E11(-9.787,14.63) E12(-8.872,14.63) E13(-7.958,14.63) E14(-7.043,14.63) E15(-6.129,14.63) E16(-5.215,14.63) E17(-4.3,14.63) E18(-3.386,14.63) E19(-2.471,14.63) E21(-0.643,14.63) E23(1.186,14.63) E24(2.101,14.63) E25(3.015,14.63) E26(3.929,14.63) E27(4.844,14.63) E28(5.758,14.63) E29(6.673,14.63) E30(7.587,14.63) E31(10.701,13.716) E32(11.615,13.716) E33(12.53,13.716) E34(13.444,13.716) E35(14.359,13.716) E36(15.273,13.716) E37(16.187,13.716) E38(17.102,13.716) E39(18.016,13.716) F4(-16.187,13.716) F5(-15.273,13.716) F6(-14.359,13.716) F7(-13.444,13.716) F8(-12.53,13.716) F9(-11.615,13.716) F10(-10.701,13.716) F11(-9.787,13.716) F12(-8.872,13.716) F13(-7.958,13.716) F14(-7.043,13.716) F15(-6.129,13.716) F16(-5.215,13.716) F17(-4.3,13.716) F18(-3.386,13.716) F19(-2.471,13.716) F20(-1.557,13.716) F21(-0.643,13.716) F22(0.272,13.716) F23(1.186,13.716) F24(2.101,13.716) F25(3.015,13.716) F26(3.929,13.716) F27(4.844,13.716) F28(5.758,13.716) F29(6.673,13.716) F30(7.587,13.716) F31(10.701,12.802) F32(11.615,12.802) F33(12.53,12.802) F34(13.444,12.802) F35(14.359,12.802) F36(15.273,12.802) F37(16.187,12.802) F38(17.102,12.802) F39(18.016,12.802) F40(18.931,12.802) G3(-17.102,12.802) G4(-16.187,12.802) G5(-15.273,12.802) G6(-14.359,12.802) G7(-13.444,12.802) G8(-12.53,12.802) G9(-11.615,12.802) G10(-10.701,12.802) G11(-9.787,12.802) G12(-8.872,12.802) G13(-7.958,12.802) G14(-7.043,12.802) G15(-6.129,12.802) G16(-5.215,12.802) G17(-4.3,12.802) G18(-3.386,12.802) G19(-2.471,12.802) G20(-1.557,12.802) G21(-0.643,12.802) G22(0.272,12.802) G23(1.186,12.802) G24(2.101,12.802) G25(3.015,12.802) G26(3.929,12.802) G27(4.844,12.802) G28(5.758,12.802) G29(6.673,12.802) G30(7.587,12.802) G31(10.701,11.887) G32(11.615,11.887) G33(12.53,11.887) G34(13.444,11.887) G35(14.359,11.887) G36(15.273,11.887) G37(16.187,11.887) G38(17.102,11.887) G39(18.016,11.887) G40(18.931,11.887) H4(-16.187,11.887) H5(-15.273,11.887) H6(-14.359,11.887) H7(-13.444,11.887) H8(-12.53,11.887) H9(-11.615,11.887) H10(-10.701,11.887) H11(-9.787,11.887) H12(-8.872,11.887) H13(-7.958,11.887) H14(-7.043,11.887) H15(-6.129,11.887) H16(-5.215,11.887) H17(-4.3,11.887) H18(-3.386,11.887) H19(-2.471,11.887) H20(-1.557,11.887) H21(-0.643,11.887) H22(0.272,11.887) H23(1.186,11.887) H24(2.101,11.887) H25(3.015,11.887) H26(3.929,11.887) H27(4.844,11.887) H28(5.758,11.887) H29(6.673,11.887) H30(7.587,11.887) H31(10.701,10.973) H32(11.615,10.973) H33(12.53,10.973) H34(13.444,10.973) H35(14.359,10.973) H36(15.273,10.973) H37(16.187,10.973) H38(17.102,10.973) H39(18.016,10.973) H40(18.931,10.973) J3(-17.102,10.973) J4(-16.187,10.973) J5(-15.273,10.973) J6(-14.359,10.973) J7(-13.444,10.973) J8(-12.53,10.973) J9(-11.615,10.973) J10(-10.701,10.973) J11(-9.787,10.973) J12(-8.872,10.973) J13(-7.958,10.973) J14(-7.043,10.973) J15(-6.129,10.973) J16(-5.215,10.973) J17(-4.3,10.973) J18(-3.386,10.973) J19(-2.471,10.973) J20(-1.557,10.973) J21(-0.643,10.973) J22(0.272,10.973) J23(1.186,10.973) J24(2.101,10.973) J25(3.015,10.973) J26(3.929,10.973) J27(4.844,10.973) J28(5.758,10.973) J29(6.673,10.973) J30(7.587,10.973) J31(10.701,10.058) J32(11.615,10.058) J33(12.53,10.058) J34(13.444,10.058) J35(14.359,10.058) J36(15.273,10.058) J37(16.187,10.058) J38(17.102,10.058) J39(18.016,10.058) J40(18.931,10.058) K4(-16.187,10.058) K5(-15.273,10.058) K6(-14.359,10.058) K7(-13.444,10.058) K8(-12.53,10.058) K9(-11.615,10.058) K10(-10.701,10.058) K11(-9.787,10.058) K12(-8.872,10.058) K13(-7.958,10.058) K14(-7.043,10.058) K15(-6.129,10.058) K16(-5.215,10.058) K17(-4.3,10.058) K18(-3.386,10.058) K19(-2.471,10.058) K20(-1.557,10.058) K21(-0.643,10.058) K22(0.272,10.058) K23(1.186,10.058) K24(2.101,10.058) K25(3.015,10.058) K26(3.929,10.058) K27(4.844,10.058) K28(5.758,10.058) K29(6.673,10.058) K30(7.587,10.058) K31(10.701,9.144) K32(11.615,9.144) K33(12.53,9.144) K34(13.444,9.144) K35(14.359,9.144) K36(15.273,9.144) K37(16.187,9.144) K38(17.102,9.144) K39(18.016,9.144) K40(18.931,9.144) L3(-17.102,9.144) L4(-16.187,9.144) L5(-15.273,9.144) L6(-14.359,9.144) L7(-13.444,9.144) L8(-12.53,9.144) L9(-11.615,9.144) L10(-10.701,9.144) L11(-9.787,9.144) L12(-8.872,9.144) L13(-7.958,9.144) L14(-7.043,9.144) L15(-6.129,9.144) L16(-5.215,9.144) L17(-4.3,9.144) L18(-3.386,9.144) L19(-2.471,9.144) L20(-1.557,9.144) L21(-0.643,9.144) L22(0.272,9.144) L23(1.186,9.144) L24(2.101,9.144) L25(3.015,9.144) L26(3.929,9.144) L27(4.844,9.144) L28(5.758,9.144) L29(6.673,9.144) L30(7.587,9.144) L31(10.701,8.23) L32(11.615,8.23) L33(12.53,8.23) L34(13.444,8.23) L35(14.359,8.23) L36(15.273,8.23) L37(16.187,8.23) L38(17.102,8.23) L39(18.016,8.23) L40(18.931,8.23) M4(-16.187,8.23) M5(-15.273,8.23) M6(-14.359,8.23) M7(-13.444,8.23) M8(-12.53,8.23) M9(-11.615,8.23) M10(-10.701,8.23) M11(-9.787,8.23) M12(-8.872,8.23) M13(-7.958,8.23) M14(-7.043,8.23) M15(-6.129,8.23) M16(-5.215,8.23) M17(-4.3,8.23) M18(-3.386,8.23) M19(-2.471,8.23) M20(-1.557,8.23) M21(-0.643,8.23) M22(0.272,8.23) M23(1.186,8.23) M24(2.101,8.23) M25(3.015,8.23) M26(3.929,8.23) M27(4.844,8.23) M28(5.758,8.23) M29(6.673,8.23) M30(7.587,8.23) M32(11.615,7.315) M33(12.53,7.315) M34(13.444,7.315) M35(14.359,7.315) M36(15.273,7.315) M37(16.187,7.315) M38(17.102,7.315) M39(18.016,7.315) M40(18.931,7.315) N3(-17.102,7.315) N4(-16.187,7.315) N5(-15.273,7.315) N6(-14.359,7.315) N7(-13.444,7.315) N8(-12.53,7.315) N33(12.53,6.401) N34(13.444,6.401) N35(14.359,6.401) N36(15.273,6.401) N37(16.187,6.401) N38(17.102,6.401) N39(18.016,6.401) N40(18.931,6.401) P4(-16.187,6.401) P5(-15.273,6.401) P6(-14.359,6.401) P7(-13.444,6.401) P8(-12.53,6.401) P33(12.53,5.486) P34(13.444,5.486) P35(14.359,5.486) P36(15.273,5.486) P37(16.187,5.486) P38(17.102,5.486) P39(18.016,5.486) P40(18.931,5.486) R3(-17.102,5.486) R4(-16.187,5.486) R5(-15.273,5.486) R6(-14.359,5.486) R7(-13.444,5.486) R8(-12.53,5.486) R33(12.53,4.572) R34(13.444,4.572) R35(14.359,4.572) R36(15.273,4.572) R37(16.187,4.572) R38(17.102,4.572) R39(18.016,4.572) R40(18.931,4.572) T4(-16.187,4.572) T5(-15.273,4.572) T6(-14.359,4.572) T7(-13.444,4.572) T8(-12.53,4.572) T33(12.53,3.658) T34(13.444,3.658) T35(14.359,3.658) T36(15.273,3.658) T37(16.187,3.658) T38(17.102,3.658) T39(18.016,3.658) T40(18.931,3.658) U4(-16.187,3.658) U5(-15.273,3.658) U6(-14.359,3.658) U7(-13.444,3.658) U8(-12.53,3.658) U33(12.53,2.743) U34(13.444,2.743) U35(14.359,2.743) U36(15.273,2.743) U37(16.187,2.743) U38(17.102,2.743) U39(18.016,2.743) U40(18.931,2.743) V4(-16.187,2.743) V5(-15.273,2.743) V6(-14.359,2.743) V7(-13.444,2.743) V8(-12.53,2.743) V33(12.53,1.829) V34(13.444,1.829) V35(14.359,1.829) V36(15.273,1.829) V37(16.187,1.829) V38(17.102,1.829) V39(18.016,1.829) V40(18.931,1.829) W4(-16.187,1.829) W5(-15.273,1.829) W6(-14.359,1.829) W7(-13.444,1.829) W8(-12.53,1.829) W33(12.53,0.914) W34(13.444,0.914) W35(14.359,0.914) W36(15.273,0.914) W37(16.187,0.914) W38(17.102,0.914) Y5(-15.273,0.914) Y6(-14.359,0.914) Y7(-13.444,0.914) Y8(-12.53,0.914) Y33(12.53,0) Y34(13.444,0) Y35(14.359,0) Y36(15.273,0) Y37(16.187,0) Y38(17.102,0)
  oval 0.356x0.457 smd: A11(-9.787,18.288) A12(-8.872,18.288) A13(-7.958,18.288) A14(-7.043,18.288) A15(-6.129,18.288) A16(-5.215,18.288) A17(-4.3,18.288) A18(-3.386,18.288) A23(1.186,18.288) A24(2.101,18.288) AU22(2.471,-15.545) AU23(3.386,-15.545) AV15(-3.929,-16.459) AV16(-3.015,-16.459) AV17(-2.101,-16.459) AV18(-1.186,-16.459) AV19(-0.272,-16.459) AV20(0.643,-16.459) AV21(1.557,-16.459) AV22(2.471,-16.459) AV23(3.386,-16.459) AV26(6.129,-16.459) AV27(7.043,-16.459) AV30(9.787,-16.459) AV31(10.701,-16.459) AV32(11.615,-16.459) AV33(12.53,-16.459) AV34(13.444,-16.459) AV35(14.359,-16.459) AV36(15.273,-16.459) AW5(-15.273,-16.459) AW6(-14.359,-16.459) AW7(-13.444,-16.459) AW8(-12.53,-16.459) AW15(-3.929,-17.374) AW16(-3.015,-17.374) AW17(-2.101,-17.374) AW18(-1.186,-17.374) AW23(3.386,-17.374) AW24(4.3,-17.374) AW25(5.215,-17.374) AW26(6.129,-17.374) AW27(7.043,-17.374) AW28(7.958,-17.374) AW29(8.872,-17.374) AW30(9.787,-17.374) AW31(10.701,-17.374) AW32(11.615,-17.374) AW33(12.53,-17.374) AW34(13.444,-17.374) AW35(14.359,-17.374) AW36(15.273,-17.374) AY5(-15.273,-17.374) AY6(-14.359,-17.374) AY7(-13.444,-17.374) AY8(-12.53,-17.374) AY9(-11.615,-17.374) AY11(-7.587,-18.288) AY12(-6.673,-18.288) AY13(-5.758,-18.288) AY14(-4.844,-18.288) AY15(-3.929,-18.288) AY16(-3.015,-18.288) AY17(-2.101,-18.288) AY18(-1.186,-18.288) AY23(3.386,-18.288) AY24(4.3,-18.288) AY25(5.215,-18.288) AY26(6.129,-18.288) AY27(7.043,-18.288) AY28(7.958,-18.288) AY29(8.872,-18.288) AY30(9.787,-18.288) AY31(10.701,-18.288) B8(-12.53,17.374) B9(-11.615,17.374) B10(-10.701,17.374) B11(-9.787,17.374) B12(-8.872,17.374) B13(-7.958,17.374) B14(-7.043,17.374) B15(-6.129,17.374) B16(-5.215,17.374) B17(-4.3,17.374) B18(-3.386,17.374) B23(1.186,17.374) B24(2.101,17.374) C10(-10.701,16.459) C11(-9.787,16.459) C18(-3.386,16.459) C19(-2.471,16.459) C20(-1.557,16.459) C21(-0.643,16.459) C22(0.272,16.459) C23(1.186,16.459) C24(2.101,16.459) D19(-2.471,15.545) D20(-1.557,15.545) D21(-0.643,15.545) D22(0.272,15.545) D23(1.186,15.545) E20(-1.557,14.63) E22(0.272,14.63)
  oval 0.457x0.356 smd: AA3(-17.102,0) AA4(-16.187,0) AB3(-17.102,-0.914) AB4(-16.187,-0.914) AB38(17.102,-1.829) AB39(18.016,-1.829) AB40(18.931,-1.829) AC1(-18.931,-1.829) AC2(-18.016,-1.829) AC3(-17.102,-1.829) AC4(-16.187,-1.829) AC38(17.102,-2.743) AC39(18.016,-2.743) AC40(18.931,-2.743) AD1(-18.931,-2.743) AD2(-18.016,-2.743) AD38(17.102,-3.658) AD39(18.016,-3.658) AD40(18.931,-3.658) AE1(-18.931,-3.658) AE2(-18.016,-3.658) AE39(18.016,-4.572) AE40(18.931,-4.572) AF1(-18.931,-4.572) AF2(-18.016,-4.572) AF3(-17.102,-4.572) AF39(18.016,-5.486) AF40(18.931,-5.486) AG1(-18.931,-5.486) AG2(-18.016,-5.486) AG3(-17.102,-5.486) AG39(18.016,-6.401) AG40(18.931,-6.401) AH1(-18.931,-6.401) AH2(-18.016,-6.401) AH39(18.016,-7.315) AH40(18.931,-7.315) AJ1(-18.931,-7.315) AJ2(-18.016,-7.315) AJ39(18.016,-8.23) AJ40(18.931,-8.23) AK1(-18.931,-8.23) AK2(-18.016,-8.23) AK39(18.016,-9.144) AK40(18.931,-9.144) AL1(-18.931,-9.144) AL2(-18.016,-9.144) AL39(18.016,-10.058) AL40(18.931,-10.058) AM1(-18.931,-10.058) AM2(-18.016,-10.058) AM39(18.016,-10.973) AM40(18.931,-10.973) AN1(-18.931,-10.973) AN2(-18.016,-10.973) AN39(18.016,-11.887) AN40(18.931,-11.887) AP1(-18.931,-11.887) AP2(-18.016,-11.887) AP39(18.016,-12.802) AP40(18.931,-12.802) AR1(-18.931,-12.802) AR2(-18.016,-12.802) AR39(18.016,-13.716) AR40(18.931,-13.716) AT1(-18.931,-13.716) AT2(-18.016,-13.716) AT39(18.016,-14.63) AU2(-18.016,-14.63) E1(-18.931,14.63) E2(-18.016,14.63) F1(-18.931,13.716) F2(-18.016,13.716) F3(-17.102,13.716) G1(-18.931,12.802) G2(-18.016,12.802) H1(-18.931,11.887) H2(-18.016,11.887) H3(-17.102,11.887) J1(-18.931,10.973) J2(-18.016,10.973) K1(-18.931,10.058) K2(-18.016,10.058) K3(-17.102,10.058) L1(-18.931,9.144) L2(-18.016,9.144) M1(-18.931,8.23) M2(-18.016,8.23) M3(-17.102,8.23) N1(-18.931,7.315) N2(-18.016,7.315) P1(-18.931,6.401) P2(-18.016,6.401) P3(-17.102,6.401) R1(-18.931,5.486) R2(-18.016,5.486) T1(-18.931,4.572) T2(-18.016,4.572) T3(-17.102,4.572) U1(-18.931,3.658) U2(-18.016,3.658) U3(-17.102,3.658) V1(-18.931,2.743) V2(-18.016,2.743) V3(-17.102,2.743) W1(-18.931,1.829) W2(-18.016,1.829) W3(-17.102,1.829) Y3(-17.102,0.914) Y4(-16.187,0.914)
LOGO_DELL_PPID
  round 0 smd: 1(0,0)
MH40X80_10_DELL_L4
  round 4.064 hole 4.064 unplated: (0,0)
  round 0.508 hole 0.305: 1(0,3.302) 2(1.941,2.671) 3(3.14,1.02) 4(3.14,-1.02) 5(1.941,-2.671) 6(0,-3.302) 7(-1.941,-2.671) 8(-3.14,-1.02) 9(-3.14,1.02) 10(-1.941,2.671)
MH_146_320_10_M2_P2_DELL_L4
  round 3.708 hole 3.708 unplated: (0,0)
  round 0.508 hole 0.305: 1(0,3.086) 2(1.814,2.497) 3(2.935,0.954) 4(2.935,-0.954) 5(1.814,-2.497) 6(0,-3.086) 7(-1.814,-2.497) 8(-2.935,-0.954) 9(-2.935,0.954) 10(-1.814,2.497)
MOS_7_197X236
  rect 0.66x0.635 smd: 1(-1.905,-2.835) 5(1.905,2.835) 6(0.635,2.835) 7(-0.635,2.835) 8(-1.905,2.835)
  custom 0.485x0.485 smd: 2-4(0.115,-2.18)
  rect 4.013x2.159 smd: 9(0,0.525)
NGFF_75_20_862X232_KM
  round 1.092 hole 1.092 unplated: (-0.75,-4.725)
  round 1.6 hole 1.6 unplated: (19.25,-4.725)
  oval 0.305x1.549 smd: 1(0,0) 2(0.25,-6.45) 3(0.5,0) 4(0.75,-6.45) 5(1,0) 6(1.25,-6.45) 7(1.5,0) 8(1.75,-6.45) 9(2,0) 10(2.25,-6.45) 11(2.5,0) 12(2.75,-6.45) 13(3,0) 14(3.25,-6.45) 15(3.5,0) 16(3.75,-6.45) 17(4,0) 18(4.25,-6.45) 19(4.5,0) 20(4.75,-6.45) 21(5,0) 22(5.25,-6.45) 23(5.5,0) 24(5.75,-6.45) 25(6,0) 26(6.25,-6.45) 27(6.5,0) 28(6.75,-6.45) 29(7,0) 30(7.25,-6.45) 31(7.5,0) 32(7.75,-6.45) 33(8,0) 34(8.25,-6.45) 35(8.5,0) 36(8.75,-6.45) 37(9,0) 38(9.25,-6.45) 39(9.5,0) 40(9.75,-6.45) 41(10,0) 42(10.25,-6.45) 43(10.5,0) 44(10.75,-6.45) 45(11,0) 46(11.25,-6.45) 47(11.5,0) 48(11.75,-6.45) 49(12,0) 50(12.25,-6.45) 51(12.5,0) 52(12.75,-6.45) 53(13,0) 54(13.25,-6.45) 55(13.5,0) 56(13.75,-6.45) 57(14,0) 58(14.25,-6.45) 67(16.5,0) 68(16.75,-6.45) 69(17,0) 70(17.25,-6.45) 71(17.5,0) 72(17.75,-6.45) 73(18,0) 74(18.25,-6.45) 75(18.5,0)
  rect 1.194x2.743 smd: 76(-1.1,-0.225) 77(19.6,-0.225)
NP157X354_D8_SP
  round 1.499 hole 1.499 unplated: (-4,0) (4,0)
  oval 3.2x8.992 hole 3.2x8.992 unplated: (0,0)
  round 3.988 hole 3.988 unplated: (0,0)
PCI120
  round 2.438 hole 2.438 unplated: (0,0) (0,-64.77)
  rect 1.422x1.422 hole 1.016: A1(3.81,-1.905)
  round 1.422 hole 1.016: A2(1.27,-3.175) A3(3.81,-4.445) A4(1.27,-5.715) A5(3.81,-6.985) A6(1.27,-8.255) A7(3.81,-9.525) A8(1.27,-10.795) A9(3.81,-12.065) A10(1.27,-13.335) A11(3.81,-14.605) A12(1.27,-15.875) A13(3.81,-17.145) A14(1.27,-18.415) A15(3.81,-19.685) A16(1.27,-20.955) A17(3.81,-22.225) A18(1.27,-23.495) A19(3.81,-24.765) A20(1.27,-26.035) A21(3.81,-27.305) A22(1.27,-28.575) A23(3.81,-29.845) A24(1.27,-31.115) A25(3.81,-32.385) A26(1.27,-33.655) A27(3.81,-34.925) A28(1.27,-36.195) A29(3.81,-37.465) A30(1.27,-38.735) A31(3.81,-40.005) A32(1.27,-41.275) A33(3.81,-42.545) A34(1.27,-43.815) A35(3.81,-45.085) A36(1.27,-46.355) A37(3.81,-47.625) A38(1.27,-48.895) A39(3.81,-50.165) A40(1.27,-51.435) A41(3.81,-52.705) A42(1.27,-53.975) A43(3.81,-55.245) A44(1.27,-56.515) A45(3.81,-57.785) A46(1.27,-59.055) A47(3.81,-60.325) A48(1.27,-61.595) A49(3.81,-62.865) A52(1.27,-66.675) A53(3.81,-67.945) A54(1.27,-69.215) A55(3.81,-70.485) A56(1.27,-71.755) A57(3.81,-73.025) A58(1.27,-74.295) A59(3.81,-75.565) A60(1.27,-76.835) A61(3.81,-78.105) A62(1.27,-79.375) B1(-1.27,-1.905) B2(-3.81,-3.175) B3(-1.27,-4.445) B4(-3.81,-5.715) B5(-1.27,-6.985) B6(-3.81,-8.255) B7(-1.27,-9.525) B8(-3.81,-10.795) B9(-1.27,-12.065) B10(-3.81,-13.335) B11(-1.27,-14.605) B12(-3.81,-15.875) B13(-1.27,-17.145) B14(-3.81,-18.415) B15(-1.27,-19.685) B16(-3.81,-20.955) B17(-1.27,-22.225) B18(-3.81,-23.495) B19(-1.27,-24.765) B20(-3.81,-26.035) B21(-1.27,-27.305) B22(-3.81,-28.575) B23(-1.27,-29.845) B24(-3.81,-31.115) B25(-1.27,-32.385) B26(-3.81,-33.655) B27(-1.27,-34.925) B28(-3.81,-36.195) B29(-1.27,-37.465) B30(-3.81,-38.735) B31(-1.27,-40.005) B32(-3.81,-41.275) B33(-1.27,-42.545) B34(-3.81,-43.815) B35(-1.27,-45.085) B36(-3.81,-46.355) B37(-1.27,-47.625) B38(-3.81,-48.895) B39(-1.27,-50.165) B40(-3.81,-51.435) B41(-1.27,-52.705) B42(-3.81,-53.975) B43(-1.27,-55.245) B44(-3.81,-56.515) B45(-1.27,-57.785) B46(-3.81,-59.055) B47(-1.27,-60.325) B48(-3.81,-61.595) B49(-1.27,-62.865) B52(-3.81,-66.675) B53(-1.27,-67.945) B54(-3.81,-69.215) B55(-1.27,-70.485) B56(-3.81,-71.755) B57(-1.27,-73.025) B58(-3.81,-74.295) B59(-1.27,-75.565) B60(-3.81,-76.835) B61(-1.27,-78.105) B62(-3.81,-79.375)
PCIE36_X1
  round 2.337 hole 2.337 unplated: (0,0) (9.15,0)
  rect 1.016x1.016 hole 0.711: A1(-11.65,1.25)
  round 1.016 hole 0.711: A2(-10.65,3.25) A3(-9.65,1.25) A4(-8.65,3.25) A5(-7.65,1.25) A6(-6.65,3.25) A7(-5.65,1.25) A8(-4.65,3.25) A9(-3.65,1.25) A10(-2.65,3.25) A11(-1.65,1.25) A12(1.35,3.25) A13(2.35,1.25) A14(3.35,3.25) A15(4.35,1.25) A16(5.35,3.25) A17(6.35,1.25) A18(7.35,3.25) B1(-11.65,-1.25) B2(-10.65,-3.25) B3(-9.65,-1.25) B4(-8.65,-3.25) B5(-7.65,-1.25) B6(-6.65,-3.25) B7(-5.65,-1.25) B8(-4.65,-3.25) B9(-3.65,-1.25) B10(-2.65,-3.25) B11(-1.65,-1.25) B12(1.35,-3.25) B13(2.35,-1.25) B14(3.35,-3.25) B15(4.35,-1.25) B16(5.35,-3.25) B17(6.35,-1.25) B18(7.35,-3.25)
PCIE164_X16_RM_POUDRE
  round 2.362 hole 2.362 unplated: (-84.8,1.25) (-11.65,1.25)
  rect 1.016x1.016 hole 0.711: A1(0,0)
  round 1.016 hole 0.711: A2(-1,-2) A3(-2,0) A4(-3,-2) A5(-4,0) A6(-5,-2) A7(-6,0) A8(-7,-2) A9(-8,0) A10(-9,-2) A11(-10,0) A12(-13,-2) A13(-14,0) A14(-15,-2) A15(-16,0) A16(-17,-2) A17(-18,0) A18(-19,-2) A19(-20,0) A20(-21,-2) A21(-22,0) A22(-23,-2) A23(-24,0) A24(-25,-2) A25(-26,0) A26(-27,-2) A27(-28,0) A28(-29,-2) A29(-30,0) A30(-31,-2) A31(-32,0) A32(-33,-2) A33(-34,0) A34(-35,-2) A35(-36,0) A36(-37,-2) A37(-38,0) A38(-39,-2) A39(-40,0) A40(-41,-2) A41(-42,0) A42(-43,-2) A43(-44,0) A44(-45,-2) A45(-46,0) A46(-47,-2) A47(-48,0) A48(-49,-2) A49(-50,0) A50(-51,-2) A51(-52,0) A52(-53,-2) A53(-54,0) A54(-55,-2) A55(-56,0) A56(-57,-2) A57(-58,0) A58(-59,-2) A59(-60,0) A60(-61,-2) A61(-62,0) A62(-63,-2) A63(-64,0) A64(-65,-2) A65(-66,0) A66(-67,-2) A67(-68,0) A68(-69,-2) A69(-70,0) A70(-71,-2) A71(-72,0) A72(-73,-2) A73(-74,0) A74(-75,-2) A75(-76,0) A76(-77,-2) A77(-78,0) A78(-79,-2) A79(-80,0) A80(-81,-2) A81(-82,0) A82(-83,-2) B1(0,2.5) B2(-1,4.5) B3(-2,2.5) B4(-3,4.5) B5(-4,2.5) B6(-5,4.5) B7(-6,2.5) B8(-7,4.5) B9(-8,2.5) B10(-9,4.5) B11(-10,2.5) B12(-13,4.5) B13(-14,2.5) B14(-15,4.5) B15(-16,2.5) B16(-17,4.5) B17(-18,2.5) B18(-19,4.5) B19(-20,2.5) B20(-21,4.5) B21(-22,2.5) B22(-23,4.5) B23(-24,2.5) B24(-25,4.5) B25(-26,2.5) B26(-27,4.5) B27(-28,2.5) B28(-29,4.5) B29(-30,2.5) B30(-31,4.5) B31(-32,2.5) B32(-33,4.5) B33(-34,2.5) B34(-35,4.5) B35(-36,2.5) B36(-37,4.5) B37(-38,2.5) B38(-39,4.5) B39(-40,2.5) B40(-41,4.5) B41(-42,2.5) B42(-43,4.5) B43(-44,2.5) B44(-45,4.5) B45(-46,2.5) B46(-47,4.5) B47(-48,2.5) B48(-49,4.5) B49(-50,2.5) B50(-51,4.5) B51(-52,2.5) B52(-53,4.5) B53(-54,2.5) B54(-55,4.5) B55(-56,2.5) B56(-57,4.5) B57(-58,2.5) B58(-59,4.5) B59(-60,2.5) B60(-61,4.5) B61(-62,2.5) B62(-63,4.5) B63(-64,2.5) B64(-65,4.5) B65(-66,2.5) B66(-67,4.5) B67(-68,2.5) B68(-69,4.5) B69(-70,2.5) B70(-71,4.5) B71(-72,2.5) B72(-73,4.5) B73(-74,2.5) B74(-75,4.5) B75(-76,2.5) B76(-77,4.5) B77(-78,2.5) B78(-79,4.5) B79(-80,2.5) B80(-81,4.5) B81(-82,2.5) B82(-83,4.5)
PS2X2
  rect 1.321x1.321 hole 0.914: 1(-1.295,-2.997)
  round 1.321 hole 0.914: 2(1.295,-2.997) 3(-3.404,-2.997) 4(3.404,-2.997) 5(-3.404,-5.486) 6(3.404,-5.486) 7(-1.295,-10.058) 8(1.295,-10.058) 9(-3.404,-10.058) 10(3.404,-10.058) 11(-3.404,-12.548) 12(3.404,-12.548)
  round 2.946 hole 2.337: 13(-6.744,0) 14(0,0.813) 15(6.744,0) 16(-6.744,-10.058) 17(6.744,-10.058)
PWR4NWP1
  round 3.048 hole 3.048 unplated: (4.7,5.04)
  rect 1.93x1.93 hole 1.422: 1(0,0)
  round 1.93 hole 1.422: 2(-4.2,0) 3(0,5.5) 4(-4.2,5.5)
PWR_2X3_165_547X378_O6
  round 2.997 hole 2.997 unplated: (-4.7,-5.04)
  rect 1.905x1.905 hole 1.397: 1(0,0)
  round 1.905 hole 1.397: 2(4.2,0) 3(8.4,0) 4(0,-5.5) 5(4.2,-5.5)
PWR_2X4_165_PEGL_WL496
  round 2.997 hole 2.997 unplated: (-4.7,-5.04)
  rect 1.905x1.905 hole 1.397: 1(0,0)
  round 1.905 hole 1.397: 2(4.2,0) 3(8.4,0) 4(12.6,0) 5(0,-5.5) 6(4.2,-5.5) 7(8.4,-5.5) 8(12.6,-5.5)
QFN32C1
  oval 0.787x0.254 smd: 1(-2.487,1.75) 2(-2.487,1.25) 3(-2.487,0.75) 4(-2.487,0.25) 5(-2.487,-0.25) 6(-2.487,-0.75) 7(-2.487,-1.25) 8(-2.487,-1.75) 17(2.487,-1.75) 18(2.487,-1.25) 19(2.487,-0.75) 20(2.487,-0.25) 21(2.487,0.25) 22(2.487,0.75) 23(2.487,1.25) 24(2.487,1.75)
  oval 0.254x0.787 smd: 9(-1.75,-2.487) 10(-1.25,-2.487) 11(-0.75,-2.487) 12(-0.25,-2.487) 13(0.25,-2.487) 14(0.75,-2.487) 15(1.25,-2.487) 16(1.75,-2.487) 25(1.75,2.487) 26(1.25,2.487) 27(0.75,2.487) 28(0.25,2.487) 29(-0.25,2.487) 30(-0.75,2.487) 31(-1.25,2.487) 32(-1.75,2.487)
  rect 3.404x3.404 smd: 33(0,0)
QFN32C1_H31
  oval 0.787x0.254 smd: 1(-2.487,1.75) 2(-2.487,1.25) 3(-2.487,0.75) 4(-2.487,0.25) 5(-2.487,-0.25) 6(-2.487,-0.75) 7(-2.487,-1.25) 8(-2.487,-1.75) 17(2.487,-1.75) 18(2.487,-1.25) 19(2.487,-0.75) 20(2.487,-0.25) 21(2.487,0.25) 22(2.487,0.75) 23(2.487,1.25) 24(2.487,1.75)
  oval 0.254x0.787 smd: 9(-1.75,-2.487) 10(-1.25,-2.487) 11(-0.75,-2.487) 12(-0.25,-2.487) 13(0.25,-2.487) 14(0.75,-2.487) 15(1.25,-2.487) 16(1.75,-2.487) 25(1.75,2.487) 26(1.25,2.487) 27(0.75,2.487) 28(0.25,2.487) 29(-0.25,2.487) 30(-0.75,2.487) 31(-1.25,2.487) 32(-1.75,2.487)
  rect 3.404x3.404 smd: 33(0,0)
QFN_20_16_118X118
  oval 0.737x0.203 smd: 1(-1.511,0.8) 2(-1.511,0.4) 3(-1.511,0) 4(-1.511,-0.4) 5(-1.511,-0.8) 11(1.511,-0.8) 12(1.511,-0.4) 13(1.511,0) 14(1.511,0.4) 15(1.511,0.8)
  oval 0.203x0.737 smd: 6(-0.8,-1.511) 7(-0.4,-1.511) 8(0,-1.511) 9(0.4,-1.511) 10(0.8,-1.511) 16(0.8,1.511) 17(0.4,1.511) 18(0,1.511) 19(-0.4,1.511) 20(-0.8,1.511)
  rect 1.651x1.651 smd: 21(0,0)
QFN_23_20_157
  oval 0.787x0.254 smd: 1(-1.987,1.25) 2(-1.987,0.75) 3(-1.987,0.25) 4(-1.987,-0.25) 5(-1.987,-0.75) 6(-1.987,-1.25) 12(1.987,-1.25) 13(1.987,-0.75) 14(1.987,-0.25) 15(1.987,0.25) 16(1.987,0.75) 17(1.987,1.25)
  custom 0.345x0.345 smd: 7-9(-0.687,-0.526)
  custom 0.239x0.239 smd: 10-11(0.9,-0.526)
  oval 0.254x0.787 smd: 18(1.25,1.987) 19(0.75,1.987) 20(0.25,1.987) 21(-0.25,1.987) 22(-0.75,1.987) 23(-1.25,1.987)
QFN_32_16_157X157_TH106_H35
  oval 0.762x0.203 smd: 1(-2,1.4) 2(-2,1) 3(-2,0.6) 4(-2,0.2) 5(-2,-0.2) 6(-2,-0.6) 7(-2,-1) 8(-2,-1.4) 17(2,-1.4) 18(2,-1) 19(2,-0.6) 20(2,-0.2) 21(2,0.2) 22(2,0.6) 23(2,1) 24(2,1.4)
  oval 0.203x0.762 smd: 9(-1.4,-2) 10(-1,-2) 11(-0.6,-2) 12(-0.2,-2) 13(0.2,-2) 14(0.6,-2) 15(1,-2) 16(1.4,-2) 25(1.4,2) 26(1,2) 27(0.6,2) 28(0.2,2) 29(-0.2,2) 30(-0.6,2) 31(-1,2) 32(-1.4,2)
  rect 2.692x2.692 smd: 33(0,0)
QFN_48_16_236X236_TH173
  oval 0.889x0.203 smd: 1(-2.936,2.2) 2(-2.936,1.8) 3(-2.936,1.4) 4(-2.936,1) 5(-2.936,0.6) 6(-2.936,0.2) 7(-2.936,-0.2) 8(-2.936,-0.6) 9(-2.936,-1) 10(-2.936,-1.4) 11(-2.936,-1.8) 12(-2.936,-2.2) 25(2.936,-2.2) 26(2.936,-1.8) 27(2.936,-1.4) 28(2.936,-1) 29(2.936,-0.6) 30(2.936,-0.2) 31(2.936,0.2) 32(2.936,0.6) 33(2.936,1) 34(2.936,1.4) 35(2.936,1.8) 36(2.936,2.2)
  oval 0.203x0.889 smd: 13(-2.2,-2.936) 14(-1.8,-2.936) 15(-1.4,-2.936) 16(-1,-2.936) 17(-0.6,-2.936) 18(-0.2,-2.936) 19(0.2,-2.936) 20(0.6,-2.936) 21(1,-2.936) 22(1.4,-2.936) 23(1.8,-2.936) 24(2.2,-2.936) 37(2.2,2.936) 38(1.8,2.936) 39(1.4,2.936) 40(1,2.936) 41(0.6,2.936) 42(0.2,2.936) 43(-0.2,2.936) 44(-0.6,2.936) 45(-1,2.936) 46(-1.4,2.936) 47(-1.8,2.936) 48(-2.2,2.936)
  rect 4.394x4.394 smd: 49(0,0)
R0402
  oval 0.635x0.508 smd: 1(-0.445,0) 2(0.445,0)
R0402_S4MIL
  custom 0.127x0.127 smd: 1(-0.445,0) 2(0.445,0)
R0402_S4MIL_MVB
  custom 0.127x0.127 smd: 1(-0.445,0) 2(0.445,0)
R0402_S10MIL_MVB
  custom 0.127x0.127 smd: 1(-0.445,0) 2(0.445,0)
R0603
  oval 0.914x0.813 smd: 1(-0.686,0) 2(0.686,0)
R0603_S15MIL_MVB
  custom 0.191x0.191 smd: 1(-0.686,0) 2(0.686,0)
R0805
  oval 1.016x1.27 smd: 1(-0.889,0) 2(0.889,0)
SATA7_LE18
  rect 1.016x1.016 hole 0.711: 1(3.81,-1.5)
  round 1.016 hole 0.711: 2(2.755,0) 3(1.055,0) 4(0,-1.5) 5(-1.055,0) 6(-2.755,0) 7(-3.81,-1.5)
  round 1.88 hole 1.372: 8(6.27,-1.5) 9(-6.56,-0.5)
SC70_5
  oval 1.016x0.406 smd: 1(-1.067,0.65) 2(-1.067,0) 3(-1.067,-0.65) 4(1.067,-0.65) 5(1.067,0.65)
SHORTPAD_R10X16
  rect 0.254x0.407 smd: 1(0,0.267) 2(0,-0.267)
SK_BP_LGA115X
  round 3.81 hole 3.81 unplated: (-30.91,0) (30.11,18) (30.11,-18)
SMA
  round 2.286 smd: 1(-2.032,0) 2(2.032,0)
SO8_FL4
  oval 0.406x1.118 smd: 1(0.975,1.535) 2(0.325,1.535) 3(-0.325,1.535) 4(-0.975,1.535)
  rect 3.2x2.261 smd: 5(0,-0.764)
SOD123
  oval 1.016x1.27 smd: 1(-1.829,0) 2(1.829,0)
SOD123_H57
  oval 1.016x1.27 smd: 1(-1.829,0) 2(1.829,0)
SOD_323_H43_1
  oval 0.914x0.762 smd: 1(1.168,0) 2(-1.168,0)
SOD_523
  oval 0.787x0.61 smd: 1(-0.724,0) 2(0.724,0)
SOP8JA
  oval 0.508x1.778 smd: 1(-1.905,-2.667) 2(-0.635,-2.667) 3(0.635,-2.667) 4(1.905,-2.667) 5(1.905,2.667) 6(0.635,2.667) 7(-0.635,2.667) 8(-1.905,2.667)
SOP8JA-THP
  oval 0.508x1.778 smd: 1(-1.905,-2.667) 2(-0.635,-2.667) 3(0.635,-2.667) 4(1.905,-2.667) 5(1.905,2.667) 6(0.635,2.667) 7(-0.635,2.667) 8(-1.905,2.667)
  rect 3.404x2.515 smd: 9(0,0)
SOP8JA_SOCKET2
  rect 0.889x1.346 smd: 1(1.905,3.675) 2(0.635,3.675) 3(-0.635,3.675) 4(-1.905,3.675) 5(-1.905,-3.675) 6(-0.635,-3.675) 7(0.635,-3.675) 8(1.905,-3.675)
SOP8JG
  oval 0.508x1.778 smd: 1(-1.905,-3.556) 2(-0.635,-3.556) 3(0.635,-3.556) 4(1.905,-3.556) 5(1.905,3.556) 6(0.635,3.556) 7(-0.635,3.556) 8(-1.905,3.556)
SOT23_5
  oval 1.27x0.66 smd: 1(-1.27,0.94) 2(-1.27,0) 3(-1.27,-0.965) 4(1.27,-0.965) 5(1.27,0.94)
SOT23_6
  oval 1.118x0.61 smd: 1(-1.27,0.94) 2(-1.27,0) 3(-1.27,-0.94) 4(1.27,-0.94) 5(1.27,0) 6(1.27,0.94)
SOT23_8_H39
  oval 1.118x0.406 smd: 1(-1.219,0.975) 2(-1.219,0.325) 3(-1.219,-0.325) 4(-1.219,-0.975) 5(1.219,-0.975) 6(1.219,-0.325) 7(1.219,0.325) 8(1.219,0.975)
SOT23_123
  oval 1.27x1.016 smd: 1(-1.143,0.953) 2(-1.143,-0.953) 3(1.143,0)
SOT23_BEC
  oval 1.27x1.016 smd: B(-1.143,0.953) C(1.143,0) E(-1.143,-0.953)
SOT23_GSD
  oval 1.27x1.016 smd: D(1.143,0) G(-1.143,0.953) S(-1.143,-0.953)
SOT23_GSD_H43
  oval 1.27x1.016 smd: D(1.143,0) G(-1.143,0.953) S(-1.143,-0.953)
SOT353_5
  oval 1.016x0.406 smd: 1(-1.016,0.65) 2(-1.016,0) 3(-1.016,-0.65) 4(1.016,-0.65) 5(1.016,0.65)
SOT363M
  oval 0.914x0.406 smd: D1(-1.016,-0.65) D2(1.016,0.65) G1(1.016,0) G2(-1.016,0) S1(1.016,-0.65) S2(-1.016,0.65)
SOT363V
  oval 0.914x0.406 smd: 1(-1.016,0.65) 2(-1.016,0) 3(-1.016,-0.65) 4(1.016,-0.65) 5(1.016,0) 6(1.016,0.65)
SSOP20FB
  oval 0.406x1.778 smd: 1(-2.921,-3.429) 2(-2.271,-3.429) 3(-1.621,-3.429) 4(-0.971,-3.429) 5(-0.321,-3.429) 6(0.329,-3.429) 7(0.979,-3.429) 8(1.629,-3.429) 9(2.279,-3.429) 10(2.929,-3.429) 11(2.929,3.429) 12(2.279,3.429) 13(1.629,3.429) 14(0.979,3.429) 15(0.329,3.429) 16(-0.321,3.429) 17(-0.971,3.429) 18(-1.621,3.429) 19(-2.271,3.429) 20(-2.921,3.429)
SW_2_236X150
  rect 1.524x1.397 smd: 1(-3.25,0) 2(3.25,0)
SW_4_268X303_LED_A
  oval 0.914x1.118 hole 0.711: 1(-1.725,-1.15) 2(-0.575,-1.15) 3(0.575,-1.15) 4(1.725,-1.15)
  round 1.397 hole 0.991: 5(-1.6,1.05) 6(1.6,1.05)
TO92_EBC_H310
  round 1.092 hole 0.787: B(0,0) C(2.54,0) E(-2.54,0)
TO252_BCE_H94
  rect 1.499x2.489 smd: B(-2.3,-6.9) E(2.3,-6.9)
  rect 7.01x7.01 smd: C(0,0)
TO252_GDS
  rect 5.588x6.198 smd: D(0,0)
  rect 1.219x2.21 smd: G(-2.286,-6.388) S(2.286,-6.388)
TPC22B30D12
  round 0.559 hole 0.305: 1(0,0)
TPC30B
  round 0.762 smd: 1(0,0)
TQFN_32_20_197_TH124
  oval 0.914x0.254 smd: 1(-2.424,1.75) 2(-2.424,1.25) 3(-2.424,0.75) 4(-2.424,0.25) 5(-2.424,-0.25) 6(-2.424,-0.75) 7(-2.424,-1.25) 8(-2.424,-1.75) 17(2.424,-1.75) 18(2.424,-1.25) 19(2.424,-0.75) 20(2.424,-0.25) 21(2.424,0.25) 22(2.424,0.75) 23(2.424,1.25) 24(2.424,1.75)
  oval 0.254x0.914 smd: 9(-1.75,-2.424) 10(-1.25,-2.424) 11(-0.75,-2.424) 12(-0.25,-2.424) 13(0.25,-2.424) 14(0.75,-2.424) 15(1.25,-2.424) 16(1.75,-2.424) 25(1.75,2.424) 26(1.25,2.424) 27(0.75,2.424) 28(0.25,2.424) 29(-0.25,2.424) 30(-0.75,2.424) 31(-1.25,2.424) 32(-1.75,2.424)
  rect 3.15x3.15 smd: 33(0,0)
TSOP6QI
  oval 0.508x1.27 smd: 1(-0.95,-1.27) 2(0,-1.27) 3(0.95,-1.27) 4(0.95,1.27) 5(0,1.27) 6(-0.95,1.27)
TSOT23_5_H39
  oval 1.27x0.66 smd: 1(-1.27,0.94) 2(-1.27,0) 3(-1.27,-0.965) 4(1.27,-0.965) 5(1.27,0.94)
TSSOP8FA
  oval 1.778x0.406 smd: 1(2.743,-0.991) 2(2.743,-0.33) 3(2.743,0.33) 4(2.743,0.991) 5(-2.743,0.991) 6(-2.743,0.33) 7(-2.743,-0.33) 8(-2.743,-0.991)
UCSP_6_20_60X39
  round 0.305 smd: A1(-0.5,0.25) A2(0,0.25) A3(0.5,0.25) B1(-0.5,-0.25) B2(0,-0.25) B3(0.5,-0.25)
unnamed
  round 3.175 hole 3.175 unplated: (0,0)
USB3X4_18_79
  rect 1.016x1.016 hole 0.711: 1(-3.5,-0.84)
  round 1.016 hole 0.711: 2(-1,-0.84) 3(1,-0.84) 4(3.5,-0.84) 5(4,0.66) 6(2,0.66) 7(0,0.66) 8(-2,0.66) 9(-4,0.66) 10(-3.5,2.36) 11(-1,2.36) 12(1,2.36) 13(3.5,2.36) 14(4,3.86) 15(2,3.86) 16(0,3.86) 17(-2,3.86) 18(-4,3.86)
  round 2.946 hole 2.337: 19(-6.57,-2.84) 20(6.57,-2.84) 21(6.57,2.84) 22(-6.57,2.84)
USB4X2
  rect 1.321x1.321 hole 0.914: 1(3.5,-5.33)
  round 1.321 hole 0.914: 2(1,-5.33) 3(-1,-5.33) 4(-3.5,-5.33) 5(3.5,-2.71) 6(1,-2.71) 7(-1,-2.71) 8(-3.5,-2.71)
  round 2.946 hole 2.337: 9(6.57,-5.68) 10(-6.57,-5.68) 11(6.57,0) 12(-6.57,0)
USB4X2_RJ45P10_LED3
  rect 1.372x1.372 hole 0.965: 1(-3.505,2.713)
  round 1.372 hole 0.965: 2(-1.016,2.713) 3(0.991,2.713) 4(3.505,2.713) 5(-3.505,5.334) 6(-1.016,5.334) 7(0.991,5.334) 8(3.505,5.334)
  round 1.321 hole 0.914: 9(5.702,10.135) 10(4.432,12.675) 11(3.162,10.135) 12(1.892,12.675) 13(0.622,10.135) 14(-0.648,12.675) 15(-1.918,10.135) 16(-3.188,12.675) 17(-4.458,10.135) 18(-5.728,12.675) 19(-7.201,15.519) 20(-4.661,15.519) 21(4.661,15.519) 22(7.201,15.519)
  round 2.946 hole 2.337: 23(9.347,10.058) 24(6.553,5.685) 25(6.553,0) 26(9.347,-2.616) 27(-9.347,8.331) 28(-6.553,5.685) 29(-6.553,0) 30(-9.347,-2.616)
