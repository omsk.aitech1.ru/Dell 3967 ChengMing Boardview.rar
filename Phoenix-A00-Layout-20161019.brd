# Allegro board Phoenix-A00-Layout-20161019.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
VTQFP_128_16_630
  oval 1.524x0.203 smd: 1(-7.619,6.2) 2(-7.619,5.8) 3(-7.619,5.4) 4(-7.619,5) 5(-7.619,4.6) 6(-7.619,4.2) 7(-7.619,3.8) 8(-7.619,3.4) 9(-7.619,3) 10(-7.619,2.6) 11(-7.619,2.2) 12(-7.619,1.8) 13(-7.619,1.4) 14(-7.619,1) 15(-7.619,0.6) 16(-7.619,0.2) 17(-7.619,-0.2) 18(-7.619,-0.6) 19(-7.619,-1) 20(-7.619,-1.4) 21(-7.619,-1.8) 22(-7.619,-2.2) 23(-7.619,-2.6) 24(-7.619,-3) 25(-7.619,-3.4) 26(-7.619,-3.8) 27(-7.619,-4.2) 28(-7.619,-4.6) 29(-7.619,-5) 30(-7.619,-5.4) 31(-7.619,-5.8) 32(-7.619,-6.2) 65(7.619,-6.2) 66(7.619,-5.8) 67(7.619,-5.4) 68(7.619,-5) 69(7.619,-4.6) 70(7.619,-4.2) 71(7.619,-3.8) 72(7.619,-3.4) 73(7.619,-3) 74(7.619,-2.6) 75(7.619,-2.2) 76(7.619,-1.8) 77(7.619,-1.4) 78(7.619,-1) 79(7.619,-0.6) 80(7.619,-0.2) 81(7.619,0.2) 82(7.619,0.6) 83(7.619,1) 84(7.619,1.4) 85(7.619,1.8) 86(7.619,2.2) 87(7.619,2.6) 88(7.619,3) 89(7.619,3.4) 90(7.619,3.8) 91(7.619,4.2) 92(7.619,4.6) 93(7.619,5) 94(7.619,5.4) 95(7.619,5.8) 96(7.619,6.2)
  oval 0.203x1.524 smd: 33(-6.2,-7.619) 34(-5.8,-7.619) 35(-5.4,-7.619) 36(-5,-7.619) 37(-4.6,-7.619) 38(-4.2,-7.619) 39(-3.8,-7.619) 40(-3.4,-7.619) 41(-3,-7.619) 42(-2.6,-7.619) 43(-2.2,-7.619) 44(-1.8,-7.619) 45(-1.4,-7.619) 46(-1,-7.619) 47(-0.6,-7.619) 48(-0.2,-7.619) 49(0.2,-7.619) 50(0.6,-7.619) 51(1,-7.619) 52(1.4,-7.619) 53(1.8,-7.619) 54(2.2,-7.619) 55(2.6,-7.619) 56(3,-7.619) 57(3.4,-7.619) 58(3.8,-7.619) 59(4.2,-7.619) 60(4.6,-7.619) 61(5,-7.619) 62(5.4,-7.619) 63(5.8,-7.619) 64(6.2,-7.619) 97(6.2,7.619) 98(5.8,7.619) 99(5.4,7.619) 100(5,7.619) 101(4.6,7.619) 102(4.2,7.619) 103(3.8,7.619) 104(3.4,7.619) 105(3,7.619) 106(2.6,7.619) 107(2.2,7.619) 108(1.8,7.619) 109(1.4,7.619) 110(1,7.619) 111(0.6,7.619) 112(0.2,7.619) 113(-0.2,7.619) 114(-0.6,7.619) 115(-1,7.619) 116(-1.4,7.619) 117(-1.8,7.619) 118(-2.2,7.619) 119(-2.6,7.619) 120(-3,7.619) 121(-3.4,7.619) 122(-3.8,7.619) 123(-4.2,7.619) 124(-4.6,7.619) 125(-5,7.619) 126(-5.4,7.619) 127(-5.8,7.619) 128(-6.2,7.619)
WQFN_56_16_236_TH174
  oval 0.686x0.203 smd: 1(-3.038,2.8) 2(-3.038,2.4) 14(-3.038,-2.4) 15(-3.038,-2.8) 29(3.038,-2.8) 30(3.038,-2.4) 42(3.038,2.4) 43(3.038,2.8)
  oval 0.787x0.203 smd: 3(-2.987,2) 4(-2.987,1.6) 5(-2.987,1.2) 6(-2.987,0.8) 7(-2.987,0.4) 8(-2.987,0) 9(-2.987,-0.4) 10(-2.987,-0.8) 11(-2.987,-1.2) 12(-2.987,-1.6) 13(-2.987,-2) 31(2.987,-2) 32(2.987,-1.6) 33(2.987,-1.2) 34(2.987,-0.8) 35(2.987,-0.4) 36(2.987,0) 37(2.987,0.4) 38(2.987,0.8) 39(2.987,1.2) 40(2.987,1.6) 41(2.987,2)
  oval 0.203x0.787 smd: 16(-2.4,-2.987) 17(-2,-2.987) 18(-1.6,-2.987) 19(-1.2,-2.987) 20(-0.8,-2.987) 21(-0.4,-2.987) 22(0,-2.987) 23(0.4,-2.987) 24(0.8,-2.987) 25(1.2,-2.987) 26(1.6,-2.987) 27(2,-2.987) 28(2.4,-2.987) 44(2.4,2.987) 45(2,2.987) 46(1.6,2.987) 47(1.2,2.987) 48(0.8,2.987) 49(0.4,2.987) 50(0,2.987) 51(-0.4,2.987) 52(-0.8,2.987) 53(-1.2,2.987) 54(-1.6,2.987) 55(-2,2.987) 56(-2.4,2.987)
  rect 4.42x4.42 smd: 57(0,0)
X2O
  round 1.321 hole 0.914: 1(-2.54,0) 2(2.54,0)
X4S32X25
  oval 1.422x1.219 smd: 1(-1.1,-0.85) 2(1.1,-0.85) 3(1.1,0.85) 4(-1.1,0.85)
X4S38X80
  oval 1.321x1.905 smd: 1(-2.75,-1.6) 2(2.75,-1.6) 3(2.75,1.6) 4(-2.75,1.6)

## Nets
3V_5V_PWROK: PR337.2 RO174.2
5V_DUAL_USB_EN_M: R6658.2 U4.BD14(GPD7_USB2_WAKEOUT_N)
5V_SMART_USB_EN: PU20.4(EN) RH4.2 U4.N44(GPP_G17_ADR_COMPLETE)
+3V_5V_EN: PC343.1 PQ52.D2 PR234.2 PR237.2 PR238.1
+3V_5V_EN_3V: PQ51.G(GATE) PR239.1
+3V_5V_EN_3V_R: PC347.1 PR235.2 PR238.2 PR239.2
+3V_5V_EN_5V: PQ50.G(GATE) PR237.1
+3V_5V_EN_R: PQ52.D1 PQ52.G2 PR236.2
+3V_BATT: C228.1 C1682.1 C1683.1 D1.3(NODE3) R6425.2 R6467.1 R6539.1 U4.BA22(VCCRTC)
+3V_LAN: CL5.1 CL6.1 CL15.1 CL17.1 CL33.1 CL50.2 CL51.2 CL58.1 CL59.1 NIC_USB.21(D3) QL7.D(DRAIN) RL43.2 RTK_LAN.11(AVDD33(1)) RTK_LAN.23(VDDREG) RTK_LAN.32(AVDD33(2)) UU17.5 UU18.5
+3V_VA: CA2.1 CA21.1 CA22.2 CA27.2 CA28.1 FBA4.2 RA17.2 RA18.2 RA21.2 RA37.1 UA1.1(DVDD) UA1.9(DVDD-IO) UA1.36(CPVDD)
+5V_3P3V_PG: PR269.2 PU16.7(PGOOD)
+5V_AUX: CS178.1 CS179.1 PC48.1 PC63.2 PC258.1 PC308.1 PC331.1 PC336.1 PC341.1 PCE35.1 PCE36.1 PJP30.1 PL12.1 PQ50.D(DRAIN) PQ54.D(DRAIN) PR39.2 PR54.2 PR77.1 PR212.1 PR230.1 PR232.1 PR347.1 PR353.1 PU3.6(VCNTL) PU5.21(VCC) PU16.14(BYP1) PU20.5(VIN) PU21.5(VCC) RIO8.1 RIO9.1 RNO5.1 RNO5.2 RNO5.3 RNO5.4
+5V_DDC: CG18.2 DG4.2(CATHODE) RG20.1 RG21.1 RG24.2
+5V_DUAL_USB: CO42.1 CS140.1 CS141.1 CS142.1 CS143.1 CS144.1 CS145.1 CS156.1 CS161.1 CS165.1 CS166.1 CS212.1 F6.1 FU2.1 FU5.2 FU6.1 FU9.2 PQ54.S(SOURCE) PR248.1 PR249.1 PR388.2 RN5.5 RN5.6 RN5.7 RN5.8
+5V_HDMI: C531.1 F2.1 HDMI.18(+5V)
+5V_MAIN: C379.1 CA8.1 CA9.2 CB3.1 CK27.1 CK30.1 CK31.1 CK33.1 CK59.1 CK60.1 CK61.1 CK67.1 CS126.1 D41.3 DG4.1(ANODE) ECK1.1 ECK5.1 F2.2 FBA3.1 FG1.1 LPC_DEBUG.8 PC300.1 PC346.1 PCE31.1 PD6.2(C) PQ50.S(SOURCE) PR98.2 PR137.2 PR160.2 PR197.2 PR240.1 PR241.1 QG1.G(GATE) QO2.1(EMITTER) RF5.1 RG29.1 RIO11.1 RK4.1 RK5.2 RK24.2 RK32.2 RK37.2 RK42.2 RK49.2 RK50.1 RK54.2 RNK1.5 RNK1.6 RNK1.7 RNK1.8 RNK4.1 RNK4.2 RNK5.5 RNK5.6 RNK5.7 RNK5.8 RNK6.5 RNK6.6 RNK6.7 RNK6.8 RNK7.1 RNK7.2 SATA_PWR.2(1) SLOT3.A5(+5V2) SLOT3.A8(+5V4) SLOT3.A10(+5V5) SLOT3.A16(+5V6) SLOT3.A59(+5V9) SLOT3.A61(+5V11) SLOT3.A62(+5V13) SLOT3.B5(+5V1) SLOT3.B6(+5V3) SLOT3.B19(+5V7) SLOT3.B59(+5V8) SLOT3.B61(+5V10) SLOT3.B62(+5V12) SLOT4.A5(+5V2) SLOT4.A8(+5V4) SLOT4.A10(+5V5) SLOT4.A16(+5V6) SLOT4.A59(+5V9) SLOT4.A61(+5V11) SLOT4.A62(+5V13) SLOT4.B5(+5V1) SLOT4.B6(+5V3) SLOT4.B19(+5V7) SLOT4.B59(+5V8) SLOT4.B61(+5V10) SLOT4.B62(+5V12) UO2.20(VCC)
+5V_PS2: C409.1 C414.1 C415.2 F6.2 KYBD_MOUSE.4 KYBD_MOUSE.10 R381.1 UU27.5(VDD)
+5V_SMART_USB: CU5.1 ECU13.1 NIC_USB.1(VBUS1) NIC_USB.5(VBUS2) PR344.2 PU20.1(VOUT) UU1.5(VDD)
+5V_USB_EN_L: PQ54.G(GATE) PR246.1
+5VAUX_BOOT_20: PR257.2 PU16.17(BOOT1)
+5VAUX_BOOTR_20: PC328.1 PR257.1
+5VAUX_CS: PR273.1 PU16.1(CS1)
+5VAUX_EN: PC339.1 PR275.1 PR276.1 PU16.20(EN1)
+5VAUX_FB: PC335.2 PR266.2 PR270.1 PR271.1 PU16.2(FB1)
+5VAUX_FB_R: PC335.1 PJP30.2 PR266.1
+5VAUX_LG_25: PQ60.4(G) PU16.15(LGATE1)
+5VAUX_LPS_LDO: DA7.1(CATH1) FBA1.1 PC337.1 PR17.1 PR24.1 PR31.1 PR41.1 PR76.1 PR231.1 PR236.1 PR243.1 PR389.1 PR392.1 PU16.13(LDO5) RO9.2 RO167.2 RO189.1
+5VAUX_PHASE_25: PC328.2 PC332.1 PL12.2 PQ58.1(S1) PQ58.2(S2) PQ58.3(S3) PQ60.5(D1) PR261.2 PU16.18(PHASE1)
+5VAUX_PHASE_R: PC332.2 PR264.1
+5VAUX_UG_25: PR259.2 PU16.16(UGATE1)
+5VAUX_UGR_25: PQ58.4(G) PR259.1 PR261.1
+5VAUX_VCLK: PR272.1 PU16.19(VCLK)
+12V_CPU: ATX_CPU.3 ATX_CPU.4 PL6.1 RO56.1
+12V_CPU_VIN: PC71.1 PC107.1 PC108.1 PC114.1 PC115.1 PC121.1 PC122.1 PC151.1 PC152.1 PC166.1 PC167.1 PC179.1 PC207.1 PC208.1 PC209.1 PC210.1 PC211.1 PCE12.1 PCE13.1 PCE14.1 PL6.2 PQ29.5(D1) PQ32.5(D1) PQ35.5(D1) PQ38.5(D1) PQ41.5(D1) PQ44.2(D1) PQ45.2-4(D1) PR91.1 PR118.1 PR120.1 PR169.2 PR174.2 PR180.2 PR187.2 PR193.2
+12V_DUAL: CS213.1 PC316.1 PC319.1 PC320.2 PCE33.1 PD5.2(C) PFB2.2 PFB3.2 PFB4.2 PFB10.1 PFB11.1 PFB12.2 PQ53.1(S1) PQ53.2(S2) PQ53.3(S3) PR244.1 PR254.1
+12V_DUAL_3V5V_VIN: PC323.1 PC324.1 PC326.1 PC327.1 PCE34.1 PFB10.2 PFB11.2 PQ58.5(D1) PQ59.5(D1)
+12V_MAIN: ATX_SYS.5 ATX_SYS.6 CK25.1 CK62.1 CPO1.2 CS154.1 CS161.2 CS162.1 CS178.2 CS214.1 CS215.1 CS216.1 CX18.1 CX19.1 CX83.1 CX84.1 DF1.2(CATHODE) DO2.1(ANODE) ECK4.1 ECK7.1 ECX7.1 ECX10.1 PC80.1 PC304.1 PC305.1 PCE30.1 PQ53.5(D) PR87.2 PR214.1 PR233.1 PR234.1 PR235.1 PU6.6(VCC) RF1.1 RF10.2 RF33.1 RF180.2 SATA_PWR.4(3) SLOT1.A2(+12V_4) SLOT1.A3(+12V_5) SLOT1.B1(+12V_1) SLOT1.B2(+12V_2) SLOT1.B3(+12V_3) SLOT2.A2(+12V_4) SLOT2.A3(+12V_5) SLOT2.B1(+12V_1) SLOT2.B2(+12V_2) SLOT2.B3(+12V_3) SLOT3.A2(+12V) SLOT4.A2(+12V) UF147.8(V+)
+12V_SB: ATX_SYS.1 PC322.1 PD5.1(A) PR252.1 PR256.1 RO46.1 RO50.1
+VCCGT: CPU.AA34(VCCGT[16]) CPU.AA35(VCCGT[5]) CPU.AA36(VCCGT[4]) CPU.AA37(VCCGT[3]) CPU.AA38(VCCGT[10]) CPU.AB33(VCCGT[2]) CPU.AB34(VCCGT[1]) CPU.G36(VCCGT[59]) CPU.G37(VCCGT[8]) CPU.G38(VCCGT[6]) CPU.G39(VCCGT[79]) CPU.G40(VCCGT[78]) CPU.H36(VCCGT[0]) CPU.H38(VCCGT[77]) CPU.H40(VCCGT[76]) CPU.J36(VCCGT[75]) CPU.J37(VCCGT[74]) CPU.J38(VCCGT[57]) CPU.J39(VCCGT[73]) CPU.J40(VCCGT[72]) CPU.K36(VCCGT[49]) CPU.K38(VCCGT[71]) CPU.K40(VCCGT[70]) CPU.L34(VCCGT[69]) CPU.L35(VCCGT[68]) CPU.L36(VCCGT[67]) CPU.L37(VCCGT[66]) CPU.L38(VCCGT[65]) CPU.L39(VCCGT[64]) CPU.L40(VCCGT[63]) CPU.M33(VCCGT[62]) CPU.M34(VCCGT[61]) CPU.M36(VCCGT[60]) CPU.M38(VCCGT[47]) CPU.M40(VCCGT[58]) CPU.N34(VCCGT[45]) CPU.N35(VCCGT[56]) CPU.N36(VCCGT[43]) CPU.N37(VCCGT[55]) CPU.N38(VCCGT[54]) CPU.N39(VCCGT[53]) CPU.N40(VCCGT[52]) CPU.P33(VCCGT[51]) CPU.P34(VCCGT[50]) CPU.P36(VCCGT[48]) CPU.P38(VCCGT[46]) CPU.P40(VCCGT[44]) CPU.R34(VCCGT[35]) CPU.R35(VCCGT[42]) CPU.R36(VCCGT[41]) CPU.R37(VCCGT[40]) CPU.R38(VCCGT[34]) CPU.R39(VCCGT[39]) CPU.R40(VCCGT[38]) CPU.T33(VCCGT[37]) CPU.T34(VCCGT[36]) CPU.T36(VCCGT[32]) CPU.T38(VCCGT[33]) CPU.T40(VCCGT[31]) CPU.U34(VCCGT[30]) CPU.U35(VCCGT[29]) CPU.U36(VCCGT[28]) CPU.U37(VCCGT[27]) CPU.U38(VCCGT[26]) CPU.U39(VCCGT[25]) CPU.U40(VCCGT[24]) CPU.V33(VCCGT[23]) CPU.V34(VCCGT[22]) CPU.V36(VCCGT[20]) CPU.V38(VCCGT[21]) CPU.V40(VCCGT[17]) CPU.W34(VCCGT[19]) CPU.W35(VCCGT[15]) CPU.W36(VCCGT[18]) CPU.W37(VCCGT[14]) CPU.W38(VCCGT[13]) CPU.Y33(VCCGT[12]) CPU.Y34(VCCGT[11]) CPU.Y36(VCCGT[9]) CPU.Y38(VCCGT[7]) PC158.1 PC159.1 PC160.1 PC161.1 PC162.1 PC168.1 PC169.1 PC170.1 PC171.1 PC172.1 PCE21.1 PCE22.1 PCE23.1 PCE24.1 PCE25.1 PJP16.1 PJP18.1 PL9.2 PL10.2 PR158.1
+VCCIO: CPU.AJ23(VCCIO[3]) CPU.AK11(VCCIO[2]) CPU.AK14(VCCIO[1]) CPU.AK24(VCCIO[0]) CPU.M8(VCCIO[7]) CPU.P8(VCCIO[6]) CPU.T8(VCCIO[8]) CPU.U8(VCCIO[5]) CPU.W8(VCCIO[4]) CS73.1 CS75.1 CS112.1 CS218.1 PC199.2 PC201.1 PC202.1 PC203.1 PC204.1 PC293.1 PC294.1 PC295.1 PC296.1 PC297.1 PC298.1 PCE28.1 PJP20.1 PQ48.1(S1) PQ48.2(S2) PQ48.3(S3) PR213.1 QO4.4(EMITTER) R48.2 R6255.2 R6289.1 R6290.1 R6579.1 RX21.1
+VCCIO_COMP_RC: PC200.2 PR219.1
+VCCIO_DRV: PR217.1 PR219.2 PU14.5(DRV)
+VCCIO_DRV_R: PC199.1 PQ48.4(G) PR217.2
+VCCIO_FB: PC200.1 PR220.1 PR222.1 PR224.1 PU14.3(FB)
+VCCIO_FB_R: PC206.2 PR220.2 PR221.1 PR223.1
+VCCIO_FB_RC: PC206.1 PR222.2
+VCCIO_FB_SENSE: PJP20.2 PR221.2
+VCCIO_SS: PC198.1 PU14.4(SS)
+VCCIO_VCC: PC350.2 PR214.2 PU14.6(VCC)
+VCCRTC_SIO: CO11.1 D5.3(NODE3) RO5.1 SIO_5553.21(VBAT)
+VCCSA: CPU.AA6(VCCSA[16]) CPU.AA7(VCCSA[4]) CPU.AB6(VCCSA[3]) CPU.AB7(VCCSA[2]) CPU.AB8(VCCSA[1]) CPU.AC7(VCCSA[0]) CPU.AC8(VCCSA[13]) CPU.N7(VCCSA[12]) CPU.P7(VCCSA[11]) CPU.R7(VCCSA[10]) CPU.T7(VCCSA[9]) CPU.U7(VCCSA[8]) CPU.V7(VCCSA[15]) CPU.W7(VCCSA[14]) CPU.Y6(VCCSA[6]) CPU.Y7(VCCSA[5]) CPU.Y8(VCCSA[7]) CS78.1 CS82.1 CS83.1 CS84.1 CS148.1 CS208.1 CS209.1 CS210.1 CS211.1 PC183.1 PC186.1 PC187.1 PC188.1 PC189.1 PC190.1 PC191.1 PC192.1 PC193.1 PCE26.1 PCE27.1 PL11.2 PR206.1
+VCCSA_BOOT_25: PR199.1 PU13.10(BOOT)
+VCCSA_BOOT_R25: PC180.2 PR199.2
+VCCSA_CS: PR204.2 PU13.2(CS)
+VCCSA_FB: PC184.2 PR207.1 PR209.1 PR210.1 PU13.4(FB)
+VCCSA_FB_R: PC184.1 PC185.1 PR206.2 PR207.2 PR208.2
+VCCSA_FB_VSS: PJP19.1 PR209.2 PR211.2
+VCCSA_HG_25: PR200.1 PU13.9(UGATE)
+VCCSA_HG_R_25: PQ44.1(G1) PQ45.1(G1) PR200.2 PR201.1
+VCCSA_LG_25: PQ44.7(G2) PQ45.8(G2) PU13.6(LGATE)
+VCCSA_PHASE_25: PC180.1 PC182.1 PL11.1 PQ44.3(S1/D2) PQ45.9(PHASE(S1/D2)) PR201.2 PU13.8(PHASE)
+VCCSA_RF: PR203.2 PU13.5(RF)
+VCCSA_SN_20: PC182.2 PR205.1
+VCCSA_VCC_20: PC178.1 PR197.1 PU13.7(VCC)
+VCCST_PWRGD: PR8.2 PR11.1 PR14.1 R6546.2
+VCCST_PWRGD_R: PQ3.D2 PR14.2
+VDDQ: C1.1 C2.1 C3.1 C5.1 C6.2 C7.2 C8.2 C9.2 C19.2 C48.1 C49.1 C50.1 C51.1 C52.2 C53.2 C54.2 C55.2 C56.2 C57.1 C58.1 C59.1 C60.1 C61.1 C71.1 C1766.1 C1767.1 C1768.1 C1769.1 CD4.1 CPU.AT18(VDDQ_15) CPU.AT21(VDDQ_14) CPU.AU13(VDDQ_13) CPU.AU15(VDDQ_12) CPU.AU19(VDDQ_11) CPU.AU23(VDDQ_10) CPU.AV11(VDDQ_9) CPU.AV17(VDDQ_8) CPU.AV21(VDDQ_7) CPU.AW10(VDDQ_6) CPU.AW14(VDDQ_5) CPU.AW25(VDDQ_4) CPU.AY12(VDDQ_3) CPU.AY16(VDDQ_2) CPU.AY18(VDDQ_1) CPU.AY23(VDDQ_16) CS217.1 DIMM1.7(DQS9P) DIMM1.18(DQS10P) DIMM1.29(DQS11P) DIMM1.40(DQS12P) DIMM1.51(DQS17P) DIMM1.59(VDD_0) DIMM1.61(VDD_1) DIMM1.64(VDD_2) DIMM1.67(VDD_03) DIMM1.70(VDD_04) DIMM1.73(VDD_05) DIMM1.76(VDD_06) DIMM1.80(VDD_07) DIMM1.83(VDD_08) DIMM1.85(VDD_09) DIMM1.88(VDD_10) DIMM1.90(VDD_11) DIMM1.92(VDD_12) DIMM1.99(DQS13P) DIMM1.110(DQS14P) DIMM1.121(DQS15P) DIMM1.132(DQS16P) DIMM1.204(VDD_13) DIMM1.206(VDD_14) DIMM1.209(VDD_15) DIMM1.212(VDD_16) DIMM1.215(VDD_17) DIMM1.217(VDD_18) DIMM1.220(VDD_19) DIMM1.223(VDD_20) DIMM1.226(VDD_21) DIMM1.229(VDD_22) DIMM1.231(VDD_23) DIMM1.233(VDD_24) DIMM1.236(VDD_25) DIMM2.7(DQS9P) DIMM2.18(DQS10P) DIMM2.29(DQS11P) DIMM2.40(DQS12P) DIMM2.51(DQS17P) DIMM2.59(VDD_0) DIMM2.61(VDD_1) DIMM2.64(VDD_2) DIMM2.67(VDD_03) DIMM2.70(VDD_04) DIMM2.73(VDD_05) DIMM2.76(VDD_06) DIMM2.80(VDD_07) DIMM2.83(VDD_08) DIMM2.85(VDD_09) DIMM2.88(VDD_10) DIMM2.90(VDD_11) DIMM2.92(VDD_12) DIMM2.99(DQS13P) DIMM2.110(DQS14P) DIMM2.121(DQS15P) DIMM2.132(DQS16P) DIMM2.204(VDD_13) DIMM2.206(VDD_14) DIMM2.209(VDD_15) DIMM2.212(VDD_16) DIMM2.215(VDD_17) DIMM2.217(VDD_18) DIMM2.220(VDD_19) DIMM2.223(VDD_20) DIMM2.226(VDD_21) DIMM2.229(VDD_22) DIMM2.231(VDD_23) DIMM2.233(VDD_24) DIMM2.236(VDD_25) PC38.1 PC39.1 PC40.1 PC43.1 PC44.1 PC45.1 PC46.1 PC47.1 PC195.1 PC196.1 PCE2.1 PCE3.1 PCE4.1 PJP2.2 PL2.2 PQ48.5(D1) PR53.1 PR361.2 PU3.1(VIN) QO1.4(EMITTER) R60.1 R61.1 R6500.2 RD3.1 RD5.1 RD6.1 U139.5(VCC)
-12V: CK34.1 CK64.1 CPO2.2 DO3.2(CATHODE) PC79.2 PC81.2 PC82.1 PCE8.2 PD3.1(A) PR88.1 PR89.2 PU6.4(GND) SLOT3.B1(-12V) SLOT4.B1(-12V)
-12V_COMP: PR89.1 PR90.1 PU6.5(COMP)
-12V_SWC: PR87.1 PU6.1(SWC) PU6.7(PK) PU6.8(DC)
-12V_SWE: PD3.2(C) PL4.2 PU6.2(SWE)
-12V_TCAP: PC79.1 PU6.3(TCAP)
AVCC33: CG23.1 CG24.2 FBG1.2 RTK_VGA.24(AVCC_33)
AVDD2: CA4.1 CA102.1 FBA2.2 FBA5.2 UA1.40(AVDD2)
DVCC_1P5V: BRIDGE.D7(VDD_15_PCIE) BRIDGE.F10(VDD_15_5) BRIDGE.G4(VDD_15_3) BRIDGE.G10(VDD_15_4) BRIDGE.H10(VDD_15_2) BRIDGE.K7(VDD_15_1) CK5.1 CK12.1 CK48.1 CK49.1 CK50.1 CK51.1 CK52.1 CK56.1 FBK1.1 RC1.1 RK43.1 RK44.1 UK2.4(VOUT)
DVCC_1P5V_ADJ: RC1.2 RK43.2 RK45.1 UK2.5(SET)
GND: APS/PETS.8 APS/PETS.10 APS/PETS.12 APS/PETS.14 ATX_CPU.1 ATX_CPU.2 ATX_SYS.2 ATX_SYS.3 ATX_SYS.7 AUX_PWR1.2(CATHODE) BATTERY.2(POS2) BH1.1(NC) BH1.3(GND) BRIDGE.C11(VSSA_6) BRIDGE.D4(VSS36) BRIDGE.D6(VSS37) BRIDGE.D8(VSS38) BRIDGE.D10(VSS39) BRIDGE.E5(VSS31) BRIDGE.E6(VSS32) BRIDGE.E7(VSS33) BRIDGE.E8(VSS34) BRIDGE.E9(VSS35) BRIDGE.E10(VSSA_4) BRIDGE.E11(VSSA_5) BRIDGE.F4(VSS23) BRIDGE.F5(VSS24) BRIDGE.F6(VSS25) BRIDGE.F7(VSS26) BRIDGE.F8(VSS27) BRIDGE.F9(VSS28) BRIDGE.F11(VSS29) BRIDGE.F12(VSS30) BRIDGE.G5(VSS18) BRIDGE.G6(VSS19) BRIDGE.G7(VSS20) BRIDGE.G8(VSS21) BRIDGE.G9(VSS22) BRIDGE.G11(VSSA_3) BRIDGE.H4(VSS12) BRIDGE.H5(VSS13) BRIDGE.H6(VSS14) BRIDGE.H7(VSS15) BRIDGE.H8(VSS16) BRIDGE.H9(VSS17) BRIDGE.H12(VSSA_2) BRIDGE.J5(VSS6) BRIDGE.J6(VSS7) BRIDGE.J7(VSS8) BRIDGE.J8(VSS9) BRIDGE.J9(VSS10) BRIDGE.J10(VSS11) BRIDGE.K4(VSS2) BRIDGE.K5(VSS3) BRIDGE.K6(VSS4) BRIDGE.K8(VSS5) BRIDGE.K10(VSSA_1) BRIDGE.L11(VSS1) C1.2 C2.2 C3.2 C5.2 C6.1 C7.1 C8.1 C9.1 C19.1 C20.2 C21.2 C22.2 C23.2 C24.2 C25.2 C48.2 C49.2 C50.2 C51.2 C52.1 C53.1 C54.1 C55.1 C56.1 C57.2 C58.2 C59.2 C60.2 C61.2 C62.2 C63.2 C64.2 C65.2 C66.2 C67.2 C68.2 C69.2 C70.2 C71.2 C72.2 C74.1 C75.1 C228.2 C379.2 C383.2 C386.2 C409.2 C410.2 C411.2 C412.2 C413.2 C414.2 C415.1 C531.2 C558.2 C766.2 C1629.2 C1630.2 C1639.1 C1640.2 C1641.2 C1642.2 C1643.2 C1644.2 C1645.2 C1646.1 C1647.2 C1648.1 C1649.1 C1654.2 C1655.2 C1656.2 C1657.2 C1660.2 C1661.2 C1664.2 C1665.2 C1666.2 C1667.2 C1668.2 C1670.2 C1671.2 C1672.2 C1677.2 C1678.2 C1679.2 C1681.1 C1682.2 C1683.2 C1684.1 C1686.1 C1688.2 C1689.1 C1722.2 C1728.2 C1763.2 C1764.1 C1766.2 C1767.2 C1768.2 C1769.2 C1807.1 C1808.2 CA2.2 CA8.2 CA9.1 CA10.2 CA11.1 CA15.2 CA16.1 CA18.1 CA21.2 CA22.1 CA23.2 CA24.2 CA25.2 CA27.1 CA28.2 CA29.2 CA74.2 CA75.2 CA76.2 CA77.2 CA79.1 CA82.2 CA84.1 CA87.2 CA88.2 CA89.2 CA90.1 CA92.2 CA107.2 CA108.2 CA109.2 CA110.2 CA111.2 CA124.2 CA125.2 CA126.2 CB1.2 CB2.2 CB3.2 CB4.2 CB5.2 CD1.2 CD2.2 CD3.2 CD4.2 CD5.2 CF1.2 CF2.2 CF3.2 CF4.2 CF5.2 CF6.2 CF7.2 CF8.2 CF9.2 CF10.2 CF11.1 CF12.2 CF13.1 CF14.2 CF18.2 CF19.2 CF20.2 CF21.2 CF22.1 CF23.2 CF24.1 CF103.2 CF104.2 CF105.2 CF106.2 CF107.2 CF108.2 CF109.2 CF110.2 CG7.2 CG8.2 CG9.2 CG10.2 CG11.2 CG12.2 CG13.2 CG14.2 CG15.1 CG16.2 CG17.1 CG18.1 CG19.1 CG20.1 CG21.2 CG22.1 CG23.2 CG24.1 CG25.1 CG26.1 CG27.2 CK1.2 CK2.2 CK3.2 CK4.2 CK5.2 CK6.2 CK7.2 CK8.2 CK9.2 CK10.2 CK11.2 CK12.2 CK13.2 CK14.2 CK15.2 CK16.2 CK19.2 CK20.2 CK23.1 CK25.2 CK26.2 CK27.2 CK28.2 CK29.2 CK30.2 CK31.2 CK32.2 CK33.2 CK34.2 CK35.2 CK36.2 CK37.2 CK38.2 CK39.2 CK40.2 CK41.2 CK42.2 CK43.2 CK44.2 CK45.2 CK46.2 CK47.2 CK48.2 CK49.2 CK50.2 CK51.2 CK52.2 CK53.2 CK54.2 CK56.2 CK58.2 CK59.2 CK60.2 CK61.2 CK62.2 CK63.2 CK64.2 CK65.2 CK66.2 CK67.2 CK68.2 CL5.2 CL6.2 CL15.2 CL17.2 CL23.2 CL31.2 CL32.2 CL33.2 CL34.1 CL35.2 CL36.2 CL41.2 CL42.2 CL43.2 CL44.2 CL45.2 CL46.2 CL47.2 CL48.2 CL49.2 CL50.1 CL51.1 CL52.2 CL53.2 CL54.2 CL56.2 CL57.2 CL58.2 CL59.2 CM5.2 CM6.2 CNO1.1 CNO1.3 CNO1.5 CNO1.7 CNO2.1 CNO2.3 CNO2.5 CNO2.7 CO1.1 CO2.1 CO3.1 CO4.1 CO5.1 CO6.1 CO7.1 CO8.1 CO9.1 CO10.1 CO11.2 CO12.1 CO13.1 CO14.2 CO18.2 CO32.2 CO33.2 CO42.2 CO51.2 CO52.2 CO53.2 CO54.2 CO55.2 CO56.2 COOLER.5(A5) COOLER.6 COOLER.7 COOLER.8 COOLER.9 COOLER.10 COOLER.11 COOLER.12 COOLER.13 COOLER.14 COOLER.15 COOLER.16 COOLER.17 COOLER.18 COOLER.19 COOLER.20 COOLER.21 COOLER.22 COOLER.23 COOLER.24 COOLER.25 COOLER.26 COOLER.27 COOLER.28 COOLER.29 COOLER.30 COOLER.31 COOLER.32 COOLER.33 COOLER.34 COOLER.35 COOLER.36 COOLER.37 COOLER.38 COOLER.39 COOLER.40 COOLER.41 COOLER.42 COOLER.43 COOLER.44 CPU.A4(VSS_NCTF_4) CPU.A7(VSS_347) CPU.A11(VSS_125) CPU.A13(VSS_225) CPU.A15(VSS_346) CPU.A17(VSS_345) CPU.A24(VSS_344) CPU.AA3(VSS_217) CPU.AA8(VSS_216) CPU.AA33(VSS_348) CPU.AB5(VSS_214) CPU.AB39(VSS_213) CPU.AC3(VSS_212) CPU.AC6(VSS_211) CPU.AC33(VSS_210) CPU.AC34(VSS_209) CPU.AC35(VSS_208) CPU.AD1(VSS_206) CPU.AD4(VSS_205) CPU.AD6(VSS_204) CPU.AD7(VSS_203) CPU.AD8(VSS_202) CPU.AD33(VSS_201) CPU.AD36(VSS_200) CPU.AD37(VSS_199) CPU.AD38(VSS_198) CPU.AD39(VSS_197) CPU.AD40(VSS_196) CPU.AE3(VSS_195) CPU.AE5(VSS_194) CPU.AE8(VSS_193) CPU.AE33(VSS_192) CPU.AE36(VSS_191) CPU.AF1(VSS_190) CPU.AF5(VSS_189) CPU.AF8(VSS_188) CPU.AF33(VSS_187) CPU.AF36(VSS_186) CPU.AF37(VSS_185) CPU.AF40(VSS_184) CPU.AG1(VSS_183) CPU.AG2(VSS_182) CPU.AG3(VSS_181) CPU.AG4(VSS_180) CPU.AG5(VSS_179) CPU.AG8(VSS_178) CPU.AG33(VSS_177) CPU.AG36(VSS_176) CPU.AH5(VSS_175) CPU.AH8(VSS_174) CPU.AH33(VSS_173) CPU.AH36(VSS_172) CPU.AH37(VSS_171) CPU.AH38(VSS_170) CPU.AH39(VSS_169) CPU.AH40(VSS_168) CPU.AJ1(VSS_167) CPU.AJ4(VSS_166) CPU.AJ5(VSS_165) CPU.AJ8(VSS_164) CPU.AJ31(VSS_158) CPU.AJ32(VSS_157) CPU.AJ33(VSS_156) CPU.AJ34(VSS_155) CPU.AJ35(VSS_154) CPU.AJ36(VSS_153) CPU.AK5(VSS_152) CPU.AK6(VSS_151) CPU.AK7(VSS_150) CPU.AK8(VSS_149) CPU.AK9(VSS_148) CPU.AK10(VSS_147) CPU.AK12(VSS_146) CPU.AK13(VSS_145) CPU.AK15(VSS_117) CPU.AK16(VSS_127) CPU.AK17(VSS_80) CPU.AK18(VSS_144) CPU.AK19(VSS_143) CPU.AK20(VSS_162) CPU.AK23(VSS_163) CPU.AK25(VSS_142) CPU.AK26(VSS_141) CPU.AK28(VSS_140) CPU.AK29(VSS_139) CPU.AK30(VSS_138) CPU.AK36(VSS_137) CPU.AK37(VSS_136) CPU.AK40(VSS_135) CPU.AL1(VSS_134) CPU.AL2(VSS_133) CPU.AL3(VSS_132) CPU.AL4(VSS_131) CPU.AL5(VSS_130) CPU.AL11(VSS_129) CPU.AL14(VSS_128) CPU.AL21(VSS_126) CPU.AL24(VSS_124) CPU.AL27(VSS_123) CPU.AL30(VSS_122) CPU.AL36(VSS_121) CPU.AM5(VSS_120) CPU.AM11(VSS_119) CPU.AM14(VSS_118) CPU.AM17(VSS_91) CPU.AM19(VSS_116) CPU.AM24(VSS_115) CPU.AM27(VSS_114) CPU.AM30(VSS_113) CPU.AM31(VSS_112) CPU.AM32(VSS_111) CPU.AM33(VSS_110) CPU.AM34(VSS_109) CPU.AM35(VSS_108) CPU.AM36(VSS_107) CPU.AM37(VSS_106) CPU.AM38(VSS_105) CPU.AM39(VSS_104) CPU.AM40(VSS_103) CPU.AN1(VSS_102) CPU.AN4(VSS_101) CPU.AN5(VSS_100) CPU.AN6(VSS_99) CPU.AN7(VSS_98) CPU.AN8(VSS_97) CPU.AN9(VSS_96) CPU.AN10(VSS_95) CPU.AN11(VSS_94) CPU.AN14(VSS_93) CPU.AN16(VSS_92) CPU.AN19(VSS_90) CPU.AN22(VSS_89) CPU.AN23(VSS_88) CPU.AN24(VSS_87) CPU.AN27(VSS_86) CPU.AN30(VSS_85) CPU.AN36(VSS_84) CPU.AP5(VSS_83) CPU.AP11(VSS_82) CPU.AP14(VSS_81) CPU.AP24(VSS_79) CPU.AP27(VSS_78) CPU.AP30(VSS_77) CPU.AP36(VSS_76) CPU.AP37(VSS_75) CPU.AP40(VSS_74) CPU.AR1(VSS_73) CPU.AR2(VSS_72) CPU.AR3(VSS_71) CPU.AR4(VSS_70) CPU.AR5(VSS_69) CPU.AR11(VSS_68) CPU.AR14(VSS_67) CPU.AR16(VSS_66) CPU.AR17(VSS_65) CPU.AR18(VSS_64) CPU.AR19(VSS_63) CPU.AR20(VSS_62) CPU.AR21(VSS_61) CPU.AR22(VSS_161) CPU.AR23(VSS_160) CPU.AR24(VSS_60) CPU.AR27(VSS_59) CPU.AR30(VSS_58) CPU.AR31(VSS_57) CPU.AR32(VSS_56) CPU.AR33(VSS_55) CPU.AR34(VSS_54) CPU.AR35(VSS_53) CPU.AR36(VSS_52) CPU.AT5(VSS_51) CPU.AT6(VSS_50) CPU.AT7(VSS_49) CPU.AT8(VSS_48) CPU.AT9(VSS_47) CPU.AT10(VSS_46) CPU.AT11(VSS_45) CPU.AT12(VSS_44) CPU.AT13(VSS_43) CPU.AT14(VSS_42) CPU.AT15(VSS_159) CPU.AT17(VSS_41) CPU.AT24(VSS_40) CPU.AT25(VSS_39) CPU.AT26(VSS_38) CPU.AT27(VSS_37) CPU.AT28(VSS_36) CPU.AT29(VSS_35) CPU.AT30(VSS_34) CPU.AT31(VSS_304) CPU.AT32(VSS_33) CPU.AT34(VSS_32) CPU.AT36(VSS_31) CPU.AT37(VSS_30) CPU.AT38(VSS_29) CPU.AT39(VSS_28) CPU.AT40(VSS_27) CPU.AU1(VSS_26) CPU.AU4(VSS_25) CPU.AU5(VSS_24) CPU.AU7(VSS_23) CPU.AU25(VSS_22) CPU.AU30(VSS_21) CPU.AU34(VSS_20) CPU.AV2(VSS_19) CPU.AV5(VSS_18) CPU.AV9(VSS_17) CPU.AV26(VSS_16) CPU.AV28(VSS_15) CPU.AV30(VSS_14) CPU.AV34(VSS_13) CPU.AV38(VSS_12) CPU.AW3(VSS_11) CPU.AW5(VSS_10) CPU.AW9(VSS_9) CPU.AW30(VSS_8) CPU.AW32(VSS_7) CPU.AW34(VSS_6) CPU.AW36(VSS_5) CPU.AY3(RSVD[0]) CPU.AY5(VSS_4) CPU.AY7(VSS_3) CPU.AY9(VSS_2) CPU.AY27(VSS_1) CPU.AY30(VSS_374) CPU.B6(VSS_343) CPU.B24(VSS_341) CPU.B26(VSS_338) CPU.B28(VSS_337) CPU.B30(VSS_331) CPU.B38(VSS_NCTF_3) CPU.C2(VSS_NCTF_2) CPU.C5(VSS_340) CPU.C8(VSS_339) CPU.C10(VSS_342) CPU.C12(VSS_223) CPU.C14(VSS_227) CPU.C16(VSS_336) CPU.C18(VSS_335) CPU.C20(VSS_334) CPU.C22(VSS_333) CPU.C24(VSS_332) CPU.C31(VSS_330) CPU.C33(VSS_326) CPU.C35(VSS_325) CPU.C37(VSS_323) CPU.D4(VSS_329) CPU.D7(VSS_328) CPU.D24(VSS_324) CPU.D26(VSS_322) CPU.D28(VSS_317) CPU.D30(VSS_313) CPU.D37(VSS_312) CPU.D39(VSS_321) CPU.D40(VSS_NCTF_1) CPU.E3(VSS_320) CPU.E6(VSS_319) CPU.E9(VSS_318) CPU.E11(VSS_215) CPU.E13(VSS_230) CPU.E15(VSS_327) CPU.E17(VSS_284) CPU.E19(VSS_316) CPU.E21(VSS_315) CPU.E23(VSS_314) CPU.E31(VSS_307) CPU.E33(VSS_306) CPU.E35(VSS_303) CPU.E37(VSS_372) CPU.F1(VSS_311) CPU.F4(VSS_310) CPU.F7(VSS_309) CPU.F10(VSS_308) CPU.F22(VSS_207) CPU.F26(VSS_302) CPU.F28(VSS_301) CPU.F30(VSS_300) CPU.F40(VSS_234) CPU.G3(VSS_299) CPU.G6(VSS_298) CPU.G8(RSVD[19]) CPU.G11(VSS_297) CPU.G13(VSS_296) CPU.G15(VSS_295) CPU.G17(VSS_220) CPU.G19(VSS_305) CPU.G22(VSS_294) CPU.G31(VSS_293) CPU.G33(VSS_292) CPU.H1(VSS_290) CPU.H4(VSS_289) CPU.H7(VSS_288) CPU.H8(RSVD[18]) CPU.H9(VSS_287) CPU.H21(VSS_283) CPU.H24(VSS_291) CPU.H26(VSS_286) CPU.H28(VSS_285) CPU.H30(VSS_282) CPU.H35(VSS_281) CPU.H37(VSS_371) CPU.H39(VSS_370) CPU.J3(VSS_280) CPU.J6(VSS_279) CPU.J10(VSS_277) CPU.J12(VSS_276) CPU.J16(VSS_219) CPU.J18(VSS_274) CPU.J20(VSS_273) CPU.J32(VSS_278) CPU.J34(VSS_269) CPU.K1(VSS_267) CPU.K4(VSS_266) CPU.K7(VSS_265) CPU.K14(VSS_264) CPU.K15(VSS_275) CPU.K17(VSS_272) CPU.K19(VSS_233) CPU.K22(VSS_271) CPU.K24(VSS_270) CPU.K26(VSS_268) CPU.K28(VSS_262) CPU.K30(VSS_256) CPU.K33(VSS_263) CPU.K35(VSS_369) CPU.K37(VSS_368) CPU.K39(VSS_367) CPU.L3(VSS_261) CPU.L6(VSS_260) CPU.L9(VSS_259) CPU.L11(VSS_258) CPU.L13(VSS_257) CPU.L32(VSS_249) CPU.M1(VSS_248) CPU.M4(VSS_247) CPU.M7(VSS_246) CPU.M10(VSS_245) CPU.M12(VSS_244) CPU.M15(VSS_255) CPU.M17(VSS_254) CPU.M19(VSS_253) CPU.M21(VSS_252) CPU.M23(VSS_251) CPU.M25(VSS_250) CPU.M27(VSS_243) CPU.M29(VSS_240) CPU.M35(VSS_366) CPU.M37(VSS_365) CPU.M39(VSS_364) CPU.N3(VSS_242) CPU.N6(VSS_241) CPU.N8(VSS_373) CPU.N33(VSS_363) CPU.P1(VSS_239) CPU.P4(VSS_238) CPU.P35(VSS_362) CPU.P37(VSS_361) CPU.P39(VSS_360) CPU.R3(VSS_237) CPU.R6(VSS_236) CPU.R8(VSS_235) CPU.R33(VSS_359) CPU.T1(VSS_232) CPU.T4(VSS_231) CPU.T35(VSS_358) CPU.T37(VSS_357) CPU.T39(VSS_356) CPU.U3(VSS_229) CPU.U6(VSS_228) CPU.U33(VSS_355) CPU.V1(VSS_226) CPU.V8(VSS_224) CPU.V35(VSS_354) CPU.V37(VSS_353) CPU.V39(VSS_352) CPU.W3(VSS_222) CPU.W6(VSS_221) CPU.W33(VSS_351) CPU.Y5(VSS_218) CPU.Y35(VSS_350) CPU.Y37(VSS_349) CS69.2 CS73.2 CS75.2 CS78.2 CS82.2 CS83.2 CS84.2 CS97.2 CS112.2 CS118.2 CS120.2 CS126.2 CS128.2 CS129.2 CS131.2 CS132.2 CS133.2 CS140.2 CS141.2 CS142.2 CS143.2 CS144.2 CS145.2 CS148.2 CS154.2 CS156.2 CS162.2 CS165.2 CS166.2 CS171.2 CS175.2 CS176.2 CS177.2 CS179.2 CS180.2 CS181.2 CS182.2 CS183.2 CS184.2 CS185.2 CS186.2 CS187.2 CS188.2 CS189.2 CS190.2 CS191.2 CS192.2 CS193.2 CS194.2 CS195.2 CS196.2 CS197.2 CS198.2 CS199.2 CS200.2 CS201.2 CS202.2 CS203.2 CS204.2 CS205.2 CS206.2 CS207.2 CS208.2 CS209.2 CS210.2 CS211.2 CS212.2 CS213.2 CS214.2 CS215.2 CS216.2 CS217.2 CS218.2 CU2.2 CU3.2 CU5.2 CU10.2 CU11.2 CU13.2 CU14.2 CU79.2 CV40.2 CV41.2 CV42.2 CX1.1 CX14.2 CX18.2 CX19.2 CX20.2 CX25.2 CX54.2 CX55.2 CX56.2 CX57.2 CX83.2 CX84.2 DA4.3(GND) DA5.3(GND) DA6.3(GND) DA7.2(CATH2) DG1.1(ANODE1) DG2.1(ANODE1) DG3.1(ANODE1) DG5.1(ANODE1) DG6.1(ANODE1) DG7.1(ANODE1) DG8.1(ANODE1) DIMM1.2(VSS_0) DIMM1.4(VSS_1) DIMM1.6(VSS_2) DIMM1.9(VSS_3) DIMM1.11(VSS_4) DIMM1.13(VSS_5) DIMM1.15(VSS_6) DIMM1.17(VSS_7) DIMM1.20(VSS_8) DIMM1.22(VSS_9) DIMM1.24(VSS_10) DIMM1.26(VSS_11) DIMM1.28(VSS_12) DIMM1.31(VSS_13) DIMM1.33(VSS_14) DIMM1.35(VSS_15) DIMM1.37(VSS_16) DIMM1.39(VSS_17) DIMM1.42(VSS_18) DIMM1.44(VSS_19) DIMM1.46(VSS_20) DIMM1.48(VSS_21) DIMM1.50(VSS_22) DIMM1.53(VSS_23) DIMM1.55(VSS_24) DIMM1.57(VSS_25) DIMM1.94(VSS_26) DIMM1.96(VSS_27) DIMM1.98(VSS_28) DIMM1.101(VSS_29) DIMM1.103(VSS_30) DIMM1.105(VSS_31) DIMM1.107(VSS_32) DIMM1.109(VSS_33) DIMM1.112(VSS_34) DIMM1.114(VSS_35) DIMM1.116(VSS_36) DIMM1.118(VSS_37) DIMM1.120(VSS_38) DIMM1.123(VSS_39) DIMM1.125(VSS_40) DIMM1.127(VSS_41) DIMM1.129(VSS_42) DIMM1.131(VSS_43) DIMM1.134(VSS_44) DIMM1.136(VSS_45) DIMM1.138(VSS_46) DIMM1.139(SA0) DIMM1.140(SA1) DIMM1.147(VSS_47) DIMM1.149(VSS_48) DIMM1.151(VSS_49) DIMM1.154(VSS_50) DIMM1.156(VSS_51) DIMM1.158(VSS_52) DIMM1.160(VSS_53) DIMM1.162(VSS_54) DIMM1.165(VSS_55) DIMM1.167(VSS_56) DIMM1.169(VSS_57) DIMM1.171(VSS_58) DIMM1.173(VSS_59) DIMM1.176(VSS_60) DIMM1.178(VSS_61) DIMM1.180(VSS_62) DIMM1.182(VSS_63) DIMM1.184(VSS_64) DIMM1.187(VSS_65) DIMM1.189(VSS_66) DIMM1.191(VSS_67) DIMM1.193(VSS_68) DIMM1.195(VSS_69) DIMM1.198(VSS_70) DIMM1.200(VSS_71) DIMM1.202(VSS_72) DIMM1.238(SA2) DIMM1.239(VSS_73) DIMM1.241(VSS_74) DIMM1.243(VSS_75) DIMM1.246(VSS_76) DIMM1.248(VSS_77) DIMM1.250(VSS_78) DIMM1.252(VSS_79) DIMM1.254(VSS_80) DIMM1.257(VSS_81) DIMM1.259(VSS_82) DIMM1.261(VSS_83) DIMM1.263(VSS_84) DIMM1.265(VSS_85) DIMM1.268(VSS_86) DIMM1.270(VSS_87) DIMM1.272(VSS_88) DIMM1.274(VSS_89) DIMM1.276(VSS_90) DIMM1.279(VSS_91) DIMM1.281(VSS_92) DIMM1.283(VSS_93) DIMM2.2(VSS_0) DIMM2.4(VSS_1) DIMM2.6(VSS_2) DIMM2.9(VSS_3) DIMM2.11(VSS_4) DIMM2.13(VSS_5) DIMM2.15(VSS_6) DIMM2.17(VSS_7) DIMM2.20(VSS_8) DIMM2.22(VSS_9) DIMM2.24(VSS_10) DIMM2.26(VSS_11) DIMM2.28(VSS_12) DIMM2.31(VSS_13) DIMM2.33(VSS_14) DIMM2.35(VSS_15) DIMM2.37(VSS_16) DIMM2.39(VSS_17) DIMM2.42(VSS_18) DIMM2.44(VSS_19) DIMM2.46(VSS_20) DIMM2.48(VSS_21) DIMM2.50(VSS_22) DIMM2.53(VSS_23) DIMM2.55(VSS_24) DIMM2.57(VSS_25) DIMM2.94(VSS_26) DIMM2.96(VSS_27) DIMM2.98(VSS_28) DIMM2.101(VSS_29) DIMM2.103(VSS_30) DIMM2.105(VSS_31) DIMM2.107(VSS_32) DIMM2.109(VSS_33) DIMM2.112(VSS_34) DIMM2.114(VSS_35) DIMM2.116(VSS_36) DIMM2.118(VSS_37) DIMM2.120(VSS_38) DIMM2.123(VSS_39) DIMM2.125(VSS_40) DIMM2.127(VSS_41) DIMM2.129(VSS_42) DIMM2.131(VSS_43) DIMM2.134(VSS_44) DIMM2.136(VSS_45) DIMM2.138(VSS_46) DIMM2.139(SA0) DIMM2.147(VSS_47) DIMM2.149(VSS_48) DIMM2.151(VSS_49) DIMM2.154(VSS_50) DIMM2.156(VSS_51) DIMM2.158(VSS_52) DIMM2.160(VSS_53) DIMM2.162(VSS_54) DIMM2.165(VSS_55) DIMM2.167(VSS_56) DIMM2.169(VSS_57) DIMM2.171(VSS_58) DIMM2.173(VSS_59) DIMM2.176(VSS_60) DIMM2.178(VSS_61) DIMM2.180(VSS_62) DIMM2.182(VSS_63) DIMM2.184(VSS_64) DIMM2.187(VSS_65) DIMM2.189(VSS_66) DIMM2.191(VSS_67) DIMM2.193(VSS_68) DIMM2.195(VSS_69) DIMM2.198(VSS_70) DIMM2.200(VSS_71) DIMM2.202(VSS_72) DIMM2.238(SA2) DIMM2.239(VSS_73) DIMM2.241(VSS_74) DIMM2.243(VSS_75) DIMM2.246(VSS_76) DIMM2.248(VSS_77) DIMM2.250(VSS_78) DIMM2.252(VSS_79) DIMM2.254(VSS_80) DIMM2.257(VSS_81) DIMM2.259(VSS_82) DIMM2.261(VSS_83) DIMM2.263(VSS_84) DIMM2.265(VSS_85) DIMM2.268(VSS_86) DIMM2.270(VSS_87) DIMM2.272(VSS_88) DIMM2.274(VSS_89) DIMM2.276(VSS_90) DIMM2.279(VSS_91) DIMM2.281(VSS_92) DIMM2.283(VSS_93) DO1.1(A) ECK1.2 ECK3.2 ECK4.2 ECK5.2 ECK6.2 ECK7.2 ECU2.2 ECU3.2 ECU6.2 ECU7.2 ECU9.2 ECU10.2 ECU13.2 ECX7.2 ECX10.2 ECX11.2 ECX12.2 EEPROM_G.1(E0) EEPROM_G.2(E1) EEPROM_G.4(VSS) EEPROM_G.7(W\C\) F_USB2.4 F_USB2.8 F_USB2.9 F_USB2.10 F_USB2.11 F_USB2.12 F_USB3.4(GND_1) F_USB3.7(GND_DRAIN_1) F_USB3.13(GND_2) F_USB3.16(GND_DRAIN_2) F_USB3.19(MT1) F_USB3.20(MT2) F_USB3.21(MT3) F_USB3.22(MT4) FAN_CPU.4 FAN_SYS.1(SIGNAL) HDMI.2(GND_P2) HDMI.5(GND_P5) HDMI.8(GND_P8) HDMI.11(GND_P11) HDMI.17(GND_P17) HDMI.20(B_GND1) HDMI.21(B_GND2) HDMI.22(B_GND3) HDMI.23(B_GND4) HS_CLIP1.1 HS_CLIP1.2 INT_SPKR.4 KYBD_MOUSE.3 KYBD_MOUSE.9 KYBD_MOUSE.13 KYBD_MOUSE.14 KYBD_MOUSE.15 KYBD_MOUSE.16 KYBD_MOUSE.17 LPC_DEBUG.12 LPC_DEBUG.14 M.2_SSD.1(GND_14) M.2_SSD.3(GND_13) M.2_SSD.9(GND_12) M.2_SSD.15(GND_11) M.2_SSD.21(GND_10) M.2_SSD.27(GND_9) M.2_SSD.33(GND_8) M.2_SSD.39(GND_7) M.2_SSD.45(GND_6) M.2_SSD.51(GND_5) M.2_SSD.57(GND_4) M.2_SSD.71(GND_3) M.2_SSD.73(GND_2) M.2_SSD.75(GND_1) M.2_SSD.76(HOLD_GND1) M.2_SSD.77(HOLD_GND2) MH2.1 MH2.2 MH2.3 MH2.4 MH2.5 MH2.6 MH2.7 MH2.8 MH2.9 MH2.10 MH3.1 MH3.2 MH3.3 MH3.4 MH3.5 MH3.6 MH3.7 MH3.8 MH3.9 MH3.10 MH4.1 MH4.2 MH4.3 MH4.4 MH4.5 MH4.6 MH4.7 MH4.8 MH4.9 MH4.10 MH5.1 MH5.2 MH5.3 MH5.4 MH5.5 MH5.6 MH5.7 MH5.8 MH5.9 MH5.10 MH6.1 MH6.2 MH6.3 MH6.4 MH6.5 MH6.6 MH6.7 MH6.8 MH6.9 MH6.10 MH7.1 MH7.2 MH7.3 MH7.4 MH7.5 MH7.6 MH7.7 MH7.8 MH7.9 MH7.10 MH8.1 MH8.2 MH8.3 MH8.4 MH8.5 MH8.6 MH8.7 MH8.8 MH8.9 MH8.10 NIC_USB.4(GND1) NIC_USB.8(GND2) NIC_USB.23(GND3) NIC_USB.24(GND4) NIC_USB.25(GND5) NIC_USB.26(GND6) NIC_USB.27(GND7) NIC_USB.28(GND8) NIC_USB.29(GND9) NIC_USB.30(GND10) P1.2 PAD1.2 PC1.2 PC2.2 PC17.2 PC18.2 PC21.2 PC22.2 PC24.2 PC25.2 PC26.2 PC30.2 PC32.2 PC33.2 PC34.2 PC35.2 PC38.2 PC39.2 PC40.2 PC42.2 PC43.2 PC44.2 PC45.2 PC46.2 PC47.2 PC48.2 PC49.2 PC50.2 PC57.1 PC58.2 PC59.2 PC61.2 PC62.2 PC63.1 PC66.2 PC67.2 PC68.2 PC69.2 PC70.2 PC71.2 PC72.2 PC73.2 PC80.2 PC81.1 PC82.2 PC83.2 PC84.1 PC86.2 PC88.2 PC89.2 PC90.2 PC92.2 PC93.2 PC94.2 PC98.2 PC100.2 PC102.2 PC106.2 PC108.2 PC110.2 PC115.2 PC117.2 PC121.2 PC124.2 PC128.2 PC129.2 PC130.2 PC131.2 PC132.2 PC133.2 PC134.2 PC135.2 PC136.2 PC137.2 PC138.2 PC139.2 PC140.2 PC141.2 PC142.2 PC143.2 PC144.2 PC148.2 PC149.2 PC150.2 PC151.2 PC154.2 PC158.2 PC159.2 PC160.2 PC161.2 PC162.2 PC166.2 PC168.2 PC169.2 PC170.2 PC171.2 PC172.2 PC174.2 PC178.2 PC179.2 PC181.2 PC183.2 PC185.2 PC186.2 PC187.2 PC188.2 PC189.2 PC190.2 PC191.2 PC192.2 PC193.2 PC195.2 PC196.2 PC197.2 PC198.2 PC201.2 PC202.2 PC203.2 PC204.2 PC207.2 PC208.2 PC209.2 PC210.2 PC211.2 PC229.2 PC230.2 PC231.2 PC236.2 PC240.1 PC241.2 PC258.2 PC261.2 PC262.2 PC293.2 PC294.2 PC295.2 PC296.2 PC297.2 PC298.2 PC300.2 PC301.2 PC302.2 PC303.2 PC304.2 PC305.2 PC308.2 PC309.2 PC310.2 PC311.2 PC312.2 PC313.2 PC315.2 PC319.2 PC320.1 PC321.2 PC322.2 PC323.2 PC324.2 PC325.1 PC326.2 PC327.2 PC331.2 PC333.2 PC336.2 PC337.2 PC338.2 PC339.2 PC340.2 PC341.2 PC343.2 PC344.2 PC345.2 PC346.2 PC347.2 PC349.2 PC350.1 PCE1.2 PCE2.2 PCE3.2 PCE4.2 PCE7.2 PCE8.1 PCE12.2 PCE13.2 PCE14.2 PCE15.2 PCE16.2 PCE17.2 PCE18.2 PCE19.2 PCE21.2 PCE22.2 PCE23.2 PCE24.2 PCE25.2 PCE26.2 PCE27.2 PCE28.2 PCE30.2 PCE31.2 PCE32.2 PCE33.2 PCE34.2 PCE35.2 PCE36.2 PCE37.2 PL4.1 PQ3.S1 PQ3.S2 PQ4.S1 PQ4.S2 PQ9.S(SOURCE) PQ16.S(SOURCE) PQ17.1(S1) PQ17.2(S2) PQ17.3(S3) PQ19.S2 PQ20.1(EMITTER) PQ20.4(EMITTER) PQ21.S(SOURCE) PQ22.S1 PQ22.S2 PQ24.S1 PQ24.S2 PQ30.1(S1) PQ30.2(S2) PQ30.3(S3) PQ31.1(S1) PQ31.2(S2) PQ31.3(S3) PQ33.1(S1) PQ33.2(S2) PQ33.3(S3) PQ34.1(S1) PQ34.2(S2) PQ34.3(S3) PQ36.1(S1) PQ36.2(S2) PQ36.3(S3) PQ37.1(S1) PQ37.2(S2) PQ37.3(S3) PQ39.1(S1) PQ39.2(S2) PQ39.3(S3) PQ40.1(S1) PQ40.2(S2) PQ40.3(S3) PQ42.1(S1) PQ42.2(S2) PQ42.3(S3) PQ43.1(S1) PQ43.2(S2) PQ43.3(S3) PQ44.4(S2-1) PQ44.5(S2-2) PQ44.6(S2-3) PQ45.5(S2-1) PQ45.6(S2-2) PQ45.7(S2-3) PQ46.S(SOURCE) PQ47.E(EMITTER) PQ49.S1 PQ49.S2 PQ52.S1 PQ52.S2 PQ55.S1 PQ55.S2 PQ57.S(SOURCE) PQ60.1(S1) PQ60.2(S2) PQ60.3(S3) PQ61.1(S1) PQ61.2(S2) PQ61.3(S3) PQ71.S(SOURCE) PQ72.1(EMITTER) PQ76.E(EMITTER) PQ78.S1 PQ78.S2 PQ79.1(EMITTER) PQ79.4(EMITTER) PR11.2 PR22.2 PR27.2 PR28.2 PR32.2 PR34.2 PR46.1 PR47.2 PR48.2 PR49.2 PR52.2 PR55.2 PR56.2 PR71.2 PR74.2 PR88.2 PR90.2 PR92.2 PR107.1 PR109.1 PR111.1 PR113.1 PR115.1 PR122.1 PR146.1 PR157.1 PR159.2 PR162.2 PR165.2 PR166.1 PR172.2 PR178.2 PR184.2 PR190.2 PR196.2 PR203.1 PR204.1 PR205.2 PR211.1 PR224.2 PR233.2 PR240.2 PR241.2 PR242.2 PR248.2 PR249.2 PR254.2 PR263.2 PR264.2 PR267.2 PR270.2 PR272.2 PR273.2 PR274.2 PR284.2 PR345.2 PR380.2 PU2.11(GND) PU3.2(GND) PU3.9(PAD) PU5.3(\\P\F\M\) PU5.4(AGND) PU5.12(PGND1) PU5.13(PGND2) PU5.14(PGND3) PU5.15(PGND4) PU5.19(PGND5) PU7.57(GND) PU8.6(GND) PU8.9(PAD) PU9.6(GND) PU9.9(PAD) PU10.6(GND) PU10.9(PAD) PU11.6(GND) PU11.9(PAD) PU12.6(GND) PU12.9(PAD) PU13.11(GND) PU14.2(GND) PU16.21(GND) PU18.4(GND) PU20.2(GND) PU21.1(NC) PU21.3(GND) PWR_SW.3(S2) PWR_SW.5(MT1) PWR_SW.6(MT2) QA3.S(SOURCE) QL4.E(EMITTER) QL5.E(EMITTER) QL6.E(EMITTER) QM1.E(EMITTER) QM2.1(EMITTER) QM2.4(EMITTER) QO3.1(EMITTER) QO3.4(EMITTER) QO5.1(EMITTER) QO5.4(EMITTER) QO6.1(EMITTER) QO6.4(EMITTER) QO12.1(EMITTER) QO12.4(EMITTER) QO14.1(EMITTER) QO14.4(EMITTER) QS11.S1 QS11.S2 QV22.S(SOURCE) QV72.S(SOURCE) R1.1 R3.2 R12.1 R15.1 R16.1 R17.1 R21.1 R22.1 R25.1 R26.1 R27.1 R30.1 R31.1 R33.1 R37.1 R38.1 R39.1 R40.1 R45.1 R46.1 R47.1 R49.1 R65.2 R70.2 R72.2 R75.2 R78.2 R80.2 R82.2 R83.2 R90.1 R98.1 R101.1 R103.1 R106.2 R108.1 R109.1 R121.2 R152.1 R381.2 R6298.2 R6331.2 R6466.1 R6518.2 R6531.2 R6582.2 R6591.2 R6595.2 R6602.2 R6603.1 R6605.1 R6607.2 R6628.2 R6636.2 R6638.1 R6639.2 R6640.2 R6641.1 R6681.2 RA6.2 RA9.1 RA12.1 RA22.2 RA34.2 RA35.2 RA42.2 RA43.2 RA44.2 RA59.1 RB12.2 RB13.2 RD1.2 RD7.2 RD10.2 RF3.2 RF13.2 RF26.2 RF29.1 RF30.2 RF34.2 RG8.2 RG10.2 RG12.2 RG14.2 RG15.2 RG16.2 RG17.2 RG27.2 RG29.2 RG32.1 RH3.1 RK11.1 RK25.1 RK31.1 RK33.1 RK34.1 RK35.1 RK36.1 RK39.1 RK41.1 RK44.2 RK45.2 RL33.1 RL35.2 RL44.1 RNK4.3 RNK4.4 RNK7.3 RNK7.4 RNX4.1 RNX4.4 RO5.2 RO21.2 RO28.1 RO36.1 RO45.2 RO48.2 RO52.2 RO53.2 RO54.2 RO57.2 RO117.1 RO169.2 RO171.2 RO176.2 RP5.2 RP8.2 RP34.2 RP35.2 RS123.2 RS124.2 RS166.2 RS169.2 RS234.2 RS236.2 RST_SWH.2 RTK_LAN.33(GND) RTK_VGA.11(BLUE_N) RTK_VGA.13(GREEN_N) RTK_VGA.14(GND_DAC) RTK_VGA.16(RED_N) RTK_VGA.33(EPAD_GND) RU29.2 RU47.2 RU68.2 RU135.2 RV79.2 RV80.2 RX17.1 RX18.1 SATA0.1(GND1) SATA0.4(GND2) SATA0.7(GND3) SATA0.8(HOLD1) SATA0.9(HOLD2) SATA1.1(GND1) SATA1.4(GND2) SATA1.7(GND3) SATA1.8(HOLD1) SATA1.9(HOLD2) SATA2.1(GND1) SATA2.4(GND2) SATA2.7(GND3) SATA2.8(HOLD1) SATA2.9(HOLD2) SATA_PWR.1(2) SATA_PWR.3(4) SIO_5553.1(VSS1) SIO_5553.3(VSS2) SIO_5553.17(VSS3) SIO_5553.18(AVSS) SIO_5553.35(VSS4) SIO_5553.40(HVSS) SIO_5553.59(VSS5) SIO_5553.66(VSS6) SIO_5553.82(VSS7) SIO_5553.83(VSS8) SIO_5553.86(VSS9) SIO_5553.88(VSS10) SIO_5553.90(VSS11) SIO_5553.117(VSS12) SLOT1.A1(PRSNT1#) SLOT1.A4(GND35) SLOT1.A12(GND36) SLOT1.A15(GND37) SLOT1.A18(GND38) SLOT1.A20(GND39) SLOT1.A23(GND40) SLOT1.A24(GND41) SLOT1.A27(GND42) SLOT1.A28(GND43) SLOT1.A31(GND44) SLOT1.A34(GND45) SLOT1.A37(GND46) SLOT1.A38(GND47) SLOT1.A41(GND48) SLOT1.A42(GND49) SLOT1.A45(GND50) SLOT1.A46(GND51) SLOT1.A49(GND52) SLOT1.A51(GND53) SLOT1.A54(GND54) SLOT1.A55(GND55) SLOT1.A58(GND56) SLOT1.A59(GND57) SLOT1.A62(GND58) SLOT1.A63(GND59) SLOT1.A66(GND60) SLOT1.A67(GND61) SLOT1.A70(GND62) SLOT1.A71(GND63) SLOT1.A74(GND64) SLOT1.A75(GND65) SLOT1.A78(GND66) SLOT1.A79(GND67) SLOT1.A82(GND68) SLOT1.B4(GND1) SLOT1.B7(GND2) SLOT1.B13(GND3) SLOT1.B16(GND4) SLOT1.B18(GND5) SLOT1.B21(GND6) SLOT1.B22(GND7) SLOT1.B25(GND8) SLOT1.B26(GND9) SLOT1.B29(GND10) SLOT1.B32(GND11) SLOT1.B35(GND12) SLOT1.B36(GND13) SLOT1.B39(GND14) SLOT1.B40(GND15) SLOT1.B43(GND16) SLOT1.B44(GND17) SLOT1.B47(GND18) SLOT1.B49(GND19) SLOT1.B52(GND20) SLOT1.B53(GND21) SLOT1.B56(GND22) SLOT1.B57(GND23) SLOT1.B60(GND24) SLOT1.B61(GND25) SLOT1.B64(GND26) SLOT1.B65(GND27) SLOT1.B68(GND28) SLOT1.B69(GND29) SLOT1.B72(GND30) SLOT1.B73(GND31) SLOT1.B76(GND32) SLOT1.B77(GND33) SLOT1.B80(GND34) SLOT2.A1(P\R\S\N\T\1\) SLOT2.A4(GND6) SLOT2.A12(GND7) SLOT2.A15(GND8) SLOT2.A18(GND9) SLOT2.B4(GND1) SLOT2.B7(GND2) SLOT2.B13(GND3) SLOT2.B16(GND4) SLOT2.B18(GND5) SLOT3.A12(GND3) SLOT3.A13(GND5) SLOT3.A18(GND8) SLOT3.A24(GND10) SLOT3.A30(GND12) SLOT3.A35(GND14) SLOT3.A37(GND15) SLOT3.A42(GND17) SLOT3.A48(GND19) SLOT3.A56(GND21) SLOT3.B3(GND1) SLOT3.B12(GND2) SLOT3.B13(GND4) SLOT3.B15(GND6) SLOT3.B17(GND7) SLOT3.B22(GND9) SLOT3.B28(GND11) SLOT3.B34(GND13) SLOT3.B38(GND16) SLOT3.B46(GND18) SLOT3.B49(GND20) SLOT3.B57(GND22) SLOT4.A12(GND3) SLOT4.A13(GND5) SLOT4.A18(GND8) SLOT4.A24(GND10) SLOT4.A30(GND12) SLOT4.A35(GND14) SLOT4.A37(GND15) SLOT4.A42(GND17) SLOT4.A48(GND19) SLOT4.A56(GND21) SLOT4.B3(GND1) SLOT4.B12(GND2) SLOT4.B13(GND4) SLOT4.B15(GND6) SLOT4.B17(GND7) SLOT4.B22(GND9) SLOT4.B28(GND11) SLOT4.B34(GND13) SLOT4.B38(GND16) SLOT4.B46(GND18) SLOT4.B49(GND20) SLOT4.B57(GND22) SPI1.4(GND) SPI_1.4(GND) SSUSB_R.4(GND_1) SSUSB_R.7(GND_DRAIN_1) SSUSB_R.13(GND_2) SSUSB_R.16(GND_DRAIN_2) SSUSB_R.19(MT1) SSUSB_R.20(MT2) SSUSB_R.21(MT3) SSUSB_R.22(MT4) U1.3(GND) U4.A2(VSS_298) U4.A3(VSS_300) U4.A4(VSS_301) U4.A18(VSS_0) U4.A25(VSS_1) U4.A32(VSS_2) U4.A37(VSS_3) U4.A42(VSS_286) U4.A44(VSS_288) U4.AA4(VSS_11) U4.AA17(VSS_4) U4.AA18(VSS_5) U4.AA20(VSS_6) U4.AA21(VSS_7) U4.AA25(VSS_8) U4.AA29(VSS_10) U4.AA42(VSS_12) U4.AB4(VSS_20) U4.AB5(VSS_21) U4.AB7(VSS_257) U4.AB8(VSS_29) U4.AB14(VSS_15) U4.AB15(VSS_285) U4.AB31(VSS_17) U4.AB32(VSS_18) U4.AB38(VSS_19) U4.AC1(VSS_22) U4.AC18(VSS_256) U4.AC20(VSS_24) U4.AC21(VSS_25) U4.AC25(VSS_26) U4.AC29(VSS_277) U4.AC45(VSS_28) U4.AD4(VSS_35) U4.AD8(VSS_36) U4.AD11(VSS_161) U4.AD14(VSS_31) U4.AD32(VSS_32) U4.AD33(VSS_33) U4.AD36(VSS_34) U4.AE4(VSS_42) U4.AE18(VSS_37) U4.AE20(VSS_38) U4.AE21(VSS_39) U4.AE25(VSS_40) U4.AE28(VSS_41) U4.AE29(VSS_275) U4.AE42(VSS_43) U4.AF18(VSS_44) U4.AF20(VSS_45) U4.AF21(VSS_46) U4.AF23(VSS_47) U4.AF25(VSS_48) U4.AF26(VSS_49) U4.AF28(VSS_50) U4.AF29(VSS_274) U4.AG4(VSS_58) U4.AG11(VSS_51) U4.AG13(VSS_52) U4.AG31(VSS_54) U4.AG32(VSS_55) U4.AG33(VSS_56) U4.AG38(VSS_57) U4.AH1(VSS_60) U4.AH17(VSS_79) U4.AH18(VSS_61) U4.AH20(VSS_62) U4.AH21(VSS_63) U4.AH23(VSS_64) U4.AH25(VSS_65) U4.AH26(VSS_66) U4.AH28(VSS_67) U4.AH29(VSS_68) U4.AH45(VSS_69) U4.AJ10(VSS_30) U4.AJ14(VSS_70) U4.AJ15(VSS_71) U4.AJ17(VSS_27) U4.AJ18(VSS_72) U4.AJ26(VSS_73) U4.AJ28(VSS_74) U4.AJ29(VSS_75) U4.AJ31(VSS_76) U4.AJ32(VSS_77) U4.AJ36(VSS_78) U4.AK4(VSS_80) U4.AK42(VSS_81) U4.AL4(VSS_284) U4.AL10(VSS_53) U4.AL11(VSS_59) U4.AL13(VSS_82) U4.AL17(VSS_83) U4.AL19(VSS_23) U4.AL24(VSS_16) U4.AL29(VSS_84) U4.AL32(VSS_85) U4.AL33(VSS_86) U4.AL38(VSS_87) U4.AM15(VSS_88) U4.AM17(VSS_9) U4.AM19(VSS_89) U4.AM22(VSS_90) U4.AM24(VSS_91) U4.AM27(VSS_92) U4.AM29(VSS_93) U4.AM45(VSS_94) U4.AN4(VSS_283) U4.AN7(VSS_101) U4.AN8(VSS_102) U4.AN10(VSS_282) U4.AN11(VSS_95) U4.AN22(VSS_96) U4.AN27(VSS_97) U4.AN31(VSS_99) U4.AN39(VSS_100) U4.AP4(VSS_104) U4.AP11(VSS_103) U4.AR5(VSS_280) U4.AR7(VSS_281) U4.AR9(VSS_109) U4.AR33(VSS_106) U4.AR34(VSS_107) U4.AR42(VSS_108) U4.AT9(VSS_113) U4.AT10(VSS_110) U4.AT15(VSS_111) U4.AT36(VSS_112) U4.AU1(VSS_114) U4.AU7(VSS_119) U4.AU35(VSS_115) U4.AU36(VSS_116) U4.AU39(VSS_117) U4.AU45(VSS_118) U4.AV6(VSS_126) U4.AV17(VSS_120) U4.AV24(VSS_122) U4.AV27(VSS_123) U4.AV31(VSS_124) U4.AV33(VSS_125) U4.AW9(VSS_131) U4.AW13(VSS_127) U4.AW19(VSS_128) U4.AW29(VSS_129) U4.AW37(VSS_130) U4.AY38(VSS_132) U4.AY45(VSS_133) U4.B1(VSS_297) U4.B2(VSS_299) U4.B3(VSS_135) U4.B6(VSS_138) U4.B25(VSS_134) U4.B37(VSS_136) U4.B40(VSS_137) U4.B44(VSS_289) U4.B45(VSS_290) U4.BA1(VSS_273) U4.BB1(VSS_296) U4.BB11(VSS_139) U4.BB16(VSS_140) U4.BB21(VSS_141) U4.BB25(VSS_142) U4.BB30(VSS_143) U4.BB34(VSS_144) U4.BC1(VSS_295) U4.BC2(VSS_145) U4.BD2(VSS_294) U4.BD43(VSS_146) U4.BD44(VSS_292) U4.BD45(VSS_293) U4.BE9(VSS_154) U4.BE14(VSS_147) U4.BE18(VSS_148) U4.BE23(VSS_149) U4.BE28(VSS_150) U4.BE32(VSS_151) U4.BE37(VSS_152) U4.BE40(VSS_153) U4.BE44(VSS_291) U4.C1(RSVD<20>) U4.C2(VSS_156) U4.C4(VSS_159) U4.C10(VSS_155) U4.C28(VSS_157) U4.C37(VSS_158) U4.C42(VSS_160) U4.D1(RSVD<19>) U4.D10(VSS_162) U4.D12(VSS_163) U4.D15(VSS_164) U4.D16(VSS_165) U4.D17(VSS_166) U4.D19(VSS_167) U4.D21(VSS_168) U4.D24(VSS_169) U4.D25(VSS_170) U4.D27(VSS_171) U4.D29(VSS_172) U4.D30(VSS_173) U4.D31(VSS_174) U4.D33(VSS_175) U4.D35(VSS_176) U4.D36(VSS_177) U4.D45(VSS_287) U4.E13(VSS_178) U4.E15(VSS_179) U4.E31(VSS_180) U4.E33(VSS_181) U4.F8(VSS_183) U4.F44(VSS_182) U4.G9(VSS_185) U4.G42(VSS_184) U4.H3(VSS_192) U4.H17(VSS_186) U4.H19(VSS_187) U4.H22(VSS_188) U4.H24(VSS_189) U4.H27(VSS_190) U4.H29(VSS_191) U4.H35(VSS_193) U4.J3(VSS_196) U4.J5(VSS_198) U4.J7(VSS_199) U4.J10(VSS_194) U4.J11(VSS_195) U4.J39(VSS_197) U4.K4(VSS_204) U4.K10(VSS_200) U4.K27(VSS_201) U4.K33(VSS_202) U4.K36(VSS_203) U4.K42(VSS_205) U4.K43(VSS_206) U4.L4(VSS_210) U4.L8(VSS_212) U4.L12(VSS_207) U4.L13(VSS_208) U4.L15(VSS_209) U4.L41(VSS_211) U4.M35(VSS_213) U4.M42(VSS_214) U4.N4(VSS_222) U4.N5(VSS_224) U4.N10(VSS_215) U4.N15(VSS_216) U4.N19(VSS_217) U4.N22(VSS_218) U4.N24(VSS_219) U4.N35(VSS_220) U4.N36(VSS_221) U4.N41(VSS_223) U4.P17(VSS_225) U4.P19(VSS_226) U4.P22(VSS_227) U4.P45(VSS_228) U4.R5(VSS_235) U4.R10(VSS_229) U4.R14(VSS_230) U4.R22(VSS_231) U4.R29(VSS_232) U4.R33(VSS_233) U4.R38(VSS_234) U4.T1(VSS_236) U4.T2(VSS_237) U4.T4(VSS_238) U4.T42(VSS_239) U4.U4(VSS_251) U4.U8(VSS_252) U4.U10(VSS_240) U4.U11(VSS_241) U4.U14(VSS_242) U4.U15(VSS_276) U4.U17(VSS_243) U4.U18(VSS_244) U4.U28(VSS_245) U4.U29(VSS_246) U4.U31(VSS_247) U4.U32(VSS_248) U4.U33(VSS_249) U4.U38(VSS_250) U4.V3(VSS_259) U4.V18(VSS_253) U4.V20(VSS_254) U4.V21(VSS_255) U4.V23(VSS_105) U4.V25(VSS_98) U4.V29(VSS_258) U4.V45(VSS_260) U4.W4(VSS_266) U4.W8(VSS_267) U4.W14(VSS_261) U4.W31(VSS_262) U4.W32(VSS_263) U4.W33(VSS_264) U4.W38(VSS_265) U4.Y17(VSS_268) U4.Y18(VSS_269) U4.Y20(VSS_270) U4.Y21(VSS_271) U4.Y26(VSS_279) U4.Y28(VSS_278) U4.Y29(VSS_272) U122.1(EMITTER) U139.3(GND) UA1.49(GND) UA2.2(GND) UF1.9(GND1) UF1.16(GND2) UF1.23(GND3) UF1.32(GND4) UF1.33(B.M) UF2.11(GND1) UF2.16(GND2) UF2.26(GND3) UF2.32(GND4) UF2.33(GND5) UF3.4(GND) UF147.4(V-) UF147.5(+IN) UK2.2(GND) UO2.11(GND) UU1.2(GND) UU3.2(GND) UU4.2(GND) UU6.3(VN) UU7.3(VN) UU9.2(GND) UU10.3(VN) UU13.2(GND) UU17.2 UU18.2 UU26.3(VN) UU27.2(GND) UV7.3(VN) UX1.3(GND) VGA_COM.A5(20) VGA_COM.B5(5) VGA_COM.B6(6) VGA_COM.B7(7) VGA_COM.B8(8) VGA_COM.B10(10) VGA_COM.B11(11) VGA_COM.H1(26) VGA_COM.H2(27) VGA_COM.H3(28) VGA_COM.H4(29) WF_BT_USB.7 WF_BT_USB.8(9) XDP_CPU.2(VSS2) XDP_CPU.7(VSS3) XDP_CPU.8(VSS4) XDP_CPU.13(VSS5) XDP_CPU.14(VSS6) XDP_CPU.19(VSS7) XDP_CPU.20(VSS8) XDP_CPU.25(VSS9) XDP_CPU.26(VSS10) XDP_CPU.31(VSS11) XDP_CPU.32(VSS12) XDP_CPU.37(VSS13) XDP_CPU.38(VSS14) XDP_CPU.49(VSS15) XDP_CPU.50(VSS16) XDP_CPU.59(VSS17) XDP_PCH.1(VSS1) XDP_PCH.2(VSS2) XDP_PCH.7(VSS3) XDP_PCH.8(VSS4) XDP_PCH.13(VSS5) XDP_PCH.14(VSS6) XDP_PCH.19(VSS7) XDP_PCH.20(VSS8) XDP_PCH.25(VSS9) XDP_PCH.26(VSS10) XDP_PCH.31(VSS11) XDP_PCH.32(VSS12) XDP_PCH.37(VSS13) XDP_PCH.38(VSS14) XDP_PCH.49(VSS15) XDP_PCH.50(VSS16) XDP_PCH.59(VSS17) XDP_PCH.60(VSS18/XDP_PRESENT#) Y1.2(G1) Y1.4(G2) Y5.2(G2) Y5.3(G3)
VCC_AUD: CA6.1 CA7.1 FBA1.2 UA1.26(AVDD1)
VCC_OBS_AB: R118.1 XDP_CPU.43(VCC_OBS_AB)
VCC_OBS_CD: R119.1 XDP_CPU.44(VCC_OBS_CD)
VCC_OBS_R: RS21.2 XDP_PCH.43(VCC_OBS_AB) XDP_PCH.44(VCC_OBS_CD)
VCC_OPC_R: CPU.AB37(VCC_OPC_1P8[1]) CPU.AB38(VCC_OPC_1P8[0]) R6641.2
VCCEOPIO_R: CPU.AJ25(VCCEOPIO[0]) CPU.AJ26(VCCEOPIO[1]) R6640.1
VCCGT_HSN_1: PC152.2 PR185.1
VCCGT_HSN_2: PC167.2 PR192.1
VCCGT_PWM1_10: PU7.47(PWMA1) PU11.2(PWM)
VCCGT_PWM2_10: PU7.46(PWMA2) PU12.2(PWM)
VCCGT_SENSE: CPU.F39(VCCGT_SENSE) PR161.1
VCCGTX2_L31: CPU.F35(VCCGTX[11]) CPU.G34(VCCGTX[10]) CPU.G35(VCCGTX[9]) CPU.H33(VCCGTX[8]) CPU.H34(VCCGTX[7]) CPU.J33(VCCGTX[6]) CPU.J35(VCCGTX[5]) CPU.K32(VCCGTX[4]) CPU.K34(VCCGTX[3]) CPU.L31(VCCGTX[2]) CPU.L33(VCCGTX[1]) CPU.M32(VCCGTX[0]) R6638.2
VCCHDA_BA15: RP42.2 U4.BA15(VCCHDA)
VCCIO_EN: PC197.1 PQ49.D2 PR215.2 PU14.1(EN)
VCCIO_PG: PC181.1 PQ46.D(DRAIN) PR202.2 PU13.3(EN)
VCCIO_SENSE: CPU.AF4(VCCIO_SENSE) PR223.2
VCCK_V12: CG22.2 CG26.2 CG27.1 RTK_VGA.19(VCCK_12) RTK_VGA.25(AVCC_12)
VCCOPC_R: CPU.AJ27(VCCOPC[4]) CPU.AJ28(VCCOPC[3]) CPU.AJ29(VCCOPC[2]) CPU.AJ30(VCCOPC[1]) CPU.AK27(VCCOPC[0]) R6639.1
VCCPGPPA: C1678.1 R6566.1 U4.BA31(VCCPGPPA)
VCCPGPPCD_BA45: RP38.2 U4.BA45(VCCPGPPCD<1>) U4.BB45(VCCPGPPCD<3>) U4.BC44(VCCPGPPCD<0>) U4.BC45(VCCPGPPCD<2>)
VCCPLL_OC_R: CPU.AJ9(VCCPLL_OC) R6500.1
VCCPRIM_AL22: RP36.1 U4.AL22(VCCPRIM_1P0[12])
VCCPRIM_BE3: RP37.1 U4.BD3(VCCPRIM_3P3<3>) U4.BE3(VCCPRIM_3P3<1>) U4.BE4(VCCPRIM_3P3<2>)
VCCSA_SENSE: CPU.AD5(VCCSA_SENSE) PR208.1
VCCSOKET: CPU.C38(VCC_SENSE) PR149.1
VCCSPI: R6568.1 RA10.2 RA11.2 RA13.2 RA14.2 U4.BE41(VCCSPI<2>) U4.BE42(VCCSPI<1>) U4.BE43(VCCSPI<0>)
VCCST_PWRGD_1V: CPU.U2(VCCST_PWRGD) R6296.1 R6298.1 R6546.1
VDD10: CL42.1 CL43.1 CL44.1 CL45.1 CL46.1 CL47.1 CL48.1 CL49.1 LL2.2 RL36.2 RTK_LAN.3(AVDD10(1)) RTK_LAN.8(AVDD10(2)) RTK_LAN.22(DVDD10) RTK_LAN.30(AVDD10(3))
VDD_DAC_33: CG20.2 CG21.1 FBG2.2 RTK_VGA.9(VDD_DAC_33)
VDDA_1P5V: BRIDGE.F13(VDDA_15_2) BRIDGE.H13(VDDA_15_1) CK1.1 CK2.1 CK4.1 CK6.1 CK35.1 FBK1.2
VDDA_3P3V: BRIDGE.D13(VDDA_33) CK3.1 CK36.1 CK37.1 FBK3.2
VDDQ_SN: PC37.2 PR47.1
VDDQ_VTT_REFEN: PC49.1 PQ20.3(COLLECTOR) PR53.2 PR55.1 PU3.3(REFEN)
VSS_AB10: RP34.1 U4.AB10(VSS_13)
VSS_AB11: RP35.1 U4.AB11(VSS_14)
VSSGT_SENSE: CPU.F38(VSSGT_SENSE) PR153.1
VSSSAIO_SENSE: CPU.AE4(VSS_SAIO_SENSE) PJP19.2
VSSSOKET: CPU.D38(VSS_SENSE) PR148.1
1P0V_PCH_BOOT_25: PC64.1 PU5.20(BST)
1P0V_PCH_EN: PC262.1 PQ78.D2 PR70.2 PU5.2(EN)
1P0V_PCH_FB: PR73.1 PR74.1 PR75.2 PU5.5(FB)
1P0V_PCH_FB_R: PJP4.1 PR73.2
1P0V_PCH_PG: PC62.1 PR68.2 PU5.1(PGOOD)
1P0V_PCH_PHASE: PC64.2 PC65.1 PL3.1 PU5.10-11(LX1) PU5.16(LX2) PU5.17(LX3) PU5.18(LX4)
1P0V_PCH_SS: PC72.1 PU5.23(SS)
1P0V_PCH_TON: PR67.1 PU5.6(TON)
1P0V_PCH_VCCDSW: C1645.1 U4.BA29(DCPDSW_1P0)
1P0V_PCH_VCCF24_FB_R: C1670.1 C1671.1 C1672.1 L62.2 R6464.1 R6473.2 U4.K2(VCCCLK5[0]) U4.K3(VCCCLK5[1])
1P0V_PCH_VIN: PC58.1 PC59.1 PC61.1 PFB4.1 PR67.2 PU5.7-9(IN1) PU5.22(IN2)
1P0V_VCCAMPHYPLL_FB_R: C1664.1 C1665.1 C1666.1 L61.2 R6472.2 U4.A43(VCCMPHYPLL_1P0<1>) U4.B43(VCCMPHYPLL_1P0<0>) U4.C44(VCCPCIE3PLL_1P0<1>) U4.C45(VCCPCIE3PLL_1P0<0>)
1P0V_VCCAPLL_FB_R: C1660.1 C1661.1 L60.2 R6471.2 U4.AJ5(VCCUSB2PLL_1P0<0>) U4.AL5(VCCUSB2PLL_1P0<1>) U4.AN19(VCCHDAPLL_1P0)
+1P0V_PCH_AUX: C1654.1 C1655.1 C1667.1 C1668.1 C1677.1 C1679.1 CS97.1 CS111.1 L60.1 L61.1 L62.1 PC66.1 PC67.1 PC68.1 PC69.1 PC70.1 PCE7.1 PJP4.2 PL3.2 PQ23.D(DRAIN) QO2.4(EMITTER) R87.1 R118.2 R119.2 R6471.1 R6472.1 R6473.1 R6513.1 RH1.2 RP36.2 RS21.1 U4.AA23(VCCPRIM_1P0[6]) U4.AA26(VCCPRIM_1P0[7]) U4.AA28(VCCPRIM_1P0[5]) U4.AC17(VCCPRIM_1P0[11]) U4.AC23(VCCPRIM_1P0[0]) U4.AC26(VCCPRIM_1P0[1]) U4.AC28(VCCPRIM_1P0[4]) U4.AD15(VCCPRIM_1P0[10]) U4.AE23(VCCPRIM_1P0[2]) U4.AE26(VCCPRIM_1P0[3]) U4.AJ20(VCCPRIM_1P0[16]) U4.AJ21(VCCPRIM_1P0[15]) U4.AJ23(VCCPRIM_1P0[14]) U4.AJ25(VCCPRIM_1P0[13]) U4.N17(VCCCLK1) U4.R17(VCCCLK6) U4.R19(VCCCLK3) U4.U20(VCCCLK4) U4.U21(VCCMPHY_1P0<1>) U4.U23(VCCMPHY_1P0<2>) U4.U25(VCCMPHY_1P0<3>) U4.U26(VCCMPHY_1P0<4>) U4.V17(VCCCLK2) U4.V26(VCCMPHY_1P0<0>) U4.V28(VCCMPHYGT_1P0) U4.Y23(VCCPRIM_1P0[8]) U4.Y25(VCCPRIM_1P0[9])
+1P0V_PCH_SN: PC65.2 PR71.1
+1P0V_VCCST: C70.1 C1722.1 C1728.1 CO12.2 CPU.V4(VCCPLL) CPU.V5(VCCST[0]) CPU.V6(VCCST[1]) PC93.1 PQ23.S(SOURCE) PR49.1 PR69.2 PR130.1 PR131.2 PR132.2 R7.1 R8.1 R9.1 R51.1 R52.1 R116.1 R117.1 R6513.2 R6585.1 R6680.1 RO12.1 RS227.1 SIO_5553.29(PECI_VREF)
+1P2V_VDDQ_BOOT_20: PR40.1 PU2.10(BOOT)
+1P2V_VDDQ_BOOT_R20: PC36.1 PR40.2
+1P2V_VDDQ_CS: PR48.1 PU2.2(CS)
+1P2V_VDDQ_EN: PQ19.D2 PR42.2 PU2.3(EN)
+1P2V_VDDQ_FB: PC41.1 PR50.1 PR51.1 PR52.1 PU2.4(FB)
+1P2V_VDDQ_FB_R: PC41.2 PC42.1 PJP2.1 PR50.2
+1P2V_VDDQ_LG_30: PQ17.4(G) PU2.6(LGATE)
+1P2V_VDDQ_PHASE_20: PC36.2 PC37.1 PL2.1 PQ15.1(S1) PQ15.2(S2) PQ15.3(S3) PQ17.5(D1) PR45.2 PU2.8(PHASE)
+1P2V_VDDQ_RF: PR46.2 PU2.5(RF)
+1P2V_VDDQ_UG_20: PR44.1 PU2.9(UGATE)
+1P2V_VDDQ_UG_R20: PQ15.4(G) PR44.2 PR45.1
+1P2V_VDDQ_VCC: PC34.1 PR39.1 PU2.7(VCC)
+1P2V_VDDQ_VIN: PC32.1 PC33.1 PCE1.1 PFB2.1 PFB3.1 PQ15.5(D1)
+1P5V_VA: CA88.1 CA101.1 FBA2.1 RA33.1 RA34.1 UA2.4(VOUT)
+1P5V_VA_ADJ: CA101.2 RA33.2 RA35.1 UA2.5(SET)
+3P3V_AUX: BH1.5(VCC) BRIDGE.J11(VDD_33_AUX) C1648.2 C1649.2 C1656.1 C1657.1 C1681.2 C1684.2 C1686.2 C1688.1 C1689.2 C1764.2 CK38.1 CO10.2 PQ2.1(DRAIN1) PQ2.2(DRAIN2) PQ2.5(DRAIN3) PQ2.6(DRAIN4) PQ7.D(DRAIN) PR15.2 PR27.1 PR28.1 PR42.1 PR43.1 PR68.1 PR70.1 PR216.1 PR279.1 PR381.1 QO4.1(EMITTER) R19.2 R67.1 R68.1 R69.2 R71.2 R74.1 R77.2 R81.1 R85.1 R86.1 R88.1 R91.1 R99.1 R100.1 R104.1 R105.1 R112.2 R508.1 R663.1 R6352.1 R6391.1 R6392.1 R6413.1 R6533.1 R6566.2 R6568.2 R6573.2 R6604.1 R6606.1 R6608.1 R6618.1 R6619.1 R6649.1 R6665.1 R6668.1 R6669.1 RB1.1 RB7.2 RF59.2 RG22.1 RH4.1 RH5.1 RH6.2 RH8.1 RH9.1 RH10.1 RK27.1 RK28.1 RO32.1 RO39.1 RO55.1 RO80.1 RO163.1 RO179.1 RO187.1 RP25.2 RP37.2 RP38.1 RP40.2 RP41.2 RP42.1 RS89.1 RS90.1 RS127.1 RS129.1 RS159.1 RS161.1 RS222.1 RS233.1 RS235.1 RU46.1 RU174.1 RX165.1 SIO_5553.27(V3_S5) U4.AD41(VCCPGPPG) U4.AJ41(VCCPGPPEF<1>) U4.AL41(VCCPGPPEF<0>) U4.AN5(VCCPRIM_3P3<0>) U4.BA20(VCCRTCPRIM_3P3) U4.BC42(VCCPGPPBH<1>) U4.BD40(VCCPGPPBH<0>)
+3P3V_LPS_LDO: PC338.1 PR275.2 PU16.3(LDO3) PU16.6(EN2)
