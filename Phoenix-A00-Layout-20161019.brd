# Allegro board Phoenix-A00-Layout-20161019.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
F_SPI_WP#: length 15.1
  TOP w0.102: SPI_1.3 SPI1.3 35.37,109.47 35.2,109.65 35.2,111.15 35.02,111.33 34.76,111.33 34.59,111.15 34.59,109.65 34.41,109.47 34.04,109.47 33.91,109.61 33.91,111.57 34.47,112.13 36.94,112.13 v1(37.28,111.79) 37.76,111.31 37.76,110.74 37.96,110.55 RF24.2 38.64,110.8 38.64,111.45 R6642.2
F_TP_XDP_RST: length 8.5
  TOP w0.102: v1(44.23,103.38) 44.01,103.16 RS18.2 RS22.2 44.23,101.35 RS232.2 45.56,100.84 48.67,100.84 48.94,100.58 XDP_PCH.39
F_USB2_N9: length 220.3
  TOP w0.089: U4.AA1 58.64,135.17 58.78,135.17 60.36,136.75 60.36,137.54 60.36,137.55 60.36,137.57
  TOP w0.102: UR57.1 162.14,24.22 UL19.4 162.14,24.34 162.46,24.65 162.46,24.89 162.21,25.14 159.68,25.14 158.27,26.55 156.61,26.55 146.55,36.6 141.05,36.6 121.39,56.26 92.91,56.26 83.37,65.8 83.37,83.91 79.59,87.7 79.59,91.96 77.83,96.19 77.83,105.17 79.77,107.11 79.77,112.73 83.85,116.82 83.85,122.5 82.84,123.52 82.84,135.14 79.36,138.61 75.44,138.61 73.82,140.23 70.53,140.23 69.53,141.23 69.53,142.27 66.39,145.41 66.39,145.78 65.69,146.48 65.69,148.1 64.24,149.56 63.86,149.56 63.4,150.02 63.4,150.58 63.2,150.77 v1(63.05,150.77) ; v1(61.63,144.53) 61.63,144.48 61.4,144.25 61.04,144.25 60.79,143.99 60.79,143.1 60.36,142.67 60.36,137.57
  BOTTOM w0.102: v1(63.05,150.77) 63.34,150.77 63.55,150.56 63.55,150.21 63.86,149.91 63.86,149.37 64.2,149.03 64.74,149.03 64.9,148.86 64.9,146.97 v2(63.46,145.53) 62.18,144.25 61.91,144.25 v1(61.63,144.53)
F_USB2_N10: length 235.8
  TOP w0.089: U4.AJ8 v1(53.66,131.42)
  TOP w0.102: UR13.1 165.49,24.22 UL5.3 165.49,24.34 165.19,24.64 165.19,24.91 163.97,26.13 160.12,26.13 158.69,27.56 156.91,27.56 146.88,37.59 141.33,37.59 121.77,57.15 93.28,57.15 84.26,66.17 84.26,84.28 80.47,88.07 80.47,92.14 78.72,96.37 78.72,104.71 80.66,106.65 80.66,112.36 84.74,116.44 84.74,122.87 83.73,123.89 83.73,135.51 79.73,139.5 75.81,139.5 74.19,141.12 71.97,141.12 67.28,145.81 67.28,146.15 66.58,146.85 66.58,148.5 64.73,150.34 64.73,151.49 63.92,152.3 57.33,152.3 56.11,151.08 55.74,151.08 55.58,151.23 v1(55.58,151.53)
  BOTTOM w0.089: v1(53.66,131.42) 53.83,131.58 54.07,131.58 54.44,131.96 54.44,132.45 54.12,132.77 54.12,134.55 53.18,135.5 53.18,135.99 53.19,135.99 53.19,136.02
  BOTTOM w0.102: 53.19,136.02 53.19,138.69 53.7,139.21 53.7,140.64 56.4,143.33 56.4,145.02 57.06,145.68 57.06,146.61 55.13,148.54 v2(55.13,149.25) 55.13,150 55.76,150.64 55.76,150.95 55.58,151.13 v1(55.58,151.53)
F_USB2_P9: length 220.3
  TOP w0.089: 60.56,137.57 60.56,137.55 60.55,137.54 60.55,136.67 58.65,134.77 U4.AA2
  TOP w0.102: 60.56,137.57 60.56,142.59 60.99,143.02 60.99,143.91 61.13,144.04 61.35,144.04 v1(61.63,143.76) ; v1(63.96,150.77) 63.79,150.77 63.6,150.59 63.6,150.1 63.95,149.76 64.32,149.76 65.9,148.18 65.9,146.56 66.59,145.87 66.59,145.49 69.73,142.35 69.73,141.32 70.61,140.44 73.9,140.44 75.52,138.82 79.45,138.82 83.04,135.22 83.04,123.6 84.06,122.58 84.06,116.74 79.97,112.65 79.97,107.02 78.04,105.09 78.04,96.23 79.79,92 79.79,87.78 83.57,84 83.57,65.88 92.99,56.46 121.48,56.46 141.14,36.8 146.64,36.8 156.69,26.75 158.35,26.75 159.76,25.34 162.29,25.34 162.66,24.98 162.66,24.63 162.95,24.34 UL19.3 162.95,24.22 UR58.1
  BOTTOM w0.102: v1(63.96,150.77) 63.76,150.57 63.76,150.3 v2(64.44,149.61) 65.11,148.95 65.11,146.89 64.05,145.83 64.05,145.29 63.7,144.95 63.17,144.95 62.26,144.04 61.91,144.04 v1(61.63,143.76)
F_USB2_P10: length 235.8
  TOP w0.089: v1(53.8,132.21) 54.16,132.21 54.36,132.41 U4.AJ7
  TOP w0.102: UR14.1 164.68,24.22 UL5.4 164.68,24.34 164.98,24.64 164.98,24.83 163.88,25.93 160.03,25.93 158.61,27.36 156.83,27.36 146.79,37.39 141.25,37.39 121.69,56.95 93.19,56.95 84.06,66.08 84.06,84.2 80.27,87.98 80.27,92.1 78.52,96.33 78.52,104.8 80.45,106.73 80.45,112.44 84.54,116.53 84.54,122.79 83.52,123.8 83.52,135.42 79.65,139.3 75.72,139.3 74.1,140.92 71.88,140.92 67.07,145.73 67.07,146.07 66.38,146.76 66.38,148.41 64.53,150.26 64.53,151.4 63.84,152.1 57.41,152.1 56.19,150.88 55.65,150.88 55.4,151.13 55.19,151.13 v1(55.04,150.99)
  BOTTOM w0.089: v1(53.8,132.21) 53.78,132.18 53.78,131.86 53.87,131.78 53.99,131.78 54.25,132.04 54.25,132.37 53.93,132.69 53.93,134.47 52.99,135.42 52.99,135.99 52.99,135.99 52.99,136.02
  BOTTOM w0.102: 52.99,136.02 52.99,138.78 53.5,139.29 53.5,140.72 56.19,143.42 56.19,145.1 56.47,145.38 v2(56.47,145.92) 56.85,146.3 56.85,146.52 54.92,148.45 54.92,148.63 54.54,149.01 54.54,149.49 54.92,149.87 54.92,150.09 55.56,150.72 55.56,150.87 55.44,150.99 v1(55.04,150.99)
F_USB3_N1: length 219.8
  TOP w0.089: v1(55.08,133.04) 55.29,133.04 U4.AF5
  TOP w0.102: v1(58.05,150.04) 57.82,150.27 57.36,150.27 57.11,150.52 57.11,151.08 57.62,151.59 59.8,151.59 61.51,149.89 62.3,149.89 63.14,149.04 64.05,149.04 65.11,147.98 65.11,146.38 65.9,145.58 65.9,145.21 69.04,142.07 69.04,141.03 70.33,139.75 73.62,139.75 75.24,138.13 79.16,138.13 82.35,134.93 82.35,123.32 83.37,122.3 83.37,117.03 79.28,112.94 79.28,107.35 77.35,105.42 77.35,96.09 79.1,91.87 79.1,87.4 82.89,83.61 82.89,65.6 92.71,55.78 121.19,55.78 148.65,28.32 149.51,28.32 151.45,26.37 LU36.3 151.45,25.28 RU54.1
  BOTTOM w0.089: 54.05,136.02 54.05,135.99 54.05,135.99 54.05,135.6 54.63,135.01 54.63,132.96 54.81,132.78 54.95,132.78 55.08,132.91 v1(55.08,133.04)
  BOTTOM w0.102: v1(58.05,150.04) 58.16,150.14 58.16,150.36 58.02,150.5 57.77,150.5 57.6,150.33 57.6,149.57 57.12,149.09 57.12,148.51 58.45,147.18 58.45,145.6 58.84,145.22 58.84,143.91 57.18,142.25 56.48,142.25 56.32,142.08 56.32,141.55 55.97,141.2 55.43,141.2 54.77,140.54 v2(54.77,139.88) 54.77,138.99 54.41,138.63 54.41,137.34 54.05,136.98 54.05,136.02
F_USB3_N2: length 203.7
  TOP w0.089: U4.AD5 56.12,133.04 v1(56.12,133.04)
  TOP w0.102: RU58.1 148.11,25.28 LU37.4 148.41,25.6 148.41,27.3 120.82,54.89 92.34,54.89 82,65.23 82,83.24 78.21,87.03 78.21,91.69 76.46,95.92 76.46,105.79 78.39,107.72 78.39,113.37 82.48,117.46 82.48,121.88 81.47,122.9 81.47,134.52 78.74,137.24 74.87,137.24 73.25,138.86 69.96,138.86 68.16,140.66 68.16,141.7 65.01,144.84 65.01,145.07 63.6,146.48 63.6,147.24 63.44,147.4 v1(63.05,147.4)
  BOTTOM w0.089: 56.37,137.95 56.37,137.93 56.38,137.93 56.38,135.71 56.35,135.68 56.35,133.13 56.26,133.04 v1(56.12,133.04)
  BOTTOM w0.102: 56.37,137.95 56.37,138.4 59,141.04 59,141.58 59.34,141.92 59.88,141.92 60.46,142.49 v2(60.46,143.61) 60.46,144.92 61.36,145.82 61.88,145.82 62.83,146.77 63.41,146.77 63.74,147.1 63.74,147.42 63.56,147.6 63.25,147.6 v1(63.05,147.4)
F_USB3_P1: length 219.8
  TOP w0.089: U4.AG7 55.44,132.64 v1(55.08,132.28)
  TOP w0.102: v1(57.86,150.93) 57.98,150.93 58.12,150.79 58.12,150.6 57.99,150.47 57.44,150.47 57.31,150.6 57.31,151 57.71,151.39 59.72,151.39 61.43,149.68 62.21,149.68 63.05,148.84 63.96,148.84 64.9,147.9 64.9,146.3 65.7,145.5 65.7,145.12 68.84,141.98 68.84,140.95 70.24,139.55 73.53,139.55 75.15,137.93 79.07,137.93 82.15,134.85 82.15,123.23 83.17,122.22 83.17,117.12 79.08,113.02 79.08,107.43 77.15,105.5 77.15,96.05 78.9,91.83 78.9,87.31 82.68,83.53 82.68,65.51 92.62,55.58 121.11,55.58 148.57,28.11 149.42,28.11 151.25,26.28 151.25,25.84 151.16,25.75 151.15,25.75 150.8,25.75 150.65,25.6 LU36.4 150.65,25.28 RU55.1
  BOTTOM w0.089: v1(55.08,132.28) 55.04,132.28 54.44,132.88 54.44,134.93 53.86,135.52 53.86,135.99 53.85,135.99 53.85,136.02
  BOTTOM w0.102: v1(57.86,150.93) 57.4,150.47 57.4,149.65 56.92,149.17 56.92,148.42 58.25,147.09 58.25,145.52 58.63,145.13 58.63,144 57.09,142.46 56.4,142.46 v2(55.73,141.79) 54.57,140.62 54.57,140.5 54.19,140.12 54.19,139.64 54.57,139.25 54.57,139.07 54.21,138.72 54.21,137.42 53.85,137.06 53.85,136.02
F_USB3_P2: length 203.7
  TOP w0.089: v1(56.12,132.28) 56.12,132.28 U4.AD7
  TOP w0.102: v1(64.32,147.4) 63.93,147.4 63.8,147.27 63.8,146.57 65.22,145.15 65.22,144.92 68.36,141.78 68.36,140.75 70.04,139.06 73.33,139.06 74.95,137.45 78.83,137.45 81.67,134.6 81.67,122.98 82.68,121.97 82.68,117.38 78.59,113.29 78.59,107.64 76.66,105.71 76.66,95.96 78.42,91.73 78.42,87.11 82.2,83.33 82.2,65.31 92.42,55.09 120.91,55.09 148.61,27.39 148.61,25.6 LU37.3 148.91,25.28 RU59.1
  BOTTOM w0.089: 56.57,137.95 56.57,137.93 56.57,137.93 56.57,135.63 56.54,135.61 56.54,132.7 v1(56.12,132.28)
  BOTTOM w0.102: v1(64.32,147.4) 63.49,146.57 62.91,146.57 61.96,145.61 61.45,145.61 60.66,144.83 60.66,144.23 61.04,143.85 61.04,143.37 60.66,142.99 60.66,142.41 v2(59.59,141.33) 56.57,138.32 56.57,137.95
FAN_CPU_PIN1:
  vias: v1(235.39,133.38)
FAN_CPU_PWM:
  vias: v1(238.74,135.99)
FLASH_OVERRIDE#: length 258.9
  TOP w0.102: v1(150.27,35.94) 146.03,40.18 QS10.C 146.03,43.99 P3.2 ; v1(22.39,82.8) 21.93,83.26 21.93,84.2 20.38,85.75 20.38,99.18 18.44,101.12 18.44,106.25 13.55,111.15 13.55,118.82 10.8,121.57 10.8,129.86 15.25,134.31 15.25,135.35 19.98,140.08 23.05,140.08 29.9,146.94 34.89,146.94 37.65,144.18 37.65,141.45 40.74,138.37 40.74,136.91 R6346.1
  BOTTOM w0.102: v1(150.27,35.94) 149.76,36.46 145.87,36.46 144.24,34.83 138.93,34.83 136.55,37.21 116.93,37.21 114.61,39.53 108.69,39.53 105.83,42.39 102.78,42.39 101.52,43.65 99.03,43.65 97.75,44.93 91.52,44.93 85.61,50.84 83.9,50.84 80.69,54.05 75.99,54.05 68.65,61.39 65.76,61.39 64.87,62.29 53.59,62.29 53.28,62.6 47.39,62.6 45.94,61.15 42.61,61.15 40.34,63.42 37.27,63.42 28.61,72.08 28.61,72.77 22.39,78.99 v1(22.39,82.8)
FP_RST#: length 361.2
  TOP w0.089: U4.AW1 49.42,135.39 48.11,136.7 44.85,136.7 43.09,138.46
  TOP w0.102: RB16.1 10.51,119 10.19,119 8.92,120.27 8.92,121.79 9.63,122.5 9.63,133.55 v1(12.99,136.91) ; v1(30.01,155.45) 30.01,159.13 25.18,163.96 16.53,163.96 15.63,164.86 15.63,197.6 14.63,198.59 14.63,199.97 RB6.1 ; v1(101.89,154.18) 102.37,154.18 104.12,155.93 105.11,155.93 107.83,158.65 114,164.83 114,173.56 108.75,178.82 108.75,191.64 v1(114.08,196.98) ; v1(89.07,129.3) 88.86,129.51 88.86,132.76 88.86,133.91 87.64,135.13 87.64,135.71 88.53,136.6 88.53,141.75 89.61,142.83 89.61,145.51 87.17,147.95 86.91,147.95 85.45,149.41 79.91,149.41 76.65,152.67 76.65,155.09 71.35,160.4 69.09,160.4 66.47,163.02 53.63,163.02 51.52,160.91 v1(49.18,160.91) ; 43.09,138.46 43.06,138.49 43.06,138.84 42.9,139 R6431.1 43.09,139.76 43.09,145.37 43.54,145.83 43.54,148.36 42.3,149.61 RIO6.2 CO55.1 42.26,151.49 40.6,153.15 40.18,153.15 36.02,157.3 32.52,157.3 v1(31.94,157.88) ; v1(130.18,209.83) 130.8,209.83 R6659.1
  BOTTOM w0.102: v1(101.89,154.18) 105.9,154.18 107.17,152.91 107.17,148.13 105.42,146.38 105.42,142.95 108.24,140.13 108.24,138.91 106.66,137.34 106.66,136.85 106.74,136.78 106.74,135.15 105.49,133.91 104.96,133.91 104.5,134.37 103.44,134.37 102.34,133.27 101.96,133.27 101.35,132.66 101.35,131.34 100.62,130.61 99.19,130.61 98.69,130.1 95.75,130.1 95.12,130.73 93.34,130.73 92.29,129.67 v2(91.73,129.67) 91.22,129.16 89.21,129.16 v1(89.07,129.3) ; v1(12.99,136.91) 12.99,137.21 18.89,143.12 18.89,144.89 19.38,145.37 19.38,147.98 20.96,149.57 22.63,149.57 25.94,152.88 26.87,152.88 27.26,153.28 27.26,153.95 28.76,155.45 v1(30.01,155.45) 30.01,156.59 31.29,157.88 v1(31.94,157.88) 32.41,158.34 32.9,158.34 33.84,159.28 33.84,160.45 35.15,161.77 36.52,161.77 36.89,161.39 40.22,161.39 40.47,161.14 46.55,161.14 46.94,160.75 49.02,160.75 v1(49.18,160.91) ; v1(114.08,196.98) 114.08,200.3 115.07,201.29 115.07,204.75 118.37,208.05 119.34,208.05 121.57,210.29 129.73,210.29 v1(130.18,209.83)
FPNL_SATA_LED#_R: length 2.6
  TOP w0.102: RIO10.2 201.3,12.4 200.97,12.73 v1(200.97,12.83) 200.97,13.92 200.72,14.18 QO6.2
GPIO0: length 2
  TOP w0.102: UF1.29 34.83,91.87 34.83,91.57 v1(35.42,90.98) 34.83,90.4 RF64.2
GPIO2: length 2.5
  TOP w0.102: RF63.2 38.7,92.27 37.88,93.09 37.88,93.29 v1(37.83,93.34) 37.56,93.61 UF1.3
GPIO4: length 7.2
  TOP w0.102: BRIDGE.M10 56.81,200.98 56.81,201.52 56.55,201.78 56.33,201.78 54.39,203.72 v1(54.39,204.6) RK39.2
  BOTTOM w0.102: v2(54.77,203.58) 54.39,203.96 v1(54.39,204.6)
GPIO_PEG SLOT_RESET: length 311.3
  TOP w0.089: v1(58.58,116.59) 58.88,116.28 U4.W39
  TOP w0.102: U1.2 43.98,253.49 43.47,252.98 v1(43.47,251.21) ; v1(55.35,82.12) 54.06,82.12 53.55,82.63 51.57,82.63 50.42,81.48 49.16,81.48 48.14,82.5 46.71,82.5 45.59,81.38 42.7,81.38 42.27,80.95 39.46,80.95 35.32,76.81 30.72,76.81 29.8,75.89 25.21,75.89 22.51,78.59 22.51,78.9 18.77,82.64 18.77,83.85 18.19,84.43 v1(17.31,84.43) ; v1(59.84,102.48) 60.18,102.48 RP41.1 ; v1(5.26,208.18) 5.26,207.65 5.52,207.39 5.52,185.07 7.2,183.39 9.94,183.39 11.07,182.25 11.07,163.08 13.62,160.53 v1(14.13,160.53)
  BOTTOM w0.089: 59.6,111.25 59.65,111.3 59.65,112.29 59.09,112.85 59.09,116.08 v1(58.58,116.59)
  BOTTOM w0.102: v1(43.47,251.21) 43.44,251.21 39.45,247.22 v2(36.43,247.22) 35.61,247.22 34.42,246.02 32.11,246.02 30.61,247.52 23.49,247.52 22.47,246.51 20.11,246.51 19.13,245.53 19.13,243.85 18.42,243.14 18.42,241.14 17.54,240.25 15.35,240.25 13.63,238.53 6.66,238.53 4.3,236.17 4.3,211.06 5.26,210.1 v1(5.26,208.18) ; 59.6,111.25 58.53,110.19 58.53,105.28 59.09,104.72 59.09,103.23 v1(59.84,102.48) 58.06,102.48 57.82,102.23 57.82,101.73 58.38,101.16 58.38,99.5 57.77,98.88 57.77,91.97 55.38,89.58 55.38,86.61 54.97,86.21 54.97,82.49 v1(55.35,82.12) ; v1(17.31,84.43) 16.8,84.94 16.8,85.09 15.4,86.49 11.16,86.49 6.94,90.7 6.94,96.67 13.14,102.87 13.14,110.77 13.67,111.3 13.67,124.51 11.64,126.54 11.64,137.48 14.82,140.66 14.82,149.22 16.52,150.93 16.52,152.42 16.1,152.84 16.1,159.19 14.77,160.53 v1(14.13,160.53)
GPP_A0: length 24.6
  TOP w0.089: v1(50.49,127.96) 50.54,127.96 50.66,127.84 U4.AT17
  TOP w0.102: R73.2 28.75,129.87 31.01,129.87 R6369.2 32.08,129.41 32.21,129.28 v1(32.21,129.23)
  BOTTOM w0.089: v1(50.49,127.96) 50.01,127.48 48.83,127.48 48.69,127.62 44.24,127.62 43.52,126.9 43.23,126.9
  BOTTOM w0.102: v1(32.21,129.23) 32.21,129.16 33.49,127.89 34.23,127.89 35.48,126.64 37.82,126.64 38.07,126.9 43.23,126.9
GPP_A8: length 18.6
  TOP w0.089: v3(49.28,125.65) 49.13,125.5 U4.AW22
  TOP w0.102: v1(34.96,121.92) 34.96,122.87 R6392.2
  BOTTOM w0.089: 43.23,124 43.96,124 45.05,125.09 46.54,125.09 47,125.55 47.84,125.55 48.34,126.06 48.88,126.06 v3(49.28,125.65)
  BOTTOM w0.102: v1(34.96,121.92) 35.56,122.52 v2(36.2,122.52) 38.76,122.52 40.24,124 43.23,124
GPP_A13: length 7.5
  TOP w0.089: U4.BD19 46.74,126.2 46.36,126.2 46.07,125.92 44.37,125.92 44.25,126.04 43.19,126.04
  TOP w0.102: R6663.2 41.68,126.04 43.19,126.04
GPP_B14: length 10
  TOP w0.089: 43.19,120.85 44.38,120.85 44.97,121.45 44.97,122.49 45.4,122.91 46.8,122.91 U4.BD26
  TOP w0.102: 43.19,120.85 40.17,120.85 39.71,120.4 R114.2
GPP_F17: length 8.9
  TOP w0.089: 60.23,111.25 60.23,112.19 59.34,113.08 59.34,113.78 59.49,113.93 U4.W44
  TOP w0.102: RH8.2 60.73,106.49 60.1,107.11 60.1,108.52 60.22,108.63 60.22,109.77 60.03,109.96 60.03,110.22 v1(60.13,110.32) 60.13,110.9 60.23,111 60.23,111.25
GPP_F18: length 14.5
  TOP w0.089: 60.99,111.25 60.42,111.82 60.42,112.27 60.31,112.39 60.31,113.31 59.72,113.9 59.72,114.5 U4.W43
  TOP w0.102: R6618.2 61.91,102.15 61.91,105.12 61.65,105.38 61.65,107.95 v1(61.37,108.23) 61.65,108.51 61.65,110.59 60.99,111.25
GT1+_RT3607: length 6.7
  TOP w0.203: PR145.1 230.09,194.69 v1(229.52,194.69) 229,194.17 PC95.2 228.77,193.43 228.13,192.79 227.29,192.79 226.91,192.41 226.66,192.41 226,191.74 PU7.38
GT1-_RT3607: length 3.8
  TOP w0.203: PU7.39 225.93,192.14 v1(226.73,192.94) 226.73,193.48 227.62,194.37 PR147.1
GT2+_RT3607: length 5.8
  TOP w0.203: PU7.37 226.07,191.34 226.8,192.07 227.59,192.07 PC101.2 228.01,192.11 228.67,192.77 v1(229.67,192.77) PR151.1
GT2-_RT3607: length 2.5
  TOP w0.203: PR156.1 v1(226.47,190.94) PU7.36
GT3-_RT3607: length 6.1
  TOP w0.203: 226,192.94 226,192.69 225.85,192.54 PU7.40 ; 226,192.94 PU7.41 ; 226,192.94 226.32,193.27 226.32,193.55 226.98,194.21 226.98,194.88 PR160.1 227.43,196.22 v1(227.24,196.22)
GT_COMPA: length 5.1
  TOP w0.203: PU7.34 226.02,190.14 226.23,189.93 PC104.2 228.38,189.42 v1(229.41,189.42) 229.46,189.42 229.9,189.87 PR155.2
GT_FBA: length 12.4
  TOP w0.203: PU7.35 226.1,190.54 226.22,190.42 228.26,190.42 PC104.1 228.89,189.93 PR154.1 229.9,191.05 230.51,191.66 231.24,191.66 231.48,191.41 v1(232.7,191.41) 232.7,189.29 PC103.2 232.44,188.66 PR152.2
GT_ISEN1+: length 34.6
  TOP w0.203: PR145.2 231.17,195.01 231.29,195.12 v3(231.29,195.21)
  BOTTOM w0.203: PJP15.2 218.09,169.29 218.3,169.49 218.3,170.27 218.55,170.53 218.55,171.05 218.3,171.31 v2(218.3,172.7) 218.3,173.15 219.39,174.24 222,174.24 229.04,181.28 229.04,185.45 230.08,186.49 230.08,187.73 231.25,188.89 231.25,189.77 230.84,190.17 230.84,194.77 v3(231.29,195.21)
GT_ISEN1-: length 37.9
  TOP w0.203: 229.78,195.76 229.64,195.76 PR147.2 227.63,193.75 PC95.1 ; 229.78,195.76 PC98.1 ; 229.78,195.76 v3(230.32,195.21)
  BOTTOM w0.203: v3(230.32,195.21) 230.46,195.07 230.46,190.01 230.87,189.61 230.87,189.05 229.7,187.88 229.7,186.64 228.66,185.6 228.66,181.44 221.84,174.62 219.24,174.62 217.66,173.05 217.66,172.44 217.91,172.18 v2(217.91,170.79) 217.91,169.65 217.71,169.45 217.71,169.18 PJP16.2
GT_ISEN2+: length 57.5
  TOP w0.203: v3(232.77,193.98) 232.6,193.8 232.08,193.8 231.69,193.41 PR151.2
  BOTTOM w0.203: PJP17.2 218.22,150.44 218.03,150.63 218.03,150.96 v1(218.5,151.43) 218.5,151.66 220.25,153.42 226.02,153.42 233.38,160.78 233.38,178.75 231.94,180.19 231.94,182.24 232.7,183 232.7,183.9 233.81,185.02 233.81,193.32 233.39,193.75 233,193.75 v3(232.77,193.98)
GT_ISEN2-: length 60.9
  TOP w0.203: v3(232.75,193.27) 232.6,193.42 232.24,193.42 231.63,192.81 230.8,192.81 PC102.1 230.11,192.11 PC101.1 229,191.19 PR156.2
  BOTTOM w0.203: PJP18.2 217.46,150.44 217.65,150.63 217.65,151.5 219.16,153.01 v1(219.16,153.24) 219.51,153.24 220.07,153.8 225.86,153.8 233,160.94 233,178.59 231.55,180.04 231.55,182.4 232.32,183.16 232.32,184.06 233.43,185.18 233.43,193.17 233.23,193.37 233,193.37 232.9,193.27 v3(232.75,193.27)
GT_VSENA: length 11.1
  TOP w0.203: PR161.2 232.24,185.3 v1(232.24,186.06) 232.44,186.26 PR152.1 231.94,187.39 231.94,188.28 PC103.1 230.73,188.85 230.16,188.28 229.52,188.28 PR158.2 228.38,188.79 228.32,188.72 PC105.2 227.05,189.48 226.19,189.48 225.93,189.74 PU7.33
H_BPM#0: length 62.1
  TOP w0.102: CPU.D16 160.7,162.71 v3(160.93,162.95) ; v3(125,196.37) 125,196.82 124.7,197.12 124.7,197.42 124.44,197.68 124.16,197.96 XDP_CPU.21
  BOTTOM w0.102: v3(160.93,162.95) 161.04,163.07 161.04,164.19 161.7,164.85 161.7,166.12 161.32,166.5 161.32,168.56 157.37,172.52 148.23,172.52 137.7,183.04 137.7,188.6 135.29,191.01 135.29,193 133.06,195.23 131.5,195.23 131.05,195.68 128.03,195.68 127.11,196.6 v2(125.92,196.6) 125.23,196.6 v3(125,196.37)
H_BPM#1: length 65.8
  TOP w0.102: XDP_CPU.23 124.66,200.25 124.44,200.47 v1(124.17,200.47) ; CPU.D17 v3(161.86,162.96)
  BOTTOM w0.102: v3(161.86,162.96) 162.28,163.38 162.28,168.81 157.67,173.43 148.5,173.43 138.51,183.41 138.51,188.93 136.1,191.35 136.1,193.34 134.92,194.52 134.92,196.34 134.58,196.68 134.58,196.98 133.79,197.76 132.88,197.76 132.65,197.99 126.1,197.99 124.7,199.4 v2(124.7,199.6) 124.17,200.13 v1(124.17,200.47)
H_CATERR#: length 34.8
  TOP w0.102: CPU.D13 157.74,162.12 157.29,161.67 157.29,161.41 157,161.12 v3(156.37,161.12) ; v1(148.04,169.82) 146.87,169.82 138.39,178.31 R51.2
  BOTTOM w0.102: v3(156.37,161.12) 156.5,161.25 TPS41.1 156.5,162.94 156.88,163.32 156.88,163.98 156.62,164.24 156.62,166.28 157.54,167.19 157.54,168.25 155.91,169.88 148.09,169.88 v1(148.04,169.82)
H_PECI: length 431.7
  TOP w0.102: v1(75.6,81.91) 77.07,80.44 77.07,73.23 75.92,72.08 75.92,63.69 79.94,59.67 79.94,55.04 85.32,49.66 95.89,49.66 v1(95.92,49.63) ; v1(96.42,146.94) 96.71,146.66 102.39,146.66 105.24,149.5 108.02,149.5 109.19,150.67 111.29,150.67 114.77,154.15 114.77,155.27 122.26,162.75 122.26,169.74 128.54,176.02 129.98,176.02 130.75,176.79 131.32,176.79 131.7,177.16 132.75,177.16 134.27,175.64 135.7,175.64 136.97,174.37 137.96,174.37 138.27,174.69 R6255.1 143.8,169.99 v1(143.8,168.15) ; R6408.2 51.21,144.04 50.58,144.67 50.58,150.42 56.57,156.41 65.12,156.41 66.75,154.78 69.01,154.78 71.02,152.78 71.02,150.37 77.59,143.8 82.37,143.8 84.36,141.81 84.36,141.17 v1(84.74,140.79) ; v1(90.05,142.04) 90.2,141.88 90.2,137.5 90.61,137.09 90.61,135.03 90.99,134.65 90.99,130.41 91.9,129.5 91.9,127.38 92.03,127.25 92.03,122.25 92.41,121.87 92.41,109.83 v1(90.3,107.72) ; RO10.1 223.62,30.8 223.81,30.99 v1(223.94,30.99) ; v3(152.71,159.29) CPU.G7
  BOTTOM w0.102: v1(95.92,49.63) 95.92,50.29 96.68,51.05 110.09,51.05 115.73,45.42 118.98,45.42 120.66,43.74 136.12,43.74 136.83,43.03 138.89,43.03 139.92,42 144.83,42 145.86,43.03 150.52,43.03 151.48,42.06 153.59,42.06 154.63,41.02 173.43,41.02 176.67,44.25 182.59,44.25 186.05,40.79 190.05,40.79 200.08,30.76 215.86,30.76 216.02,30.92 223.88,30.92 v1(223.94,30.99) ; v1(143.8,168.15) 143.8,167.02 144.62,166.19 v2(146.27,166.19) 149.31,166.19 149.93,165.58 151.9,165.58 152.45,165.02 152.45,163.59 152.25,163.39 CPU.G7 v3(152.71,159.29) ; v1(96.42,146.94) 91.52,142.04 v1(90.05,142.04) 89.16,142.04 88.5,141.38 85.89,141.38 85.3,140.79 v1(84.74,140.79) ; v1(90.3,107.72) 88.86,106.27 82.76,106.27 78.19,101.7 78.19,96.85 83.4,91.64 85.91,91.64 87.97,89.58 87.97,85.6 84.76,82.4 77.86,82.4 77.38,81.91 v1(75.6,81.91)
H_PECI_C: length 7.5
  TOP w0.102: SIO_5553.30 222.09,36.02 224.02,34.1 CO14.1 223.81,33.59 223.81,32.01 v1(224.07,31.75) 224.01,31.69 RO10.2
H_PWRGOOD: length 158.6
  TOP w0.102: R6596.2 50.2,143.69 49.61,144.27 49.61,150.82 56.17,157.38 65.52,157.38 67.15,155.75 69.42,155.75 71.98,153.19 71.98,150.77 77.99,144.76 82.81,144.76 84.78,142.79 v1(84.78,142.62) ; v1(95.41,147.95) 95.79,147.95 96.74,148.91 99.46,148.91 99.86,148.51 101.72,148.51 104.49,151.28 107.29,151.28 108.46,152.45 110.51,152.45 112.99,154.93 112.99,156 120.12,163.13 120.12,174.7 123.47,178.05 129.5,178.05 130.01,178.57 130.58,178.57 131.59,179.58 134.15,179.58 v1(135.03,178.69) ; CPU.F8 v3(152.71,161.12)
  BOTTOM w0.102: v3(152.71,161.12) 153.14,161.55 153.14,162.16 153.35,162.37 153.35,163.18 153.34,163.19 153.34,163.21 153.09,163.46 153.09,166.47 v2(152.57,166.99) 151.54,168.03 149.13,168.03 148.86,168.3 147.63,168.3 141.42,174.5 139.7,174.5 139.1,175.11 139.1,175.64 137.96,176.78 136.3,176.78 135.29,177.8 135.29,178.44 v1(135.03,178.69) ; v1(84.78,142.62) 85.06,142.34 88.04,142.34 88.7,143 91.12,143 95.41,147.29 v1(95.41,147.95)
H_PWRGOOD_R: length 8.8
  TOP w0.089: 50.91,139.01 53.06,136.87 53.06,134.9 53.1,134.86 53.1,134.42 U4.AM3
  TOP w0.102: 50.91,139.01 50.88,139.04 50.88,140.41 50.58,140.72 v1(50.33,140.72) 50.2,140.84 R6596.1
H_SKTOCC#: length 344.7
  TOP w0.089: U4.Y44 58.96,114.05 58.96,112.92 59.72,112.16 59.72,111.58 59.39,111.25
  TOP w0.102: 59.39,111.25 59.33,111.19 59.33,109.9 59.72,109.51 59.72,109.22 57.89,107.39 57.89,104.83 58.12,104.6 58.12,102.67 57.44,101.98 R6573.1 58.14,101.79 v1(58.33,101.98) ; v1(180.5,145.62) 180.05,145.17 CPU.AB35
  BOTTOM w0.102: v1(180.5,145.62) 180.74,145.62 181.22,145.14 181.62,145.14 181.87,145.39 181.87,145.85 182.05,146.02 184.31,146.02 184.61,146.33 184.61,147.28 185.65,148.31 186.94,148.31 188.16,147.09 199.38,147.09 225.77,120.7 225.77,109.9 v2(225.79,109.88) 226.37,109.3 226.37,107.72 222.36,103.71 222.36,93.9 223.22,93.04 223.22,91.44 223.68,90.98 224.8,90.98 225.34,90.44 225.34,87.57 224.95,87.19 224.95,77.7 224.34,77.09 224.34,71.35 223.45,70.46 221.83,70.46 219.42,68.05 216.5,68.05 215.36,69.19 211.03,69.19 209.64,67.8 208.89,67.8 207.7,66.61 207.7,65.34 203.63,61.26 195.87,61.26 194.55,62.59 182.21,62.59 178.51,66.29 160.33,66.29 159.16,67.46 156.12,67.46 155.84,67.18 153.88,67.18 152.94,66.24 146.43,66.24 144.27,64.08 129.36,64.08 125.63,60.35 116,60.35 112.01,64.34 110.04,64.34 109.5,63.8 107.45,63.8 106.81,63.17 104,63.17 102.73,64.44 95.04,64.44 93.19,66.29 92.56,66.29 89.75,69.11 89.75,70.18 88.81,71.12 88.81,77.85 87.36,79.3 85.17,79.3 84.74,78.87 77.73,78.87 76.81,79.78 65.04,79.78 64.45,80.37 62.98,80.37 62.38,80.96 57.12,80.96 55.2,82.88 55.2,86.11 55.61,86.52 55.61,89.48 58,91.87 58,95.99 58.61,96.6 58.61,101.7 v1(58.33,101.98)
H_TCK: length 269.3
  TOP w0.102: CPU.F11 v3(156.37,160.21) ; v1(134.04,209.27) 134.04,209.49 130.64,212.89 115.11,212.89 111.69,209.47 111.69,201.95 95,185.26 95,164.71 98.17,161.54 98.17,156.33 97.47,155.62 97.47,154.96 93.44,150.94 93.44,146.88 v1(96.81,143.51) ; XDP_CPU.57 133.16,197.83 133.38,197.61 134.91,197.61 135.48,197.05 135.48,195.58 R152.2 134.25,194.35 132.07,194.35 130.69,192.97 130.69,192.45 v1(131.12,192.02) 134.11,192.02 137.07,194.98 137.07,202.06 135.42,203.71 135.42,204.73 136.94,206.25 v1(136.94,207.57) ; v1(86.93,138.23) 86.62,138.53 86.62,143.57 83.65,146.54 78.72,146.54 73.76,151.5 73.76,153.93 70.16,157.53 67.89,157.53 66.26,159.16 55.4,159.16 47.71,151.46 47.71,148.32 46.08,146.69 46.08,141.27 46.52,140.84 RS225.2
  BOTTOM w0.102: v1(131.12,192.02) 131.12,191.88 132.82,190.17 132.82,189.92 135.24,187.51 135.24,181.89 147.78,169.34 149.59,169.34 149.72,169.47 155.74,169.47 157.13,168.08 157.13,167.36 156.42,166.65 156.42,164.53 155.93,164.04 155.93,162.51 156.16,162.28 156.16,161.6 155.93,161.37 155.93,160.87 156.37,160.44 v3(156.37,160.21) ; v1(134.04,209.27) v2(135,208.32) 135.75,207.57 v1(136.94,207.57) ; v1(96.81,143.51) 96.45,143.51 95.79,142.85 95.79,141.88 95.49,141.58 94.84,141.58 92.58,139.32 90.9,139.32 90.32,138.73 87.88,138.73 87.63,138.48 87.18,138.48 v1(86.93,138.23)
H_TDI: length 270.4
  TOP w0.102: v1(131.62,192.47) 131.8,192.28 132.44,192.28 133.07,192.91 134.33,192.91 136.19,194.77 136.19,200.14 132.66,203.67 XDP_CPU.56 132.66,205.91 133.51,206.76 133.89,206.76 134.72,207.58 R6680.2 ; RS223.2 47.25,142.71 47.25,145.29 47.53,145.57 47.53,146.59 48.16,147.23 48.16,151.27 55.59,158.7 66.07,158.7 67.7,157.07 69.97,157.07 73.3,153.74 73.3,151.31 78.53,146.08 83.46,146.08 86.16,143.38 86.16,137.72 v1(86.39,137.49) ; v1(101,149.35) 101.35,149.35 104.1,152.1 106.86,152.1 107.44,152.68 107.44,153.94 117.28,163.77 117.28,174.92 111.95,180.25 111.95,181.35 112.12,181.53 116.88,181.53 117.06,181.71 117.06,181.96 116.88,182.14 112.12,182.14 111.95,182.32 111.95,182.57 112.12,182.75 116.88,182.75 117.06,182.93 117.06,183.18 116.88,183.36 112.12,183.36 111.95,183.54 111.95,184.6 112.97,185.62 113.22,185.62 114.68,184.16 114.94,184.16 115.12,184.34 115.12,184.59 113.65,186.05 113.65,186.3 113.83,186.48 114.09,186.48 115.88,184.69 116.13,184.69 116.31,184.87 116.31,185.12 114.52,186.91 114.52,187.17 114.7,187.35 114.95,187.35 116.68,185.61 116.94,185.61 117.12,185.79 117.12,186.04 115.38,187.78 115.38,188.03 115.56,188.21 115.81,188.21 116.92,187.1 117.17,187.1 117.35,187.28 117.35,187.53 116.24,188.64 116.24,188.89 116.42,189.07 116.67,189.07 117.78,187.96 118.03,187.96 118.21,188.14 118.21,188.39 117.1,189.5 117.1,189.75 117.49,190.14 125.36,190.14 125.7,190.49 129.58,190.49 129.84,190.23 132.1,190.23 v1(132.85,190.98) ; v3(156.37,159.29) CPU.G12
  BOTTOM w0.102: v3(156.37,159.29) 156.85,159.78 156.85,162.28 157.13,162.56 157.13,164.06 156.93,164.27 156.93,166 157.94,167.02 157.94,168.48 156.14,170.28 147.2,170.28 135.47,182.02 135.47,187.6 133.05,190.02 133.05,190.78 v1(132.85,190.98) 132.85,190.99 v2(132.07,191.77) 131.92,191.92 131.92,192.16 v1(131.62,192.47) ; v1(86.39,137.49) 86.39,136.91 86.65,136.65 87.92,136.65 88.22,136.96 89.94,136.96 90.55,137.57 91.61,137.57 92.22,138.18 93.06,138.18 95.32,140.44 96.02,140.44 100.15,144.56 100.15,148.5 v1(101,149.35)
H_TDO: length 289.1
  TOP w0.102: RS226.2 47.25,140.17 47.25,141.13 47.02,141.36 47.02,145.39 47.3,145.67 47.3,146.69 47.94,147.32 47.94,151.37 55.49,158.93 66.16,158.93 67.79,157.3 70.07,157.3 73.53,153.83 73.53,151.41 78.63,146.31 83.56,146.31 86.39,143.48 86.39,138.15 86.84,137.71 87.07,137.71 v1(87.64,137.13) ; CPU.H13 v3(157.28,159.29) ; v1(132.49,193.29) 132.62,193.42 134.1,193.42 135.72,195.04 135.72,199.96 132.57,203.11 132.15,203.11 131.66,203.6 XDP_CPU.52 131.66,205.91 131.99,206.24 R117.2 132.49,207.45 132.49,208.28 132.77,208.56 132.77,209.27 132.37,209.68 132.37,210.02 130.16,212.23 115.45,212.23 112.53,209.31 112.53,201.77 96.83,186.07 96.83,184.2 97.7,183.33 98.57,183.33 98.75,183.16 98.75,182.9 98.57,182.72 97.01,182.72 96.83,182.55 96.83,182.29 97.01,182.12 98.57,182.12 98.75,181.94 98.75,181.68 98.57,181.51 97.01,181.51 96.83,181.33 96.83,181.07 97.01,180.9 98.57,180.9 98.75,180.72 98.75,180.46 98.57,180.29 97.01,180.29 96.83,180.11 96.83,179.86 97.01,179.68 99.59,179.68 99.77,179.5 99.77,179.25 99.59,179.07 97.01,179.07 96.83,178.89 96.83,178.64 97.01,178.46 99.54,178.46 99.72,178.28 99.72,178.03 99.54,177.85 97.01,177.85 96.83,177.67 96.83,177.42 97.01,177.24 99.52,177.24 99.7,177.06 99.7,176.81 99.52,176.63 96.48,176.63 96.3,176.45 96.3,176.2 96.48,176.02 99.52,176.02 99.7,175.84 99.7,175.59 99.52,175.41 96.49,175.41 96.31,175.23 96.31,174.98 96.49,174.8 98.09,174.8 98.27,174.62 98.27,174.37 98.09,174.19 97.01,174.19 95.64,172.82 95.64,164.96 99.47,161.13 99.47,155.7 98.53,154.76 v1(98.28,154.76)
  BOTTOM w0.102: v3(157.28,159.29) 157.71,159.72 157.71,161.32 157.54,161.49 157.54,164.26 157.38,164.42 157.38,165.88 157.81,166.31 158.1,166.31 159.16,167.37 159.16,167.91 156.33,170.74 147.49,170.74 135.92,182.31 135.92,187.84 133.51,190.25 133.51,191.57 132.75,192.33 132.75,193.03 v1(132.49,193.29) ; v1(87.64,137.13) 87.89,137.13 88.25,137.49 89.14,137.49 89.59,137.95 90.28,137.95 91.2,138.86 92.77,138.86 95.03,141.12 95.68,141.12 99.46,144.91 99.46,150.76 v2(98.71,151.51) 98.71,153.29 98.28,153.72 v1(98.28,154.76)
H_THERMTRIP#: length 159.9
  TOP w0.102: v1(135.67,179.7) 135.39,179.98 131.43,179.98 130.42,178.97 129.84,178.97 129.43,178.56 123.26,178.56 119.61,174.91 119.61,163.2 112.58,156.17 112.58,155.09 110.34,152.86 108.29,152.86 107.12,151.69 104.3,151.69 101.53,148.92 100.03,148.92 99.61,149.34 v1(98.71,149.34) ; CPU.D11 155.46,162.94 155.46,163.57 155.34,163.7 155.34,164.62 151.43,168.53 151.16,168.53 v3(150.91,168.78) ; R6434.2 55.02,140.72 55.41,141.1 R6585.2 54.77,142.24 54.77,143.6 52.76,145.61 52.76,149.48 57.48,154.2 64.24,154.2 65.84,152.6 68.11,152.6 68.83,151.88 68.83,149.46 76.68,141.61 81.37,141.61 82.81,140.17 v1(82.81,138.3)
  BOTTOM w0.102: v1(98.71,149.34) 97.77,148.4 97.77,146.35 92.09,140.67 90.79,140.67 90.79,140.66 90.45,140.66 89.79,140 86.7,140 85.78,139.09 84.01,139.09 83.22,138.3 v1(82.81,138.3) ; v3(150.91,168.78) v2(150.08,168.78) 149.05,168.78 148.89,168.94 147.57,168.94 141.6,174.91 139.87,174.91 139.61,175.18 139.61,175.84 135.75,179.7 v1(135.67,179.7)
H_TMS: length 280.3
  TOP w0.102: v1(133.24,192.47) 134.22,192.47 136.69,194.94 136.69,200.41 133.77,203.33 133.34,203.33 133.16,203.51 XDP_CPU.58 133.16,205.89 133.47,206.2 v1(133.61,206.2) ; v1(132.34,209.04) 132.11,209.27 132.11,209.9 130.02,212 115.54,212 112.76,209.21 112.76,201.67 102.68,191.59 102.68,189.4 102.5,189.22 101.02,189.22 100.85,189.04 100.85,188.79 101.02,188.61 102.5,188.61 102.68,188.43 102.68,188.17 102.5,187.99 101.02,187.99 100.85,187.81 100.85,187.56 101.02,187.38 102.5,187.38 102.68,187.2 102.68,186.95 102.5,186.77 101.02,186.77 100.85,186.59 100.85,186.34 101.02,186.16 102.5,186.16 102.68,185.98 102.68,185.72 102.5,185.55 101.02,185.55 100.85,185.37 100.85,185.11 101.02,184.93 102.5,184.93 102.68,184.75 102.68,184.5 102.5,184.32 101.02,184.32 100.85,184.14 100.85,183.89 101.02,183.71 102.5,183.71 102.68,183.53 102.68,183.28 102.5,183.1 101.02,183.1 100.85,182.92 100.85,182.66 101.02,182.48 102.5,182.48 102.68,182.31 102.68,182.05 102.5,181.87 101.02,181.87 100.85,181.69 100.85,181.44 101.02,181.26 102.5,181.26 102.68,181.08 102.68,180.83 102.5,180.65 101.02,180.65 100.85,180.47 100.85,180.22 101.02,180.04 102.5,180.04 102.68,179.86 102.68,179.6 102.5,179.42 101.02,179.42 100.85,179.24 100.85,178.99 101.02,178.81 102.5,178.81 102.68,178.63 102.68,178.38 102.5,178.2 100.77,178.2 100.62,178.05 100.62,177.79 100.82,177.59 102.5,177.59 102.68,177.41 102.68,177.01 102.47,176.81 101.3,176.81 101.04,176.54 101.04,175.81 95.87,170.64 95.87,165.05 99.7,161.22 99.7,155.54 97.32,153.16 v1(97.24,153.16) ; v1(87.33,139.14) 87.08,139.39 87.08,143.76 83.84,147 78.91,147 74.22,151.69 74.22,154.12 70.35,157.98 68.08,157.98 66.45,159.61 55.21,159.61 47.25,151.65 47.25,148.51 45.27,146.53 45.27,142.46 RS224.2 ; CPU.F13 v3(158.2,161.12)
  BOTTOM w0.102: v1(133.24,192.47) 133.74,191.97 133.74,190.35 133.87,190.21 136.15,187.93 136.15,182.4 147.59,170.97 156.5,170.97 159.42,168.05 159.42,167.3 158.5,166.39 158.5,164.85 158.66,164.69 158.66,161.57 158.48,161.4 158.48,161.37 158.23,161.12 v3(158.2,161.12) ; v1(132.34,209.04) 132.34,207.47 v1(133.61,206.2) ; v1(87.33,139.14) 87.38,139.19 90.13,139.19 90.79,139.85 92.47,139.85 97.99,145.37 98.54,145.37 99.23,146.06 99.23,149.97 96.85,152.36 v2(96.85,152.47) 96.85,152.77 v1(97.24,153.16)
H_TRST#: length 70.3
  TOP w0.102: CPU.F12 v3(157.28,160.21) ; R6574.2 133.64,207.58 R6595.1 132.33,206.27 132.33,205.99 132.16,205.83 XDP_CPU.54 132.16,203.63 132.46,203.34 132.67,203.34 135.96,200.05 135.96,194.89 134.23,193.17 132.99,193.17 132.54,192.71 v1(132.2,192.71)
  BOTTOM w0.102: v3(157.28,160.21) 157.51,160.43 157.51,161.23 157.34,161.41 157.34,164.16 157.15,164.34 157.15,165.94 157.72,166.51 157.98,166.51 158.55,167.09 v2(158.55,167.61) 158.55,168.19 156.23,170.51 147.38,170.51 135.69,182.19 135.69,187.74 133.28,190.16 133.28,191.46 132.2,192.54 v1(132.2,192.71)
H_TRST#_R: length 195.4
  TOP w0.089: 45.59,139.03 45.56,139 RP5.1 ; U4.AY5 48.9,133.4 v1(49.23,133.4)
  TOP w0.102: 45.59,139.03 v1(46.01,139.45) 46.01,141.03 45.85,141.18 45.85,146.79 47.48,148.41 47.48,151.56 55.31,159.38 66.35,159.38 67.98,157.76 70.26,157.76 73.99,154.02 73.99,151.6 78.82,146.77 83.75,146.77 86.85,143.67 86.85,138.99 87.64,138.2 v1(87.64,137.9) ; R6574.1 134.53,208.98 134.53,209.55 130.96,213.12 115.02,213.12 111.46,209.56 111.46,202.05 94.78,185.36 94.78,164.61 97.94,161.44 97.94,156.42 97.24,155.72 97.24,155.06 92.78,150.6 92.78,146.86 95.67,143.97 95.67,142.9 v1(96.25,142.32)
  BOTTOM w0.089: 47.58,137.95 48.24,137.29 48.24,134.01 48.85,133.4 v1(49.23,133.4)
  BOTTOM w0.102: v1(87.64,137.9) 88.25,138.51 90.41,138.51 91,139.09 92.68,139.09 94.94,141.35 95.58,141.35 96.25,142.02 v1(96.25,142.32) ; 47.58,137.95 46.08,139.45 v1(46.01,139.45)
HDMI_D41_PIN1: length 2.7
  TOP w0.102: RV88.2 224.46,243.98 D41.1 v1(223.43,244.98)
HDMI_D41_PIN2: length 2.9
  TOP w0.102: v1(227.54,244.98) D41.2 226.36,244 RV89.2
HDMI_HPD: length 13.4
  TOP w0.102: QV49.D 227.66,242.98 226.86,242.18 226.86,242.11 226.55,241.81 RV80.1 CV40.1 RV79.1 222.85,243.08 222.51,243.08 222.23,243.36 UV7.4 UV7.7 222.23,246.32 CV41.1 222.05,246.38 HDMI.19
HDMI_Q99_S: length 2.6
  TOP w0.102: Q99.S v1(219.11,237.87) 219.11,236.79 RV75.2
HDMI_Q104_S: length 3
  TOP w0.102: RV84.2 223.87,237.74 Q104.S v1(224.82,237.87)
HDMI_V_HDMI_SCL_R: length 10.2
  TOP w0.102: Q99.D 220.63,240.16 220.77,240.3 220.77,240.78 v1(220.63,240.92) 220.77,241.06 220.77,241.34 RV76.1 ; RV88.1 224.85,242.91 v1(225.04,242.72)
  BOTTOM w0.102: v1(220.63,240.92) 220.77,241.06 220.77,241.63 221.23,242.09 225.05,242.09 225.28,242.32 225.28,242.49 v1(225.04,242.72)
HDMI_V_HDMI_SDA_R: length 10.3
  TOP w0.102: RV89.1 225.99,242.77 v1(225.92,242.7) ; RV85.1 221.18,241.34 221.18,241.13 v1(221.39,240.92) 221.18,240.7 221.18,240.37 221.39,240.16 Q104.D
  BOTTOM w0.102: v1(221.39,240.92) 221.18,241.13 221.18,241.47 221.39,241.68 225.21,241.68 225.68,242.15 225.68,242.46 v1(225.92,242.7)
HDMID_FET_SINK: length 20.8
  TOP w0.508: RV46.1 207.84,244.56 v1(207.87,244.54) RV45.1 ; RV73.2 v3(213.9,244.56) RV72.2 ; RV49.2 v3(210.85,244.56) 210.83,244.54 RV48.1 ; RV47.1 v1(204.76,244.56) ; RV74.2 v1(216.57,244.56) 217.45,244.56 QV22.D
  BOTTOM w0.508: v1(216.57,244.56) v3(213.9,244.56) v3(210.85,244.56) 207.89,244.56 v1(207.87,244.54) v2(206.43,244.54) 204.78,244.54 v1(204.76,244.56)
HPOUT-JD: length 21.8
  TOP w0.254: RA16.2 179.17,27.89 v1(179.1,27.89)
  BOTTOM w0.254: F_AUDIO.6 178.72,12.64 178.72,15.83 178.19,16.36 178.19,20.34 176.44,22.09 176.44,25.61 175.08,26.96 175.08,27.55 175.93,28.4 178.6,28.4 v1(179.1,27.89)
HPOUT-L: length 28.3
  TOP w0.203: 186.09,19.51 186.18,19.6 UA1.32
  TOP w0.254: RA41.2 176.37,16.59 178.47,16.59 v1(178.72,16.84) ; v1(186.34,16.46) 186.95,17.07 RA77.2 186.95,17.3 186.09,18.16 186.09,19.51 ; v1(189.39,7.19) 189.52,7.32 RA74.1
  BOTTOM w0.254: v1(178.72,16.84) v2(180.49,16.84) 185.96,16.84 v1(186.34,16.46) 187.74,15.07 188.58,15.07 190.28,13.37 190.28,8.99 189.39,8.1 v1(189.39,7.19)
HPOUT-R: length 30.2
  TOP w0.203: UA1.33 186.58,19.78
  TOP w0.254: v1(186.47,15.32) 186.47,15.38 RA76.2 187.61,16.53 187.61,17.35 186.59,18.37 186.59,19.77 186.58,19.78 ; RA75.1 188.5,7.45 v1(188.76,7.19) ; v1(179.1,16.34) 178.85,16.08 175.86,16.08 RA40.2
  BOTTOM w0.254: v1(179.1,16.34) 179.29,16.15 v2(182.34,16.15) 185.64,16.15 v1(186.47,15.32) 186.77,15.32 187.53,14.56 188.37,14.56 189.77,13.16 189.77,9.2 188.76,8.18 v1(188.76,7.19)
HS_DET#: length 48.7
  TOP w0.089: v1(58.45,118.24) 58.02,117.81 U4.AB36
  TOP w0.102: v1(59.85,96.65) 61.06,96.65 63.09,98.68 64.37,98.68 v1(64.88,98.17) ; v1(60.33,104.3) R67.2
  BOTTOM w0.089: v1(58.45,118.24) 58.45,117.6 59.28,116.78 59.28,113.07 59.85,112.5 59.85,111.25
  BOTTOM w0.102: v1(64.88,98.17) 65.67,98.96 65.67,99.67 66,100 71.2,100 72.16,99.04 HS_CLIP2.2 HS_CLIP2.1 ; 59.85,111.25 59.85,111.17 58.76,110.08 58.76,107.01 59.88,105.89 59.88,104.75 v1(60.33,104.3) 60.54,104.09 60.54,100.6 59.85,99.91 v1(59.85,96.65)
ICH_RTCRST#: length 342.4
  TOP w0.089: U4.BC10 47.19,130.8 47.05,130.66 45.55,130.66 44.83,131.38 44.34,131.38 44.05,131.09 43.84,131.09
  TOP w0.102: v1(28.61,134.37) 28.6,134.37 v1(21.88,134.37) 21.88,134.27 19.42,131.81 16.92,131.81 13.75,128.64 13.75,122.79 16.49,120.04 16.49,119.35 v1(16.31,119.18) ; 43.84,131.09 40.75,131.09 C1639.2 39.98,130.81 38.65,129.48 R6467.2 v1(38.39,130.18) ; v1(28.74,146.43) 28.74,148.08 28.35,148.46 28.35,149.34 28.87,149.86 29.2,149.86 30.41,151.08 30.41,154.36 29.52,155.25 29.52,158.84 24.89,163.47 16.33,163.47 15.15,164.66 15.15,197.4 14.15,198.39 14.15,199.43 RB4.1 ; P2.1 140.5,39.8 141.74,38.56 146.9,38.56 v1(149.51,35.94)
  BOTTOM w0.102: v1(149.51,35.94) 147.92,34.35 138.71,34.35 136.33,36.73 116.71,36.73 114.39,39.04 107.72,39.04 106.99,39.78 103.3,39.78 102.9,40.17 102.9,41.58 101.32,43.17 98.83,43.17 97.55,44.44 91.32,44.44 85.41,50.36 83.7,50.36 80.49,53.57 75.76,53.57 68.42,60.91 65.56,60.91 64.67,61.8 59.16,61.8 58.52,61.16 46.64,61.16 46.14,60.67 42.41,60.67 40.14,62.94 37.07,62.94 28.13,71.88 28.13,72.57 21.83,78.86 21.83,87.05 24.29,89.5 24.29,97.73 16.24,105.79 16.24,115.52 17.2,116.48 17.2,118.29 v1(16.31,119.18) ; v1(28.61,134.37) 29.14,134.37 30.34,133.17 30.34,132.31 30.87,131.78 37.17,131.78 38.39,130.56 v1(38.39,130.18) ; v1(28.74,146.43) 28.74,144.78 27.95,144 27.95,142.77 21.88,136.69 v1(21.88,134.37)
ICH_RTCX1: length 18.3
  TOP w0.089: 44.09,132.64 44.11,132.64 45.71,131.04 46.64,131.04 46.72,131.11 47.32,131.11 U4.BC9
  TOP w0.102: 44.09,132.64 43.44,132.64 R6468.2 42.57,132.9 40.8,132.9 C1641.1 40.03,133.68 38.49,133.68 37.85,134.32 v1(33.99,134.32) 33.22,134.32 Y5.4
ICH_RTCX2: length 17.4
  TOP w0.089: U4.BD10 46.84,130.85 45.63,130.85 44.35,132.13 44.09,132.13
  TOP w0.102: Y5.1 32.87,133.81 v1(35.86,133.81) 37.68,133.81 38.77,132.72 39.97,132.72 C1640.1 40.61,132.33 R6468.1 42.4,131.7 43.44,131.7 43.87,132.13 44.09,132.13
IMON: length 3.9
  TOP w0.203: 220.7,185.29 220.7,185.48 v1(221.39,186.18) 221.55,186.33 PU7.20
  BOTTOM w0.203: v2(221.78,185.42) 221.39,185.8 v1(221.39,186.18)
IMON_L: length 32.7
  TOP w0.203: PR128.1 220.7,175.88 219.93,175.12 214.98,175.12 212.58,177.52 212.58,180.77 210.15,183.2 210.15,191.3 v1(209.86,191.59) 209.86,192.51 208.08,194.28 208.08,195.43 207.49,196.02 PRT1.2
IMON_R: length 6.5
  TOP w0.203: PR128.2 220.24,179.15 v1(220.24,179.29) 220.7,179.74 PR125.2 220.19,180.34 220.19,183.2 220.28,183.29 220.28,183.98 PR129.1
IMONA: length 2.8
  TOP w0.203: PU7.22 222.35,187.41 v1(222.61,187.15) 222.61,186.66 222.6,186.65 222.6,185.29
IMONA_L: length 11.9
  TOP w0.203: PR135.1 222.92,177.42 v1(222.03,176.53) ; PRT2.2 v1(213.96,174.56)
  BOTTOM w0.203: v1(213.96,174.56) 213.96,175.69 214.17,175.89 221.39,175.89 v1(222.03,176.53)
IMONA_R: length 7.6
  TOP w0.203: PR134.2 222.44,178.53 222.7,178.53 PR135.2 222.92,180.8 v1(223.22,181.1) 222.6,181.72 PR136.1
ISEN1+: length 17.2
  TOP w0.203: PR101.2 213.37,194.27 v1(212.38,194.27) 211.46,195.2 210.57,195.2 209.91,195.86 209.91,196.55 210.33,196.98 210.7,196.98 v1(210.98,197.26)
  BOTTOM w0.203: PJP9.2 203.63,201.68 204.12,201.68 205.24,200.56 205.24,199.16 207.42,196.98 210.7,196.98 v1(210.98,197.26)
ISEN1-: length 20.2
  TOP w0.203: PC85.1 216.31,194.69 PR106.2 PC86.1 214.08,194.65 213.1,194.65 212.17,195.58 210.73,195.58 210.29,196.02 210.29,196.39 210.49,196.6 210.7,196.6 v1(210.98,196.31)
  BOTTOM w0.203: PJP10.2 203.5,201.29 203.96,201.29 204.86,200.4 204.86,199 207.27,196.6 210.7,196.6 v1(210.98,196.31)
ISEN2+: length 40.5
  TOP w0.203: PR116.2 213.36,192.31 v1(212.2,192.31) 211.74,192.77 211.74,193.4 210.45,194.69 210.12,194.69 v1(209.83,194.98)
  BOTTOM w0.203: v1(209.83,194.98) 209.55,194.69 208.14,194.69 201.15,201.68 201.15,201.99 200.2,202.94 198.11,202.94 196.71,201.53 196.71,200.51 195.23,199.03 189.03,199.03 187.43,197.44 187.43,195.12 185.66,193.34 184.89,193.34 184.56,193.68 PJP11.2
ISEN2-: length 45.4
  TOP w0.203: PC87.1 216.31,191.85 PR117.2 215.92,191.69 215.03,191.69 PC88.1 214.09,191.9 213.47,191.9 213.39,191.82 212,191.82 211.36,192.46 211.36,193.24 210.29,194.31 210.12,194.31 v1(209.83,194.03)
  BOTTOM w0.203: PJP12.2 184.63,192.96 185.81,192.96 187.82,194.96 187.82,197.28 189.19,198.65 195.39,198.65 197.09,200.35 197.09,201.37 198.27,202.56 200.04,202.56 200.77,201.83 200.77,201.52 207.98,194.31 209.55,194.31 v1(209.83,194.03)
ISEN3+: length 70.8
  TOP w0.203: PR123.2 213.35,197.05 213.04,197.05 v1(212.75,197.34)
  BOTTOM w0.203: PJP13.2 167.15,193.7 167.9,193.7 170.85,190.75 170.85,188.77 171.83,187.79 175.88,187.79 176.64,188.54 176.64,192.66 177.9,193.93 181.87,193.93 182.51,193.29 182.51,192.43 182.79,192.15 186.62,192.15 188.63,194.16 188.63,196.88 189.67,197.92 195.79,197.92 197.84,199.97 197.84,200.98 198.72,201.87 199.63,201.87 200.06,201.44 200.06,201.11 207.39,193.78 208.47,193.78 209.46,192.79 210.71,192.79 211.05,193.13 211.05,195.16 211.64,195.75 211.64,196.58 212.07,197.01 212.43,197.01 v1(212.75,197.34)
ISEN3-: length 75.1
  TOP w0.203: PC91.1 216.31,197.18 PR126.2 216.12,196.06 215.7,196.06 215.01,196.76 214.28,196.76 PC92.1 213.35,196.67 213.04,196.67 v1(212.75,196.39)
  BOTTOM w0.203: v1(212.75,196.39) 212.51,196.63 212.22,196.63 212.02,196.43 212.02,195.59 211.43,195 211.43,192.97 210.87,192.41 208.85,192.41 v1(208.14,193.12) 208.11,193.14 207.48,193.14 199.68,200.95 199.68,201.28 199.47,201.49 198.88,201.49 198.22,200.83 198.22,199.81 195.94,197.54 189.83,197.54 189.01,196.72 189.01,194 186.78,191.77 182.63,191.77 182.13,192.27 182.13,193.14 181.71,193.55 178.06,193.55 177.02,192.51 177.02,188.39 176.04,187.41 171.68,187.41 170.47,188.61 170.47,190.6 167.74,193.32 167.08,193.32 PJP14.2
ISOLATEB: length 9.1
  TOP w0.102: RL34.2 RL35.1 105.95,222.81 v1(106,222.86) 106.31,222.86 106.38,222.78 108.87,222.78 110.24,224.16 110.24,224.59 110.45,224.79 RTK_LAN.20
  BOTTOM w0.102: v2(105.49,223.49) 105.65,223.49 106,223.14 v1(106,222.86)
JTAG_TCK: length 6.7
  TOP w0.102: BRIDGE.M12 55.6,200.72 55.22,201.1 55.22,201.61 53.63,203.2 v1(53.63,203.45) 53.31,203.77 RK35.2
  BOTTOM w0.102: v2(53.12,202.56) 53.63,203.07 v1(53.63,203.45)
JTAG_TRST#: length 8
  TOP w0.102: BRIDGE.L9 57.58,200.21 57.58,201.55 57.35,201.78 56.88,201.78 55.41,203.25 55.41,204.06 55.76,204.42 v1(55.76,204.52) 55.76,204.94 RK34.2
  BOTTOM w0.102: v2(55.61,205.35) 55.76,205.21 v1(55.76,204.52)
K_AD0: length 65.9
  TOP w0.102: v1(49,170.25) 48.33,170.92 42.75,170.92 SLOT3.A58 42.14,170.79 38.87,170.79 37.88,171.78 37,171.78 34.51,174.27 27.37,174.27 25.59,172.48 25.59,171.43 24.96,170.8 22.31,170.8 SLOT4.A58 ; BRIDGE.C5 v1(61.6,193)
  BOTTOM w0.102: v1(49,170.25) 48.55,170.7 48.55,174.18 51.9,177.53 60.02,177.53 62.14,179.65 62.14,185.42 61.6,185.96 61.6,187.5 60.69,188.41 60.69,192.09 v1(61.6,193)
K_AD1: length 71.4
  TOP w0.102: SLOT4.B58 19.86,170.55 21.12,169.29 22.66,169.29 23.81,170.43 25.05,170.43 25.81,171.2 25.81,172.39 27.47,174.04 34.42,174.04 37.3,171.16 SLOT3.B58 40.24,170.55 41.22,169.57 43.29,169.57 44.41,170.69 47.93,170.69 v1(49,169.61) ; BRIDGE.A3 v1(62.8,191.16)
  BOTTOM w0.102: v1(49,169.61) 49.52,170.12 49.52,171.02 49.89,171.4 49.89,174.24 52.27,176.62 60.4,176.62 63.05,179.27 63.05,185.8 62.57,186.28 62.57,186.66 62.57,190.73 62.8,190.96 v1(62.8,191.16)
K_AD2: length 60.6
  TOP w0.102: BRIDGE.B4 v1(62.39,192.2) ; SLOT4.A57 27.28,174.5 34.61,174.5 37.1,172.01 38.01,172.01 38.74,172.75 40.55,172.75 41.47,171.82 44.49,171.82 SLOT3.A57 45.14,171.6 48.01,171.6 48.73,170.88 v1(49,170.88)
  BOTTOM w0.102: v1(62.39,192.2) 62.11,191.91 62.11,186.85 62.11,186.09 62.59,185.61 62.59,179.46 60.21,177.08 52.09,177.08 49,173.99 49,172.61 49.51,172.1 49.51,171.39 v1(49,170.88)
K_AD3: length 69.8
  TOP w0.102: v1(63.03,190.47) 63.23,190.68 63.23,191.62 63.18,191.68 63.18,192.22 BRIDGE.B3 ; SLOT4.B56 19.8,173.09 21.19,171.7 22.69,171.7 23.71,172.72 25.18,172.72 27.18,174.73 35.66,174.73 SLOT3.B56 40.52,173.09 41.57,172.05 43.13,172.05 43.9,172.82 45.4,172.82 46.34,171.88 48.28,171.88 48.85,171.31 49.34,171.31 49.89,170.76 v1(50.02,170.76)
  BOTTOM w0.102: v1(63.03,190.47) 62.8,190.25 62.8,186.57 62.8,186.38 63.28,185.89 63.28,179.17 60.5,176.39 52.37,176.39 50.15,174.17 50.15,170.89 v1(50.02,170.76)
K_AD4: length 59.9
  TOP w0.102: v1(50.66,170.89) 49.14,172.4 46.88,172.4 SLOT3.A55 41.95,174.36 41.27,174.36 40.27,175.36 38.62,175.36 37.84,174.59 36.62,174.59 36.02,175.18 26.68,175.18 25.86,174.36 SLOT4.A55 ; BRIDGE.A2 63.46,191.66 63.46,189.89 63.7,189.65 v1(63.7,189.6)
  BOTTOM w0.102: v1(63.7,189.6) 64.19,189.1 64.19,178.79 60.88,175.48 53.73,175.48 51.42,173.16 51.42,171.65 v1(50.66,170.89)
K_AD5: length 65.4
  TOP w0.102: BRIDGE.C4 v1(62.4,193) ; SLOT4.B55 22.5,174.36 23.5,173.35 25.18,173.35 26.78,174.96 35.93,174.96 36.52,174.36 SLOT3.B55 40.94,174.36 41.17,174.13 42.84,174.13 43.82,173.15 45.6,173.15 46.64,172.11 48.66,172.11 v1(49,171.77)
  BOTTOM w0.102: v1(49,171.77) 48.78,172 48.78,174.09 51.99,177.3 60.12,177.3 62.36,179.55 62.36,185.51 61.88,186 61.88,187.54 60.92,188.5 60.92,191.51 v1(62.4,193)
K_AD6: length 63
  TOP w0.102: BRIDGE.B2 63.6,192.47 64.02,192.05 64.02,191.68 63.69,191.35 63.69,190.22 64.13,189.78 64.13,189.34 v1(63.71,188.93) ; SLOT4.A54 26.31,175.63 27.71,177.03 38.13,177.03 39.52,175.63 SLOT3.A54 43.4,175.63 43.56,175.47 45.13,175.47 47.96,172.63 49.55,172.63 v1(50.66,171.53)
  BOTTOM w0.102: v1(50.66,171.53) 51.16,172.03 51.16,173.23 53.63,175.7 60.78,175.7 63.96,178.89 63.96,188.67 v1(63.71,188.93)
K_AD7: length 63.9
  TOP w0.102: BRIDGE.C3 v1(63.2,192.99) ; v1(49.46,173.08) 47.91,173.08 45.29,175.7 43.65,175.7 42.45,176.9 SLOT3.B53 39.48,177.26 27.72,177.26 26.83,178.15 23.92,178.15 22.67,176.9 SLOT4.B53
  BOTTOM w0.102: v1(63.2,192.99) 62.83,192.62 62.83,192.02 62.34,191.53 62.34,186.76 62.34,186.76 62.34,186.19 62.82,185.7 62.82,179.36 60.31,176.85 52.18,176.85 49.46,174.13 v1(49.46,173.08)
K_AD8: length 70.4
  TOP w0.102: BRIDGE.D3 v1(63.19,193.8) ; SLOT4.B52 20.01,178.17 21.05,177.13 22.58,177.13 23.82,178.37 37.1,178.37 SLOT3.B52 38.94,178.17 39.18,177.93 40.67,177.93 41.47,177.13 42.61,177.13 43.81,175.93 45.38,175.93 47.8,173.51 49.64,173.51 50.66,172.49 v1(50.66,172.16)
  BOTTOM w0.102: v1(63.19,193.8) 63.63,193.36 63.63,192.73 63.25,192.35 63.25,190.86 63.46,190.65 63.46,190.3 63.03,189.86 63.03,186.47 63.51,185.99 63.51,179.08 60.59,176.16 52.65,176.16 50.66,174.17 v1(50.66,172.16)
K_AD9: length 68.6
  TOP w0.102: v1(51.93,171.53) 51.32,172.14 51.32,172.48 49.83,173.96 47.99,173.96 46.04,175.92 46.04,177.36 44.92,178.48 SLOT3.A49 41.45,181.98 40.55,182.88 38.64,182.88 37.74,181.98 34.33,181.98 SLOT4.A49 ; BRIDGE.C2 63.6,193.23 64.02,192.81 64.02,192.44 64.28,192.18 64.55,192.18 64.8,191.93 64.8,191.52 v1(64.47,191.19)
  BOTTOM w0.102: v1(64.47,191.19) 64.04,190.75 64.04,189.87 65.11,188.8 65.11,185.34 64.42,184.66 64.42,178.7 60.97,175.25 53.82,175.25 51.77,173.2 51.77,171.68 v1(51.93,171.53)
K_AD10: length 76.1
  TOP w0.102: SLOT4.B48 20.01,183.25 20.94,184.18 22.87,184.18 23.79,183.25 33.06,183.25 SLOT3.B48 40.52,183.25 41.41,182.36 43.33,182.36 43.84,182.87 45.29,182.87 45.86,182.3 45.86,177.87 46.27,177.46 46.27,176.01 48.09,174.19 50,174.19 51.9,172.29 v1(52.43,172.29) ; v1(65.01,193.29) 64.9,193.4 BRIDGE.C1
  BOTTOM w0.102: v1(65.01,193.29) 65.01,192.68 65.57,192.12 65.57,189.5 65.95,189.12 65.95,180.11 65.11,179.27 65.11,178.37 61.3,174.56 54.71,174.56 v1(52.43,172.29)
K_AD11: length 69.5
  TOP w0.102: SLOT4.A47 24.92,184.2 38.34,184.2 38.95,183.59 41.13,183.59 42.06,184.52 SLOT3.A47 46.09,183.35 46.09,177.96 46.49,177.55 46.49,176.11 48.18,174.42 50.09,174.42 51.59,172.92 v1(52.43,172.92) ; v1(65.13,190.5) 65.26,190.63 65.26,192.27 64.55,192.98 64.28,192.98 64.02,193.24 64.02,193.57 63.6,193.99 BRIDGE.D2
  BOTTOM w0.102: v1(65.13,190.5) 64.98,190.35 64.98,189.76 65.72,189.02 65.72,180.2 64.88,179.36 64.88,178.47 61.2,174.79 54.3,174.79 v1(52.43,172.92)
K_AD12: length 77.1
  TOP w0.102: v1(65.46,192.84) 65.46,193.5 64.76,194.2 BRIDGE.D1 ; v1(53.07,172.29) 53.07,172.9 52.3,173.67 51.17,173.67 50.19,174.65 48.28,174.65 46.72,176.2 46.72,177.65 46.32,178.05 46.32,184.38 45.29,185.41 44.22,185.41 43.56,184.75 41.97,184.75 41.74,184.52 SLOT3.B47 38.48,184.52 38.39,184.43 26.27,184.43 25.26,185.45 23.71,185.45 22.78,184.52 SLOT4.B47
  BOTTOM w0.102: v1(53.07,172.29) 53.07,172.4 55,174.33 61.39,174.33 65.34,178.28 65.34,179.17 66.18,180.01 66.18,189.21 65.79,189.6 65.79,192.51 v1(65.46,192.84)
K_AD13: length 71
  TOP w0.102: v1(51.29,174.19) 50.97,174.19 50.28,174.88 48.37,174.88 46.95,176.3 46.95,177.74 46.55,178.15 46.55,184.48 45.23,185.79 SLOT3.A46 39.39,185.79 38.26,184.66 26.37,184.66 25.23,185.79 SLOT4.A46 ; BRIDGE.E3 v1(63.19,194.6)
  BOTTOM w0.102: v1(51.29,174.19) 53.03,175.93 60.69,175.93 63.74,178.98 63.74,186.08 63.47,186.35 63.25,186.57 63.25,189.77 63.69,190.2 63.69,190.75 63.48,190.95 63.48,192.26 63.86,192.63 63.86,193.93 v1(63.19,194.6)
