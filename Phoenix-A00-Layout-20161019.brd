# Allegro board Phoenix-A00-Layout-20161019.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on TOP (solid shape): 212.94,73.12 212.94,69.9 212.76,69.72 211.49,69.72 211.31,69.9 211.31,73.21 211.41,73.3 212.76,73.3
GND on TOP (solid shape): 88.36,75.82 88.36,74.36 88.36,74.34 88.35,74.31 88.35,71.36 88.36,71.35 88.16,71.14 87.01,71.14 86.48,71.67 86.48,75.31 87.13,75.95 88.23,75.95
GND on TOP (solid shape): 154.59,205.23 154.59,200.41 154.34,200.15 151.67,200.15 151.42,199.9 150.53,199.9 150.4,200.03 150.4,201.29 151.29,202.18 151.29,206.5 151.54,206.76 153.07,206.76
GND on TOP (solid shape): 51.55,58.19 51.55,56.98 51.42,56.85 50.15,56.85 49.98,57.02 48.28,57.02 47.75,57.55 47.75,58.04 48.01,58.3 49.77,58.3 49.89,58.43 51.32,58.43
GND on TOP (solid shape): 117.61,151.42 118.32,151.42 118.56,151.18 118.56,150.65 118.25,150.34 116.98,150.34 116.4,150.92 115.13,150.92 114.86,151.19 114.86,151.61 115.32,152.06 116.96,152.06
GND on TOP (solid shape): 174.53,208.53 174.53,207.26 174.66,207.14 174.66,204.6 174.53,204.47 173.77,204.47 173.64,204.6 173.64,207.01 173.39,207.26 172.75,207.26 172.63,207.39 172.63,208.53 172.75,208.66 174.4,208.66
GND on TOP (solid shape): 217.71,211.84 217.71,210.69 217.97,210.44 217.97,207.77 217.84,207.64 217.08,207.64 216.95,207.77 216.95,210.19 216.7,210.44 215.93,210.44 215.81,210.57 215.81,211.84 215.93,211.96 217.58,211.96
GND on TOP (solid shape): 228.76,145.41 228.76,144.4 229.27,143.89 229.27,140.84 229.14,140.72 228.38,140.72 228.25,140.84 228.25,143.38 228,143.64 227.36,143.64 227.24,143.76 227.24,145.41 227.36,145.54 228.63,145.54
GND on TOP (solid shape): 229.4,162.31 229.4,161.42 229.78,161.04 229.78,158.37 229.65,158.24 228.89,158.24 228.76,158.37 228.76,160.66 228.51,160.91 227.87,160.91 227.49,161.29 227.49,162.31 227.62,162.43 229.27,162.43
GND on TOP (solid shape): 58.05,55.83 58.05,54.33 58.3,54.08 58.3,53.26 58.2,53.16 58.2,53.16 55.15,53.16 54.9,53.41 54.9,54.07 54.47,54.5 54.47,55.16 55.5,56.19 57.69,56.19
GND on TOP (solid shape): 67.84,114.19 68.23,114.19 68.42,114 69.17,113.25 69.17,112.88 68.96,112.66 68.53,112.66 67.62,113.57 67.62,113.8 67.46,113.95 67.46,114.18 67.46,114.24 67.56,114.34 67.68,114.34
GND on TOP (solid shape): 103.08,68.71 103.08,68.25 102.9,68.07 102.02,68.07 101.83,68.17 101.63,68.2 101.13,68.71 101.13,69.11 101.23,69.22 102.57,69.22
GND on TOP (solid shape): 206.28,73.15 206.28,71.5 206.03,71.25 204.88,71.25 204.38,70.74 204.38,69.85 204.12,69.6 202.34,69.6 201.96,69.98 201.96,72.9 202.22,73.15 203.11,73.15 203.74,73.79 205.65,73.79
GND on TOP (solid shape): 64.82,141.91 64.82,139.48 64.44,139.09 64.44,138.3 64.25,138.12 63.99,138.12 63.79,138.33 63.79,138.47 63.59,138.66 63.31,138.66 63.12,138.86 63.12,141.89 63.22,141.99 63.75,141.99 63.89,142.13 64.6,142.13
GND on TOP (solid shape): 163.1,152.65 163.1,151.26 162.85,151 159.55,151 159.16,150.62 158.53,150.62 158.4,150.75 158.4,151.26 158.53,151.38 159.04,151.38 159.29,151.64 159.29,152.78 159.42,152.91 162.85,152.91
GND on TOP (solid shape): 73.64,84.71 73.64,81.43 73.36,81.15 69.63,81.15 69.51,81.27 69.51,81.27 69.24,81.53 69.24,81.53 69.1,81.67 66.07,81.67 65.82,81.93 65.82,82.8 65.95,82.93 69.27,82.93 69.28,82.94 69.46,82.94 71.64,85.12 73.22,85.12
GND on TOP (solid shape): 210.02,135.97 210.02,133.79 219.69,124.12 219.69,121.75 222.18,119.26 222.18,119.21 225,116.39 225,106.85 224.17,106.02 223.74,106.02 223.57,106.19 223.57,106.8 223.83,107.06 223.83,111.28 209.51,125.6 209.51,136.16 209.61,136.26 209.73,136.26
GND on TOP (solid shape): 213.27,156.59 217.2,156.59 217.33,156.46 217.33,155.45 217.46,155.32 219.11,155.32 219.24,155.45 219.24,156.31 223.4,156.31 223.55,156.16 223.55,154.31 223.43,154.18 211.87,154.18 211.62,154.43 211.62,156.84 212,157.23 212.63,157.23
GND on TOP (solid shape): 100.01,125.37 105.18,125.37 105.46,125.1 105.46,124.86 105.36,124.76 99.37,124.76 99.29,124.84 99.29,125.23 99.43,125.37 99.95,125.37
GND on TOP (solid shape): 103.35,134.48 103.35,133.31 104.18,132.48 104.18,132.06 103.98,131.86 103.95,131.86 103.79,131.85 103.65,131.77 102.28,131.77 101.93,132.13 101.93,134.15 102.5,134.73 103.1,134.73
GND on TOP (solid shape): 152.17,232.15 152.17,231.88 151.72,231.43 151.72,230.21 152.2,229.73 152.2,229.51 152.04,229.35 151.62,229.35 150.77,230.2 150.77,231.95 150.78,232.03 150.77,232.15 150.95,232.32 151.99,232.32
GND on TOP (solid shape): 71.33,100.13 71.33,97.18 71.43,97.08 71.43,97.03 72.52,95.94 72.52,93.11 74.48,91.15 74.48,90.65 74.15,90.33 71.67,90.33 70.77,91.22 70.77,96.52 70.52,96.77 70.52,98.17 70.01,98.68 68.49,98.68 68.3,98.86 68.3,100.58 68.47,100.75 70.71,100.75
GND on TOP (solid shape): 212.63,138.43 216.57,138.43 216.7,138.3 216.7,137.29 216.95,137.03 217.69,137.03 217.94,137.29 217.94,137.92 218.17,138.15 222.78,138.15 222.92,138.01 222.92,136.27 222.54,135.89 213.4,135.89 210.81,138.47 210.81,138.9 211.11,139.19 211.87,139.19
GND on TOP (solid shape): 179.1,200.28 179.1,185.92 178.86,185.68 177.05,185.68 176.69,186.04 176.69,191.77 176.82,191.9 177.71,191.9 177.83,192.02 177.83,192.79 176.94,193.68 176.94,200.45 177.14,200.66 178.72,200.66
GND on TOP (solid shape): 214.28,209.8 214.28,200.53 211.62,197.87 209.84,197.87 209.71,197.99 209.71,199.64 209.84,199.77 210.98,199.77 211.87,200.66 211.87,204.09 212,204.22 213,204.22 213.17,204.39 213.17,205.04 212.98,205.23 212.49,205.23 212.12,205.6 212.12,209.68 212.38,209.93 214.16,209.93
GND on TOP (solid shape): 47.73,114.79 47.73,114.63 47.54,114.44 47.4,114.44 47.16,114.2 47.16,114.06 47.01,113.91 47.01,113.5 46.58,113.08 46.39,113.08 46.19,113.28 46.19,113.95 46.42,114.17 46.63,114.17 46.81,114.34 46.81,114.75 46.86,114.8 47.02,114.8 47.08,114.86 47.27,114.86 47.36,114.95 47.56,114.95
GND on TOP (solid shape): 197.01,203.83 197.01,193.93 192.95,189.87 191.93,189.87 191.8,189.99 191.8,191.77 191.93,191.9 193.58,191.9 194.34,192.66 194.34,196.09 194.47,196.22 195.36,196.22 195.61,196.47 195.61,197.23 195.36,197.49 194.85,197.49 194.72,197.61 194.72,203.96 194.85,204.09 196.76,204.09
GND on TOP (solid shape): 153.45,144.27 162.93,144.27 163.11,144.09 163.11,142.75 162.97,142.62 162.97,141.48 162.85,141.35 160.05,141.35 159.93,141.48 159.93,142.49 159.67,142.75 158.4,142.75 158.02,142.37 154.97,142.37 153.96,141.35 153.07,141.35 152.56,141.86 152.56,141.99 153.2,142.62 153.2,143 153.07,143.13 153.07,143.51 153.2,143.64 153.2,143.89 153.07,144.02 153.07,144.27 153.2,144.4 153.32,144.4
GND on TOP (solid shape): 118.26,142.3 118.26,141.75 118.08,141.57 116.79,141.57 116.7,141.6 116.62,141.61 116.49,141.61 116.41,141.6 116.33,141.57 115.9,141.57 115.81,141.6 115.73,141.61 115.6,141.61 115.52,141.6 115.44,141.57 115.29,141.57 115.17,141.69 115.17,142.14 115.94,142.91 117.65,142.91
GND on TOP (solid shape): 96.6,126.01 96.6,125.07 96.25,124.71 96.23,124.7 96.2,124.67 96.17,124.64 96.16,124.62 96.05,124.51 96.05,121.23 95.89,121.08 95.44,121.08 95.28,121.23 95.28,121.87 94.72,122.43 93.51,122.43 93.19,122.75 93.19,123.23 95.74,123.23 95.74,124.47 95.55,124.47 95.55,123.23 95.24,123.23 95.24,124.47 95.05,124.47 95.05,123.23 93.19,123.23 93.19,125.9 93.53,126.24 96.38,126.24
GND on TOP (solid shape): 48.57,135.41 48.57,135.14 48.26,134.83 48.19,134.8 48.12,134.82 47.87,134.86 47.71,134.66 47.71,134.62 46.91,134.62 46.86,134.68 46.86,134.99 46.9,135 47.13,135.27 46.9,135.55 46.86,135.56 46.86,135.77 46.91,135.84 46.95,135.92 46.96,135.93 47.12,136.09 47.88,136.09
GND on TOP (solid shape): 123.2,222.05 123.2,218.08 122,216.89 100.79,216.89 100.77,216.87 100.34,216.87 100.13,217.07 100.13,218.74 100.77,219.38 100.79,219.38 101.17,219.75 101.25,219.78 101.32,219.74 101.79,219.62 102,220.05 102,220.08 102.09,220.17 102.98,220.17 103.21,219.94 103.21,219.38 103.77,218.82 105.62,218.82 106.28,219.48 107.02,219.48 107.7,220.17 107.7,222 107.86,222.15 109.25,222.15 109.53,221.87 109.53,217.53 109.81,217.25 118.45,217.25 121.98,220.78 121.98,222.05 122.26,222.33 122.92,222.33
GND on TOP (solid shape): 69.04,136.07 69.25,136.07 69.48,135.84 69.48,135.51 68.87,134.9 68.87,134.89 68.29,134.31 68.29,134.21 68.28,134.14 68.29,134.07 68.29,133.83 68.15,133.68 68.15,133.68 67.88,133.53 67.93,133.23 67.96,133.16 67.94,133.09 67.88,132.85 68.05,132.67 68.09,132.63 68.05,132.58 68,132.56 67.81,132.56 67.73,132.61 67.64,132.63 67.59,132.63 67.5,132.62 67.42,132.56 67.4,132.56 67.3,132.64 67.19,132.68 67.19,134.18 66.79,134.58 66.81,134.61 66.85,134.92 66.65,135.15 66.62,135.17 66.62,135.34 66.68,135.4 66.69,135.41 66.83,135.49 66.91,135.63 66.92,135.64 67.36,136.08 69.04,136.08
GND on TOP (solid shape): 124,25.84 125.43,25.25 126.02,23.83 126.02,6.36 126.4,5.98 126.4,5.97 128.42,3.94 172.55,3.94 173.81,2.68 173.81,2.06 173.69,1.95 129,1.95 126.53,2.97 125.51,5.44 125.51,23.83 125.07,24.89 124,25.34 85.47,25.34 85.37,25.39 85.39,25.5 85.46,25.58 85.53,25.66 85.68,25.84
GND on TOP (solid shape): 67.49,116.31 67.54,116.29 67.59,116.29 67.64,116.29 67.68,116.29 67.74,116.31 67.91,116.14 67.89,116.11 67.87,115.96 67.94,115.83 67.96,115.76 67.94,115.69 67.86,115.5 67.94,115.31 68.2,115.25 68.38,115.44 68.39,115.48 68.69,115.48 68.92,115.26 68.92,114.94 68.82,114.84 68.55,114.84 68.52,114.87 68.21,114.87 68.12,114.85 68.07,114.86 67.99,114.94 67.97,114.95 67.46,114.95 67.42,114.89 67.33,114.8 67.33,114.75 67.02,114.43 66.94,114.4 66.86,114.45 66.83,114.49 66.83,114.54 66.71,114.65 66.71,115.08 66.89,115.26 67.08,115.3 67.23,115.43 67.36,115.68 67.3,115.95 67.3,116.06 67.28,116.13 67.32,116.2 67.37,116.24 67.42,116.3 67.46,116.32
GND on TOP (solid shape): 121.91,230.91 124.24,233.24 126.56,230.91 126.56,224.51 124.49,222.2 121.97,224.02 121.91,224.29 121.91,227.02 123.73,227.02 123.93,226.82 123.93,225.9 124.24,224.38 124.54,225.9 124.54,227.08 124.42,227.2 124.42,227.84 124.54,227.97 124.54,229.52 124.24,231.04 123.93,229.52 123.93,228.22 123.86,228.14 121.91,228.14
GND on TOP (solid shape): outline of 247 points within 76.11,244.6 84.23,252.73
GND on TOP (solid shape): outline of 247 points within 230.28,30.83 238.41,38.96
GND on TOP (solid shape): outline of 255 points within 4.59,244.6 12.71,252.73
GND on TOP (solid shape): outline of 255 points within 10.07,89.66 18.19,97.79
GND on TOP (solid shape): outline of 255 points within 76.11,26.27 84.23,34.4
GND on TOP (solid shape): outline of 255 points within 82.28,94.74 90.41,102.87
GND on TOP (solid shape): outline of 255 points within 230.28,94.74 238.41,102.87
GND on TOP (solid shape): outline of 272 points within 123.09,179.96 132.08,188.94
GND on TOP (solid shape): outline of 272 points within 123.09,104.96 132.08,113.94
GND on TOP (solid shape): outline of 272 points within 198.09,179.96 207.08,188.94
GND on TOP (solid shape): outline of 272 points within 198.09,104.96 207.08,113.94
GND on TOP (solid shape): outline of 8223 points within 47.71,112.17 68.99,134.53
GND on BOTTOM (solid shape): 79.15,133.45 79.15,130.49 78.66,130 75.39,130 75.24,130.15 75.24,134.52 75.5,134.77 77.83,134.77
GND on BOTTOM (solid shape): 112.15,228.57 112.15,225.98 112.02,225.86 109.66,225.86 109.23,226.29 109.23,228.27 109.68,228.73 112,228.73
GND on BOTTOM (solid shape): 60.38,127.36 60.38,126.34 60.15,126.11 59.85,126.11 59.57,125.83 59.57,123.14 59.44,123.01 59.01,123.01 58.91,123.11 58.91,124.38 58.73,124.56 58.12,124.56 57.95,124.38 57.95,123.88 57.87,123.8 57.39,123.8 57.31,123.88 57.31,126.06 57.95,126.7 59.55,126.7 59.77,126.92 59.77,127.33 59.9,127.46 60.28,127.46
GND on BOTTOM (solid shape): 124,25.84 125.43,25.25 126.02,23.83 126.02,5.43 126.89,3.32 129,2.44 173.62,2.44 173.82,2.24 173.82,2.06 173.7,1.94 129,1.94 126.53,2.96 125.51,5.43 125.51,23.83 125.07,24.89 124,25.34 85.47,25.34 85.37,25.39 85.39,25.5 85.46,25.58 85.53,25.66 85.59,25.72 85.68,25.84
GND on BOTTOM (solid shape): outline of 217 points within 121.91,222.56 126.56,233.24
GND on BOTTOM (solid shape): outline of 247 points within 76.11,244.6 84.23,252.73
GND on BOTTOM (solid shape): outline of 247 points within 230.28,30.83 238.41,38.96
GND on BOTTOM (solid shape): outline of 255 points within 4.59,244.6 12.71,252.73
GND on BOTTOM (solid shape): outline of 255 points within 10.07,89.66 18.19,97.79
GND on BOTTOM (solid shape): outline of 255 points within 76.11,26.27 84.23,34.4
GND on BOTTOM (solid shape): outline of 255 points within 82.28,94.74 90.41,102.87
GND on BOTTOM (solid shape): outline of 255 points within 230.28,94.74 238.41,102.87
GND on BOTTOM (solid shape): outline of 272 points within 123.09,179.96 132.08,188.94
GND on BOTTOM (solid shape): outline of 272 points within 123.09,104.96 132.08,113.94
GND on BOTTOM (solid shape): outline of 272 points within 198.09,179.96 207.08,188.94
GND on BOTTOM (solid shape): outline of 272 points within 198.09,104.96 207.08,113.94
GND on BOTTOM (solid shape): outline of 40262 points within 100.65,76.26 224.14,146.87
GND on L2_VCC: 37.56,129.18 35.91,130.84 35.91,130.98 35.19,131.7 30.49,131.7 30.26,131.93 30.26,136.8 31.38,137.92 31.55,137.92 32.69,136.78 37.52,136.78 38.23,136.06 38.23,134.94 39.34,133.83 40.51,133.83 41.27,133.07 43.78,133.07 45.31,131.55 45.82,131.55 46.02,131.34 46.5,131.34 46.68,131.17 47.29,131.17 47.54,131.42 47.72,131.42 48.01,131.13 48.01,130.49 47.85,130.33 43.02,130.33 42.74,130.05 40.03,130.05 39.63,129.65 39.63,129.35 39.47,129.18
GND on L2_VCC: outline of 258 points within 96.68,68.33 236.38,148.59
GND on L2_VCC: 215.31,205.23 214.99,205.55 214.99,207.86 214.36,208.49 214.36,210.52 213.6,211.28 211.9,211.28 211.59,211.58 206.56,211.58 206.03,211.05 206.03,210.04 205.79,209.8 204.65,209.8 204.4,209.55 203.85,209.55 203.61,209.78 203.61,210.33 203.85,210.57 204.48,210.57 205.14,211.22 205.14,214.91 205.37,215.14 207.83,215.14 208.31,214.65 208.31,213.51 208.84,212.98 212.78,212.98 213.54,212.22 220.65,212.22 221.65,211.22 221.65,206.35 221.42,206.12 217.99,206.12 217.1,205.23
GND on L2_VCC: 95.17,105.66 94.46,106.38 94.46,108.76 95.36,109.66 99.93,109.66 101.44,111.17 101.44,115.24 101.7,115.49 101.7,117.93 101.33,118.3 100.19,118.3 99.79,118.7 99.79,122.51 99.16,123.14 99.16,123.78 99.22,123.85 99.22,125.37 99.96,126.11 116.13,126.11 116.49,125.75 116.49,123.3 115.5,122.3 110.67,122.3 102.9,114.53 102.9,105.9 102.67,105.66 ; 3 cut-outs
GND on L2_VCC: 176.54,202.44 176.16,202.82 171.46,202.82 170.32,203.96 169.3,203.96 168.31,204.96 168.31,205.63 168.54,205.87 168.92,205.87 171.72,208.66 175.57,208.66 176.08,208.15 177.6,208.15 178.47,207.29 178.47,202.92 177.98,202.44
GND on L2_VCC: 185.94,204.34 185.33,204.96 185.33,205.76 185.56,205.99 186.32,205.99 186.98,206.65 186.98,208.68 190.89,212.6 194.49,212.6 195.11,211.98 195.11,208.05 195.23,207.92 195.23,207.47 195.22,207.44 195.23,207.38 195.22,207.32 195.23,207.31 195.23,206.25 193.56,206.25 193.43,206.38 189.16,206.38 188.5,205.72 188.5,204.96 187.89,204.34
GND on L2_VCC: 4.94,211.77 4.67,212.04 4.67,233.73 4.94,234 7.57,234 7.72,233.86 7.72,232.33 8.73,231.32 8.73,226.27 8.1,225.63 8.1,222.3 8.46,221.93 9.38,221.93 9.75,222.3 9.75,224.84 10.15,225.23 10.88,225.23 11.15,224.97 11.15,216.61 10.24,215.71 8.46,215.71 7.84,215.09 7.84,212.04 7.57,211.77
GND on L2_VCC: 225.44,137.41 224.95,137.9 224.95,138.28 224.44,138.79 224.44,147.34 224.67,147.57 225.23,147.57 225.46,147.34 225.46,146.71 225.99,146.18 236.53,146.18 236.89,145.82 236.89,144.38 234.22,141.71 234.22,137.77 233.86,137.41
GND on L2_VCC: 69.73,70.74 69.25,71.23 69.25,72.62 68.59,73.28 66.09,73.28 65.46,72.64 60.46,72.64 58.83,74.27 58.83,81.81 60.99,83.97 60.99,86.76 61.35,87.12 61.99,87.12 62.52,87.65 62.52,88.67 62.62,88.77 62.92,88.77 63.03,88.67 63.03,85.12 61.17,83.27 61.17,82.34 61.92,81.58 62.94,81.58 63.83,80.7 64.46,80.7 64.6,80.56 64.6,80.18 64.97,79.81 68.7,79.81 69.33,80.44 73.35,80.44 73.69,80.1 73.69,77.22 71.17,77.22 70.52,76.56 70.52,71.1 70.16,70.74
GND on L2_VCC: 219.9,68.33 219.82,68.41 219.82,70.65 220.33,71.16 220.33,74 219.83,74.5 215,74.5 214.61,74.89 214.61,75.86 214.95,76.2 221.75,76.2 223.15,77.6 226.11,77.6 227.74,75.97 227.74,68.69 227.38,68.33
GND on L2_VCC: 41.13,73.09 39.21,75.01 39.21,76.88 40.63,78.3 44.82,78.3 44.94,78.42 48.88,78.42 49.26,78.8 52.91,78.8 53.82,77.9 53.82,74.75 52.91,73.85 48.21,73.85 47.45,73.09
GND on L2_VCC: 227.72,170.05 227.62,170.16 227.62,171.94 225.94,173.61 223.66,173.61 223.43,173.84 223.43,174.52 224.04,175.13 226.37,175.13 229.65,171.85 229.65,170.41 229.29,170.05
GND on L2_VCC: 152.79,192.53 152.31,193.02 152.31,194.03 152.05,194.29 152.05,198.27 152.81,199.03 152.81,199.75 152.28,200.28 151.57,200.28 150.93,199.64 150.67,199.64 150.46,199.85 150.46,201.22 151.23,201.98 151.23,207.26 152.58,207.26 154.72,205.13 154.72,192.76 154.49,192.53
GND on L2_VCC: 208.04,65.66 207.42,66.27 207.42,71.86 206.92,72.37 206.92,74.15 206.54,74.53 206.54,75.33 207.4,76.2 213.87,76.2 214.21,75.86 214.21,74.72 214.83,74.09 219.66,74.09 219.92,73.83 219.92,71.33 219.41,70.82 219.41,68.41 219.33,68.33 215.83,68.33 215.07,67.56 210.11,67.56 208.21,65.66
GND on L2_VCC: 37.35,45.47 36.55,46.26 36.56,46.27 36.56,48.23 36.61,48.28 36.61,48.49 36.08,49.02 35.44,49.02 35.21,49.25 35.21,54.12 35.44,54.36 36.12,54.36 37.75,52.73 37.75,51.71 39.78,49.68 39.78,48.15 40.6,47.34 40.6,45.8 40.26,45.47
GND on L2_VCC: 203.21,64.13 202.34,65 202.34,67.25 203.95,67.25 204.19,67.49 204.21,67.49 204.92,68.2 204.99,68.2 205.14,68.35 205.14,69.45 204.61,69.98 203.64,69.98 203.13,69.47 202.32,69.47 202.09,69.7 202.09,74.68 205.67,74.68 206.41,73.94 206.41,72.16 206.92,71.65 206.92,65.51 205.54,64.13
GND on L2_VCC: 212.86,173.61 209.33,177.14 209.33,192.76 206.15,195.94 206.15,197.09 206.42,197.36 211.72,197.36 215.04,200.68 215.04,204.46 215.31,204.72 217.31,204.72 218.2,205.61 220.48,205.61 220.48,205.42 221.65,204.25 221.65,203.48 222.56,202.56 230.81,202.56 231.17,202.21 231.17,200.3 233.08,198.4 233.08,180.32 231.83,179.07 227.89,179.07 226.22,177.4 226.22,176.13 225.73,175.64 223.83,175.64 222.92,174.73 222.92,173.84 222.69,173.61
GND on L2_VCC: 211.85,154.18 211.49,154.54 211.49,157.12 211.72,157.35 212.78,157.35 213.8,156.34 217.69,156.34 218.32,156.97 224.59,156.97 224.95,156.61 224.95,154.54 224.59,154.18
GND on L2_VCC: 8.62,222.31 8.48,222.46 8.48,225.47 9.11,226.11 9.11,231.47 8.1,232.49 8.1,233.86 8.24,234 9.23,234 11.53,231.7 11.53,225.88 11.26,225.62 9.99,225.62 9.37,225 9.37,222.46 9.23,222.31
GND on L2_VCC: 96.02,61.59 92.36,65.26 92.36,67.08 94.63,69.34 95.43,69.34 97.46,67.31 100.6,67.31 101.51,68.22 101.51,68.29 101.72,68.5 102.23,68.5 102.73,69 102.73,69.68 102.23,70.18 100.52,70.18 99.86,70.84 99.86,72.92 100.87,73.94 100.87,75.84 101.1,76.07 105.46,76.07 106.61,74.93 109.78,74.93 110.14,74.57 110.14,72.41 110.78,71.78 110.78,61.95 110.42,61.59
GND on L2_VCC: 53.35,53.09 53.12,53.32 53.12,53.87 55.51,56.26 58.6,56.26 59.85,55.01 59.85,53.45 59.49,53.09
GND on L2_VCC: outline of 416 points within 1.52,8.46 232.67,257.3 ; 293 cut-outs
GND on L2_VCC: 27.32,44.45 26.96,44.81 26.96,45.87 27.19,46.1 28.33,46.1 28.48,46.25 28.48,46.32 29.84,47.68 30.56,47.68 30.82,47.41 30.82,46.57 30.73,46.48 30.03,46.48 27.99,44.45
GND on L2_VCC: 135.01,54.1 127.52,61.59 111.64,61.59 111.29,61.95 111.29,71.01 111.9,71.63 136.96,71.63 137.54,71.05 137.15,71.05 136.51,70.41 137.15,69.77 138.85,69.77 139.47,70.28 139.11,70.99 140.69,70.99 140.33,70.28 140.96,69.77 142.66,69.77 143.28,70.28 142.92,70.99 143.31,70.99 144.69,69.62 144.69,62.89 145.85,61.72 149.62,61.72 150.27,62.38 150.27,67.02 150.49,67.23 150.82,67.23 150.96,67.1 150.96,66.59 152.22,65.33 154.51,65.33 154.85,64.99 154.85,62.97 150.53,58.65 150.53,55.6 149.03,54.1 ; 34 cut-outs
GND on L2_VCC: 41.41,44.96 41,45.37 41,47.34 41.05,47.39 41.05,47.6 40.29,48.37 40.29,49.89 38.26,51.92 38.26,52.94 36.33,54.86 35.44,54.86 35.21,55.1 35.21,60.6 35.44,60.83 36.63,60.83 39.81,57.66 47.04,57.66 48.06,56.64 52.12,56.64 52.61,56.16 52.61,55.51 52.6,55.42 52.61,55.41 52.61,54.04 52.59,54.01 52.61,53.94 52.61,51.2 52.87,50.95 52.87,49.06 52.65,48.84 50.49,48.84 49.99,48.34 49.99,45.37 49.58,44.96
GND on L2_VCC: 225.56,154.43 225.46,154.54 225.46,161.27 224.19,162.54 224.19,164.99 224.55,165.35 225.23,165.35 225.46,165.12 225.46,164.36 226.5,163.32 229.54,163.32 230.79,162.07 230.79,161.69 231.45,161.04 232.72,161.04 233.08,160.68 233.08,157.84 231.7,156.46 228.65,156.46 226.62,154.43
GND on L2_VCC: 172.11,141.63 171.8,141.94 171.8,152.45 172.96,153.61 177.4,153.61 180.69,156.89 180.69,158.93 180.96,159.19 185.02,159.19 185.64,159.81 185.64,160.11 185.71,160.17 185.71,160.3 187.61,162.2 187.61,167.15 190.53,170.07 190.53,174.01 194.07,177.55 198.17,177.55 198.94,176.78 208.97,176.78 212.65,173.1 218.62,173.1 218.85,172.87 218.85,170.03 210.98,162.16 210.98,154.33 211.64,153.67 221.03,153.67 221.14,153.56 221.14,153.27 210.62,142.75 206.64,142.75 200.29,149.1 186.87,149.1 186.47,148.7 186.47,148.68 182.85,145.06 179.93,145.06 179.67,144.81 178.02,144.81 176.88,143.66 176.12,143.66 175.23,142.77 174.09,142.77 172.94,141.63
GND on L2_VCC: 50.74,45.47 50.4,45.8 50.4,48.18 50.66,48.44 52.65,48.44 52.87,48.23 52.87,47.65 53.25,47.27 53.25,46.76 53.5,46.5 53.5,45.7 53.27,45.47
GND on L2_VCC: 176.92,185.67 176.69,185.91 176.69,201.74 176.88,201.93 178.19,201.93 178.56,202.3 178.88,202.3 179.23,201.95 179.23,185.91 179,185.67
GND on L2_VCC: 210.32,197.87 209.96,198.23 209.96,199.41 210.2,199.64 211.21,199.64 212,200.43 212,210.87 213.44,210.87 213.95,210.35 213.95,208.32 214.59,207.69 214.59,205.23 214.54,205.23 214.54,200.89 211.51,197.87
GND on L2_VCC: 196.66,6.81 192.82,10.65 192.82,13.69 195.61,16.48 195.61,22.66 194.96,23.32 192.59,23.32 192.49,23.22 188.06,23.22 187.71,22.88 187.71,21.99 188.06,21.64 189.07,21.64 189.45,21.26 190.04,21.26 191.14,20.16 191.14,18.05 190.22,17.12 188.69,17.12 187.13,18.69 187.13,20.08 186.95,20.26 186.95,21.25 186.51,21.7 183.61,21.7 183.45,21.86 183.45,26.18 180.56,29.06 177.73,29.06 177.63,29.16 174.76,29.16 174.31,29.62 173.11,29.62 171.89,28.4 170.06,28.4 169.71,28.76 169.71,38.25 174.51,43.05 178.57,43.05 190.77,55.25 204.99,55.25 206.26,56.51 207.15,56.51 207.68,57.04 207.68,58.19 212.23,62.74 215.91,62.74 216.8,63.63 227.13,63.63 227.38,63.37 238.18,63.37 238.67,62.89 238.67,40.53 241.33,37.87 241.33,31.6 237.93,28.19 234.12,28.19 231.55,25.63 231.55,12.5 230.43,11.38 225.06,11.38 223.15,13.29 210.74,13.29 209.34,15.49 207.32,15.49 202.85,11.03 202.85,7.42 202.24,6.81 197.52,6.81
GND on L2_VCC: 158.97,139.47 158.81,139.64 158.81,140.14 159.74,141.07 162.91,141.07 163.38,141.54 163.38,152.84 162.66,153.57 159.48,153.57 158.47,154.58 158.08,154.58 157.79,154.88 157.79,156.27 159.1,157.58 163.55,157.58 167.63,161.67 168.29,161.67 168.94,162.33 168.94,167.36 161.2,175.11 161.2,191.79 161.56,192.15 166.42,192.15 173.54,185.04 176.03,185.04 176.16,185.17 179.21,185.17 179.74,185.7 179.74,192.68 180.1,193.04 185.22,193.04 189.03,189.23 193.43,189.23 197.52,193.32 197.52,201.06 197.88,201.42 202.62,201.42 205.65,198.4 205.65,195.73 208.82,192.55 208.82,177.78 208.33,177.29 199.15,177.29 198.39,178.05 193.86,178.05 190.03,174.22 190.03,170.29 187.1,167.36 187.1,162.41 185.2,160.51 185.2,160.17 185.26,160.11 185.26,159.97 184.87,159.58 180.8,159.58 180.31,159.08 180.31,157.05 177.25,153.99 172.8,153.99 171.42,152.61 171.42,141.94 171.15,141.67 170.52,141.67 170.4,141.56 170.4,141.5 168.37,139.47
GND on L2_VCC: 69.46,80.85 68.7,81.61 66.03,81.61 65.9,81.75 65.9,82.72 66.03,82.85 69.33,82.85 72.5,86.02 72.5,87.67 72.71,87.88 73.91,87.88 74.33,87.47 74.33,86.21 73.69,85.58 73.69,81.19 73.35,80.85
GND on L2_VCC: 213.5,135.89 210.85,138.54 210.85,139.09 211.09,139.32 212.4,139.32 212.91,138.81 223.7,138.81 224.44,138.07 224.44,137.27 223.07,135.89
GND on L2_VCC: 129,1.94 126.53,2.96 125.51,5.43 125.51,23.83 125.07,24.89 124,25.34 4,25.34 1.53,26.36 0.51,28.83 0.51,254.83 1.53,257.3 4,258.32 226.09,258.32 226.09,257.92 225.99,257.81 3.89,257.81 3.89,257.81 1.89,256.94 1.02,254.93 1.02,254.93 1.02,28.72 1.02,28.72 1.89,26.72 3.89,25.85 3.89,25.84 124,25.84 125.43,25.25 126.02,23.83 126.02,5.32 126.02,5.32 126.89,3.32 128.89,2.45 128.9,2.44 173.23,2.44 173.23,2.44 173.64,2.44 173.9,2.18 173.9,1.94
GND on L2_VCC: 192.09,189.74 191.88,189.95 191.88,191.56 192.14,191.82 193.54,191.82 194.29,192.57 194.29,197.06 193.91,197.44 193.91,205.29 194.36,205.74 195.38,205.74 197.01,204.11 197.01,193.53 193.22,189.74
GND on L2_VCC: 138.62,187.58 138.41,187.79 138.41,206.16 138.67,206.43 145.74,206.43 146.15,206.02 146.15,199.69 147.04,198.8 147.04,198.33 146.77,198.06 146.26,198.06 145.77,197.56 145.77,192.45 146.51,191.71 147.27,191.71 147.48,191.5 147.48,187.85 147.21,187.58
GND on L3_GND: outline of 96 points within 0.51,1.94 241.33,258.32 ; 306 cut-outs
VCC_AUD on TOP (solid shape): 183.38,20.32 183.45,20.33 183.53,20.33 183.57,20.29 183.57,20.2 183.16,19.79 183.16,18.65 182.4,17.89 182.4,17.23 181.26,16.08 181.26,14.56 180.98,14.28 179.98,14.28 179.71,14.55 179.71,16.22 180.76,17.26 180.76,18.3 182.09,19.63 182.09,20.12 182.3,20.33 183.31,20.33
VCCGTX2_L31 on TOP (solid shape): outline of 234 points within 176.09,154.05 180.38,159.99
VCCK_V12 on TOP (solid shape): 153.3,231.79 153.3,228.81 152.7,228.21 152.35,228.21 152.16,228.4 152.16,228.93 152.41,229.18 152.41,230.05 152.14,230.32 152.14,231.62 152.6,232.08 153.02,232.08
VCCOPC_R on TOP (solid shape): 176.08,139.46 176.08,138.97 175.83,138.72 175.83,138.69 175.8,138.64 175.78,138.64 175.66,138.56 175.58,138.45 175.49,138.39 175.4,138.45 175.09,138.67 174.74,138.55 174.65,138.44 174.61,138.31 174.56,138.26 174.51,138.31 174.51,138.32 174.21,138.65 173.8,138.52 173.73,138.43 173.7,138.33 173.69,138.31 173.49,138.1 173.36,137.99 173.31,137.83 173.28,137.78 173.23,137.75 173.03,137.72 172.88,137.6 172.6,137.6 172.46,137.74 172.43,137.83 172.48,137.9 172.57,137.98 172.68,138.37 172.39,138.66 172.39,138.66 172.39,139.65 172.72,139.98 175.55,139.98
VCCPGPPCD_BA45 on TOP (solid shape): 48.39,113.84 48.39,113.83 48.51,113.7 48.51,113.5 48.33,113.32 48.31,113.05 48.31,113.03 47.61,112.32 47.12,112.32 46.59,111.79 46.59,109.63 46.52,109.55 45.85,109.55 45.7,109.7 45.7,111.79 47.19,113.28 47.19,113.71 47.21,113.73 47.29,113.8 47.29,114.15 47.45,114.31 47.91,114.31
VCCPRIM_BE3 on TOP (solid shape): 42.94,137.99 43.03,137.99 44.68,136.33 44.84,136.33 46.22,134.96 46.22,134.93 46.25,134.79 46.34,134.68 46.45,134.64 46.56,134.65 46.59,134.65 46.78,134.46 47.05,134.46 47.15,134.37 47.15,134.24 46.99,134.08 46.78,134.08 46.53,133.83 46.53,133.83 46.48,133.77 46.24,133.77 45.75,134.26 45.75,134.4 44.64,135.51 44.51,135.64 44.51,135.64 43.98,136.17 43.01,136.17 42.78,136.4 42.78,137.03 42.81,137.05 42.81,137.37 42.58,137.59 42.27,137.59 42.24,137.57 41.87,137.57 41.74,137.69 41.74,138.15 41.87,138.28 42.66,138.28
VCCSPI on TOP (solid shape): 46.57,115.07 46.65,114.99 46.65,114.95 46.55,114.85 46.55,114.45 46.53,114.43 46.45,114.43 45.93,113.91 45.93,112.78 44.66,111.51 44.19,111.51 44,111.56 43.81,111.51 42.96,111.51 42.9,111.53 42.83,111.55 42.61,111.77 42.61,112.14 42.8,112.33 43.42,112.33 43.67,112.57 44.49,112.57 45.07,113.16 45.07,113.99 45.84,114.75 45.84,115.43 46.08,115.66 46.57,115.66
VDD10 on TOP (solid shape): 111.35,225.56 111.35,224.8 111.49,224.66 111.49,223.6 111.03,223.14 111.03,222.91 111.03,222.86 111.03,222.58 111.09,222.52 111.09,222.13 111.41,221.82 111.41,221.82 111.73,221.5 111.73,219.21 111.87,219.07 114.46,219.07 114.97,219.58 114.97,220.32 114.76,220.52 113.83,220.52 113.75,220.6 113.75,221.31 113.95,221.51 114.59,221.51 114.84,221.26 119.41,221.26 119.44,221.28 119.49,221.28 119.74,221.54 119.74,221.59 119.79,221.64 119.79,223.11 119.97,223.29 119.97,224.66 120.15,224.84 121.28,224.84 121.45,224.67 121.45,220.55 118.4,217.5 109.91,217.5 109.7,217.7 109.7,222.92 110.7,223.92 110.7,224.38 111.16,224.84 111.16,225.55 111.21,225.6 111.31,225.6
VDD10 on TOP (solid shape): 116.01,232.1 116.01,231.35 115.93,231.27 115.77,231.27 115.76,231.27 114.89,231.27 114.76,231.39 114.76,232.06 114.54,232.29 113.47,232.29 113.28,232.11 113.28,231.22 113.23,231.17 113.06,231.17 112.98,231.09 112.73,231.09 112.71,231.07 112.32,230.68 111.94,230.68 111.93,230.67 111.88,230.66 111.84,230.71 111.84,231.01 112.13,231.29 112.13,231.71 112.16,231.72 112.26,232.38 111.64,232.12 111.64,232.08 110.62,232.08 110.55,232.11 110.52,232.18 110.11,232.54 109.76,232.12 109.76,231.8 109.64,231.68 108.58,231.68 108.36,231.46 108.36,230.74 109.33,229.77 109.33,228.89 109.27,228.83 108.84,228.83 108.71,228.96 108.71,229.59 107.68,230.63 107.68,231.74 108.16,232.23 108.59,232.23 110.19,233.83 114.28,233.83
VDD10 on BOTTOM (solid shape): outline of 135 points within 114.51,222.02 121.19,232.13
VDD_DAC_33 on TOP (solid shape): 155.62,223.14 155.62,222.65 155.53,222.56 155.53,222.36 155.46,222.06 155.62,221.79 155.62,219.46 155.5,219.33 154.35,219.33 154.23,219.46 154.23,222.88 154.1,223.01 153.59,223.01 153.59,223.27 155.5,223.27
VDDA_1P5V on TOP (solid shape): 52.23,197.87 52.23,197.1 51.85,196.72 50.96,196.72 50.83,196.85 50.83,197.99 50.96,198.12 51.98,198.12
VDDA_1P5V on BOTTOM (solid shape): 52.23,197.87 52.23,197.1 51.85,196.72 50.96,196.72 50.83,196.85 50.83,197.99 50.96,198.12 51.98,198.12
VDDA_3P3V on TOP (solid shape): 53.07,191.06 53.07,190.44 52.82,190.19 52.82,189.09 52.05,188.32 52.05,184.53 51.87,184.35 51.37,184.35 51.21,184.51 51.21,188.72 51.74,189.25 51.74,190.24 52.69,191.19 52.94,191.19
1P0V_PCH_PHASE on TOP (solid shape): 72.08,87.67 72.08,86.93 71.76,86.61 71.76,85.83 69.22,83.29 65.82,83.29 65.52,82.98 65.52,81.67 65.86,81.33 68.52,81.33 68.84,81.01 68.84,80.47 68.63,80.26 65.06,80.26 64.93,80.39 64.93,80.9 64.8,81.03 64.13,81.03 63.1,82.06 62.3,82.06 61.77,82.59 61.77,83.31 63.53,85.08 63.53,87.38 64.04,87.88 71.86,87.88
1P0V_PCH_PHASE on L2_VCC: 65.14,80.21 65.01,80.35 65.01,80.73 64.63,81.1 64,81.1 63.11,81.99 62.09,81.99 61.58,82.51 61.58,83.1 63.31,84.84 63.38,84.84 63.53,84.98 63.53,87.65 63.79,87.91 63.81,87.88 71.88,87.88 72.09,87.67 72.09,86.19 69.16,83.26 65.86,83.26 65.49,82.89 65.49,81.58 65.86,81.2 68.53,81.2 68.79,80.94 68.79,80.48 68.53,80.21
1P0V_PCH_VCCF24_FB_R on TOP (solid shape): 67.72,141.52 67.72,140.32 67.6,140.2 67.49,140.2 67.49,140.19 67.19,140.19 65.74,138.74 65.74,138.72 65.03,138.01 65.03,137.5 64.91,137.39 64.66,137.39 64.57,137.49 64.57,138.6 65.57,139.6 65.57,141.86 64.8,142.62 64.8,143.26 65.1,143.55 65.69,143.55
1P0V_PCH_VIN on TOP (solid shape): 73.57,80.04 73.57,78.04 73.25,77.73 73.23,77.72 73.01,77.65 72.87,77.46 72.86,77.42 70.57,77.42 70.56,77.43 70.2,77.43 69.96,77.67 69.96,78.09 69.57,78.49 65.06,78.49 64.93,78.61 64.93,78.87 64.8,78.99 63.91,78.99 63.91,79.25 64.8,79.25 64.93,79.38 64.93,79.88 69.25,79.88 69.76,80.39 73.21,80.39
1P0V_VCCAMPHYPLL_FB_R on TOP (solid shape): outline of 92 points within 66.94,107.54 70.76,114.82
1P0V_VCCAPLL_FB_R on TOP (solid shape): 54.54,133.34 54.54,133.06 54.44,132.96 54.18,132.96 54.08,132.86 53.53,132.86 53.46,132.94 53.1,132.97 52.86,132.78 52.82,132.78 52.77,132.73 52.48,132.73 52.4,132.81 52.4,133.06 52.53,133.19 52.93,133.19 53.18,133.43 54.45,133.43
1P0V_VCCAPLL_FB_R on TOP (solid shape): 56.46,147.91 56.46,145.35 56.08,144.97 54.97,144.97 54.03,145.92 53.82,146.12 53.82,146.59 54.29,147.07 54.77,147.07 55.1,147.39 55.1,147.85 55.49,148.25 56.12,148.25
+1P0V_PCH_AUX on TOP (solid shape): 102.55,97.69 102.55,97.26 101.02,95.73 100.01,95.73 99.86,95.88 99.86,97.03 100.67,97.84 102.4,97.84
+1P0V_PCH_AUX on TOP (solid shape): 73.57,111.76 73.57,108.53 72.52,107.49 72.37,107.49 71.99,107.87 71.86,107.87 70.9,108.84 70.9,111.76 71.15,112.01 73.31,112.01
+1P0V_PCH_AUX on TOP (solid shape): outline of 150 points within 62.35,88.4 74.48,98.4
+1P0V_PCH_AUX on BOTTOM (solid shape): 101.46,98.7 101.46,97.05 101.28,96.88 100.41,96.88 100.21,97.08 100.21,98.53 100.39,98.7 100.39,99.26 100.9,99.26
+1P0V_PCH_AUX on BOTTOM (solid shape): outline of 636 points within 53.93,120.79 62.41,128.82
+1P0V_PCH_AUX on L2_VCC: 64.02,88.39 59.6,92.82 59.6,102.51 60.23,103.15 60.23,106.91 56.02,111.12 55.87,111.12 55.68,111.32 55.68,117.03 54.67,118.05 54.67,120.08 54.29,120.46 54.29,123.63 54.03,123.89 54.03,127.32 50.99,130.37 50.99,131.13 50.73,131.38 50.73,133.03 50.48,133.29 50.48,135.7 48.83,137.35 48.83,141.67 48.99,141.83 51.28,141.83 51.62,142.18 51.62,143.19 51.79,143.36 52.04,143.36 52.59,142.81 52.59,137.99 53.22,137.35 53.22,134.18 52.2,133.16 52.2,131.25 52.67,130.78 52.93,130.78 54.2,129.51 58.39,129.51 60.17,127.74 61.06,127.74 61.48,127.32 61.48,125.54 62.24,124.78 62.24,120.59 62.71,120.12 64.1,120.12 64.4,119.82 64.4,116.6 65.29,115.71 65.29,114.36 67.22,112.43 67.22,112.29 67.36,112.14 72.83,112.14 73.19,111.78 73.19,108.56 70.9,106.28 70.9,96.92 71.05,96.77 71.12,96.77 72.47,95.42 72.47,93.01 74.51,90.97 74.51,88.73 74.17,88.39
+1P0V_PCH_SN on TOP (solid shape): 73.58,87.49 73.58,85.94 73.37,85.72 72.6,85.72 72.42,85.9 72.42,86.69 72.43,86.7 72.43,87.69 72.54,87.8 73.28,87.8
+1P0V_VCCST on TOP (solid shape): 104.17,101.35 104.17,96.07 103.61,95.5 103.16,95.5 103,95.66 102.47,95.66 101.61,94.79 97.95,94.79 97.62,95.12 97.62,95.86 97.98,96.22 98.69,96.22 99.37,95.53 101.15,95.53 102.78,97.16 102.78,101.35 102.9,101.47 104.05,101.47
+1P0V_VCCST on TOP (solid shape): 149.33,150.18 149.68,150.18 149.72,150.22 150.21,150.22 150.25,150.18 150.6,150.18 150.63,150.22 151.54,150.22 151.6,150.16 151.6,149.68 151.74,149.54 151.89,149.54 152.07,149.36 152.07,149.1 151.9,148.93 151.64,148.93 151.35,149.12 151.04,148.95 151.03,148.93 151.01,148.92 150.78,148.92 150.48,149.22 150.48,149.33 150.15,149.66 149.79,149.66 149.51,149.38 149.42,149.38 149.28,149.57 149.07,149.66 149.05,149.66 149,149.71 149,150.09 149.13,150.22 149.3,150.22
+1P0V_VCCST on BOTTOM (solid shape): outline of 291 points within 141.79,145.01 152.36,149.53
+1P2V_VDDQ_BOOT_20 on TOP (solid shape): 211.12,70.44 211.12,69.83 211.76,69.19 211.76,68.12 211.62,67.99 210.16,67.99 209.88,68.27 209.88,70.36 210.15,70.63 210.92,70.63
+1P2V_VDDQ_LG_30 on TOP (solid shape): 211.11,73.53 211.11,72.52 210.98,72.39 210.22,72.39 210.09,72.52 210.09,73.53 210.22,73.66 210.98,73.66
+1P2V_VDDQ_PHASE_20 on TOP (solid shape): 209.84,71.63 210.92,71.63 211,71.55 211,71.42 210.94,71.35 209.91,71.35 209.9,71.35 209.69,71.35 209.06,70.72 207.62,70.72 207.47,70.87 207.47,71.68 207.55,71.75 209.71,71.75
+1P2V_VDDQ_PHASE_20 on TOP (solid shape): 201.79,73.96 201.79,69.9 202.24,69.44 204.55,69.44 204.74,69.25 204.74,68.64 204.48,68.38 204.08,68.38 203.45,67.75 198.57,67.75 198.28,68.04 198.28,69.34 197.83,69.79 197.2,69.79 196.76,69.34 196.76,67.91 195.27,66.42 194.11,66.42 193.6,68.45 193.09,66.42 192,66.42 191.74,66.67 191.74,74.06 191.91,74.23 201.53,74.23
+1P2V_VDDQ_PHASE_20 on BOTTOM (solid shape): 201.79,74.29 201.79,69.93 201.65,69.79 197.2,69.79 196.76,69.34 196.76,69.27 196.71,69.22 196.71,67.82 195.26,66.37 191.98,66.37 191.65,66.7 191.65,74.17 192.16,74.68 201.4,74.68
+1P2V_VDDQ_PHASE_20 on L2_VCC: 192.04,66.42 191.68,66.78 191.68,74.19 192.16,74.68 201.58,74.68 201.58,69.49 202.11,68.96 203.34,68.96 203.85,69.47 204.4,69.47 204.63,69.24 204.63,68.49 203.92,67.78 203.92,67.76 203.79,67.63 202.26,67.63 202.2,67.69 196.65,67.69 195.38,66.42
+1P2V_VDDQ_VCC on TOP (solid shape): 208.98,73.66 209.2,73.66 209.84,73.03 209.84,72.52 210.22,72.14 210.98,72.14 211.03,72.09 211.03,71.93 210.96,71.86 209.83,71.86 209.74,71.94 207.37,71.94 207.14,72.18 207.14,73.34 207.28,73.48 207.3,73.48 207.48,73.66 207.91,73.66 208.11,73.86 208.79,73.86
+1P2V_VDDQ_VIN on TOP (solid shape): outline of 150 points within 166.41,60.45 205.39,67.06
+1P2V_VDDQ_VIN on BOTTOM (solid shape): 201.84,66.57 201.84,66.55 202.12,66.27 202.12,64.16 202.55,63.73 202.55,62.48 202.29,62.23 196.53,62.23 194.85,63.91 184.31,63.91 183.98,64.24 183.98,65.46 184.34,65.81 195.64,65.81 196.91,67.08 201.33,67.08
+1P2V_VDDQ_VIN on L2_VCC: 166.76,60.45 166.4,60.81 166.4,65.43 166.89,65.91 195.59,65.91 196.86,67.18 201.84,67.18 201.84,64.79 203,63.63 204.91,63.63 205.39,63.14 205.39,62.84 203,60.45 188.3,60.45 188.25,60.47 188.2,60.45
+1P5V_VA on TOP (solid shape): 199.89,20.81 199.89,20.42 200.96,19.35 200.96,17.03 200.77,16.84 200.39,16.84 200.14,17.09 200.14,17.5 199.46,18.18 198.72,18.18 198.53,18.37 198.53,19.25 198.53,19.26 198.53,19.5 198.37,19.66 197.38,19.66 196.84,20.19 195.75,20.19 195.58,20.37 195.58,21.12 195.8,21.35 199.36,21.35
+1P5V_VA_ADJ on TOP (solid shape): 202.08,20.85 202.08,16.97 201.96,16.84 201.47,16.84 201.47,19.56 200.59,20.44 200.59,21.13 200.75,21.3 201.63,21.3
+3P3V_AUX on TOP (solid shape): 42.17,129.1 42.03,128.96 40.23,128.96 39.98,129.21 39.98,129.51 40.14,129.67 42.17,129.67
+3P3V_AUX on TOP (solid shape): 42.68,135.81 44.15,135.81 44.46,135.51 44.46,135.51 44.54,135.43 45.63,134.34 45.63,134.09 45.5,133.96 45.29,133.96 44.76,134.49 44.76,134.5 44.63,134.63 44.55,134.63 44.53,134.65 41.87,134.65 41.61,134.9 41.61,135.92 41.71,136.02 42.48,136.02
+3P3V_AUX on TOP (solid shape): 46.08,72.2 46.08,70.34 45.65,69.91 39.28,69.91 38.38,69 30.83,69 30.28,68.45 24.29,68.45 24.13,68.29 22.45,68.29 21.53,69.22 21.34,69.22 21.21,69.34 19.68,69.34 19.46,69.57 19.46,70.51 20.32,71.37 22.89,71.37 23.11,71.59 23.14,71.59 23.36,71.81 23.36,71.84 24.06,72.54 45.75,72.54
+3P3V_AUX on TOP (solid shape): 48.37,89.42 48.37,88.55 48.05,88.23 44.15,88.23 41.76,85.84 41.11,85.84 40.64,85.8 40.56,85.34 40.58,85.31 40.36,85.1 38.68,85.1 38.34,85.44 38.34,86.13 39.69,87.48 40.77,87.48 43.26,89.97 47.82,89.97
+3P3V_AUX on TOP (solid shape): 40.47,114.16 40.47,112.32 40.78,111.92 41.21,112.18 41.38,112.34 42.04,112.34 42.31,112.08 42.31,111.62 42.37,111.56 42.64,111.56 42.77,111.43 42.81,111.42 42.85,111.41 42.89,111.39 42.92,111.38 43.84,111.38 43.85,111.38 44.16,111.38 44.16,111.38 44.71,111.38 44.71,111.38 44.86,111.38 45.25,111 45.25,109.73 45.03,109.51 41.43,109.51 40.8,108.89 40.29,108.89 40.1,109.08 40.1,111.17 39.78,111.49 39.78,114.18 39.94,114.34 40.29,114.34
+3P3V_AUX on TOP (solid shape): 47.77,116.75 47.77,116.49 47.74,116.47 47.65,116.13 47.99,116.03 48,116.03 48.16,116.03 48.27,115.92 48.27,115.85 48.28,115.8 48.3,115.74 48.3,115.61 48.16,115.47 48.11,115.47 48.07,115.46 48.02,115.45 47.94,115.45 47.92,115.47 47.89,115.52 47.85,115.55 47.82,115.58 47.8,115.58 47.71,115.6 47.62,115.58 47.61,115.58 47.56,115.58 47.44,115.44 47.44,115.26 47.45,115.23 47.21,114.99 47.01,114.99 46.83,115.18 46.83,116.13 46.98,116.29 47.03,116.29 47.24,116.42 47.2,116.67 47.17,116.71 47.36,116.9 47.61,116.9
+3P3V_AUX on BOTTOM (solid shape): 47.53,103.1 47.57,102.96 47.66,102.84 47.66,101.35 47.15,100.84 47.15,100.46 47.02,100.33 45.88,100.33 45.63,100.58 45.63,101.73 46.39,102.49 47.21,103.31 47.32,103.31
+3P3V_AUX on BOTTOM (solid shape): 48.1,91.11 48.27,90.96 48.5,90.94 48.75,90.69 48.75,89.23 48.01,88.5 46.95,88.5 46.31,89.14 46.31,90.33 46.34,90.37 46.36,90.41 46.39,90.53 46.37,90.66 46.82,91.11
+3P3V_AUX on BOTTOM (solid shape): 42.78,135.33 42.78,132.09 42.83,132.04 42.83,131.66 42.83,131.65 42.83,130.8 41.33,129.31 40.81,129.31 40.75,129.37 40.01,129.37 39.9,129.48 39.9,130.56 41.18,130.56 41.18,130.5 41.2,130.45 41.22,130.39 41.24,130.35 41.28,130.3 41.32,130.26 41.36,130.23 41.41,130.2 41.47,130.19 41.52,130.18 41.58,130.17 41.63,130.18 41.69,130.19 41.74,130.22 41.78,130.25 41.83,130.28 41.86,130.32 41.9,130.37 41.92,130.42 41.94,130.47 41.94,130.53 41.94,130.58 41.94,130.64 41.92,130.69 41.9,130.74 41.86,130.79 41.83,130.83 41.78,130.87 41.74,130.9 41.69,130.92 41.63,130.93 41.58,130.94 41.52,130.94 41.47,130.93 41.41,130.91 41.36,130.88 41.32,130.85 41.28,130.81 41.24,130.77 41.22,130.72 41.2,130.67 41.18,130.61 41.18,130.56 39.9,130.56 39.9,132.54 40.94,133.58 40.94,135.2 41.16,135.42 42.69,135.42
+3P3V_AUX on BOTTOM (solid shape): 40.26,85.95 40.26,85.27 40.93,84.6 40.93,80.79 41.94,79.79 41.94,79.79 42.15,79.57 42.15,79.03 42.58,78.6 42.58,76.19 45.09,73.69 45.09,73.2 45.09,73.19 45.09,71.82 44.79,71.52 42.73,71.52 41.81,72.44 41.81,74.19 40.89,75.11 40.89,75.12 40.63,75.38 40.62,75.38 40.35,75.65 40.35,76.99 40.38,77 40.66,77.37 40.38,77.73 40.13,77.72 39.95,77.56 39.9,77.51 39.84,77.58 39.82,77.6 39.1,78.32 39.1,79.59 38.34,80.35 38.34,82.84 38.37,83 38.34,83.16 38.34,85.87 38.93,86.47 39.74,86.47
+3P3V_AUX on L2_VCC: 46.37,101.47 45.88,101.96 45.88,102.98 41.31,107.55 41.31,108.69 40.78,109.22 40.06,109.22 38.39,107.55 38.39,106.91 37.52,106.04 32.9,106.04 32.42,106.53 32.42,110.21 32.04,110.6 32.04,113.18 32.16,113.31 32.16,116.35 32.27,116.46 32.9,116.46 33.31,116.86 33.31,121.31 33.82,121.81 33.82,124.44 33.41,124.84 32.65,124.84 32.55,124.95 32.55,127.61 30.26,129.9 30.26,130.96 30.49,131.19 34.98,131.19 35.55,130.62 35.69,130.62 37.43,128.88 39.59,128.88 39.94,129.22 39.94,129.53 40.15,129.74 42.87,129.74 43.15,130.02 47.98,130.02 48.23,130.28 48.86,130.28 48.99,130.15 50.77,130.15 53.73,127.19 53.73,123.76 53.98,123.51 53.98,120.33 54.36,119.95 54.36,117.92 55.38,116.9 55.38,111.19 55.66,110.91 55.66,110.77 59.72,106.7 59.72,103.36 59.09,102.72 59.09,101.96 58.73,101.6 56.02,101.6 54.62,103 52.89,103 52.23,102.34 52.23,101.71 52,101.47
+3P3V_MAIN on TOP (solid shape): 233.84,132.33 233.84,131.28 233.62,131.06 232.88,131.06 232.57,131.37 232.57,132.33 232.7,132.46 233.71,132.46
+3P3V_MAIN on TOP (solid shape): 209.84,56.13 209.84,55.12 209.71,54.99 206.54,54.99 206.05,55.47 206.05,56.35 206.46,56.76 209.22,56.76
+3P3V_MAIN on TOP (solid shape): 188.19,33.04 188.19,32.23 188.37,32.05 188.37,31.7 188.06,31.39 187.85,31.39 186.84,32.4 186.84,33.18 186.96,33.3 187.93,33.3
+3P3V_MAIN on TOP (solid shape): 25.14,154.59 25.31,154.56 25.47,154.59 25.48,154.6 26.71,154.6 26.71,153.05 26.18,152.52 25.56,152.52 24.01,154.07 24.01,154.12 24,154.2 23.95,154.27 23.95,154.52 24.04,154.6 25.13,154.6
+3P3V_MAIN on TOP (solid shape): 96.3,131.27 96.3,129.03 96.17,128.9 95.61,128.9 94.84,129.68 95.99,129.68 95.99,130.92 95.8,130.92 95.8,129.68 95.49,129.68 95.49,130.92 95.3,130.92 95.3,129.68 94.84,129.68 94.72,129.79 94.65,129.79 94.64,129.79 94.59,129.79 94.59,129.79 93.63,129.79 93.22,130.21 93.16,130.21 92.39,130.97 92.39,132.87 92.61,133.1 94.48,133.1
+3P3V_MAIN on TOP (solid shape): 202.37,23.21 202.48,23.21 202.49,23.23 203.32,23.23 204.39,22.17 204.39,22.17 206.64,19.92 206.64,17.89 206.65,17.88 206.65,15.26 206.29,14.9 205.43,14.9 205.33,15 205.33,20.16 204.61,20.88 204.61,20.87 203.26,22.23 202.94,22.23 202.94,22.23 202.19,22.23 201.77,21.81 200.54,21.81 200.54,21.8 198.65,21.8 198.48,21.64 195.77,21.64 195.6,21.82 195.6,22.69 195.86,22.96 198.08,22.96 198.97,23.85 199.32,23.85 199.51,23.65 199.51,22.71 199.79,22.43 200.38,22.43 200.49,22.54 200.49,22.54 200.63,22.69 200.63,23.66 200.83,23.85 201.74,23.85
+3P3V_MAIN on TOP (solid shape): outline of 124 points within 103.56,127.35 113.32,134.72
+3P3V_MAIN on TOP (solid shape): outline of 140 points within 41.75,57.81 54.82,63.15
+3P3V_MAIN on TOP (solid shape): outline of 135 points within 60.87,45.27 101.96,68.05
+3P3V_MAIN on TOP (solid shape): outline of 146 points within 132.75,214.33 154.37,233.93
+3P3V_MAIN on TOP (solid shape): outline of 348 points within 68.99,219.68 94.32,233.93
+3P3V_MAIN on BOTTOM (solid shape): 98.25,217.2 100.31,217.2 100.36,217.14 100.36,215.52 100.26,215.42 97.42,215.42 92.11,220.73 92.11,221.18 92.92,222 93.45,222
+3P3V_MAIN on BOTTOM (solid shape): 134.46,216.15 134.46,214.52 134.35,214.4 133.55,214.4 132.96,213.82 132.95,213.82 132.72,213.59 129.93,213.59 129.8,213.72 129.8,215.14 129.93,215.26 131.48,215.26 132.7,216.48 134.13,216.48
+3P3V_MAIN on BOTTOM (solid shape): 82.68,88.33 84.35,88.33 84.49,88.19 84.49,86.49 84.34,86.33 81.41,86.33 78.62,89.13 69.26,89.13 69.1,89.29 69.01,89.42 68.88,89.51 68.87,89.51 68.74,89.54 68.61,89.51 68.6,89.51 67.61,89.51 67.6,89.51 67.47,89.54 67.34,89.51 67.33,89.51 66.47,89.51 66.46,89.51 66.33,89.54 66.2,89.51 66.19,89.51 66.12,89.51 64.24,87.63 64.24,87.63 64.12,87.52 61.07,87.52 60.91,87.69 60.91,89.31 61.38,89.79 63.3,89.79 64.82,91.3 79.71,91.3
+3P3V_MAIN on L2_VCC: 83.05,86.56 81.26,88.35 81.26,91.48 80.87,92.53 79.23,96.56 79.23,103.93 81.64,106.34 81.64,111.8 86.47,116.63 86.47,119.85 86.34,119.97 86.34,123.15 85.07,124.42 85.07,133.14 85.33,133.4 85.84,133.4 86.47,134.03 86.47,136.19 86.73,136.45 88.38,136.45 89.01,137.08 89.01,138.6 89.4,138.99 93.48,138.99 93.53,138.94 95.64,138.94 96.66,139.95 97.59,139.95 98.1,139.45 99.71,139.45 100.72,140.46 102.29,140.46 102.52,140.23 102.52,137.56 103.18,136.91 103.69,136.91 103.79,136.8 103.79,135.02 105.57,133.24 105.57,132.31 105.21,131.95 104.66,131.95 103.14,133.48 95.05,133.48 91.22,129.65 91.22,122.07 91.73,121.56 91.73,117.71 83.98,109.96 83.98,104.25 81.31,101.58 81.31,96.41 86.65,91.08 86.65,86.9 86.31,86.56
+3P3V_MAIN on L2_VCC: outline of 192 points within 10.45,55.37 89.06,236.47 ; 1 cut-out
+3P3V_PCIAUX on TOP (solid shape): outline of 144 points within 65.63,221.23 79.54,230.25
+3P3V_PCIAUX on TOP (solid shape): outline of 1533 points within 9.81,208.03 59.05,233.17
+3P3V_PCIAUX on BOTTOM (solid shape): 15.89,232.72 15.89,208.26 15.78,208.15 13.88,208.15 13.75,208.28 13.75,232.75 13.93,232.92 15.69,232.92
+3P3V_PCIAUX on BOTTOM (solid shape): outline of 908 points within 55.53,219.96 66.92,230.4
+3P3V_SB on TOP (solid shape): 226.87,52.44 226.87,51.07 226.71,50.92 226.22,50.92 226.18,50.88 225.61,51.45 222.98,51.45 222.81,51.63 222.81,53.17 223.01,53.38 225.93,53.38
+3P3V_SB on TOP (solid shape): 13.37,209.42 13.37,208.28 13.24,208.15 12.86,208.15 12.61,207.9 12.61,205.36 12.48,205.23 10.19,205.23 10.07,205.36 10.07,208.28 10.26,208.47 10.26,209.04 10.51,209.3 12.41,209.3 12.67,209.55 13.24,209.55
+3P3V_SB on TOP (solid shape): 53.62,254.49 53.62,253.96 53.48,253.82 51.98,253.82 51.8,253.64 51.8,253.17 51.5,252.87 50.25,252.87 49.97,253.14 49.97,253.63 49.23,254.37 48.69,254.37 48.64,254.38 48.6,254.38 47.99,254.38 47.94,254.38 47.81,254.37 47.75,254.32 47.66,254.25 47.59,254.16 47.45,254.01 47.45,253.64 47.07,253.25 45.93,253.25 45.68,253.5 45.68,254.48 45.84,254.65 53.46,254.65
+3P3V_SB on TOP (solid shape): 66.58,254.5 66.58,254.25 66.58,254.13 66.58,253.9 66.83,253.65 67.2,253.65 67.63,253.22 67.64,253.21 67.78,252.98 68.01,252.83 68.02,252.83 69.11,251.74 69.11,249.99 68.79,249.68 67.91,249.68 67.66,249.93 67.66,250.66 67.26,251.07 67.23,251.1 67.13,251.2 66.96,251.21 66.87,251.2 66.66,251.2 66.21,251.65 65.42,251.65 65.19,251.89 65.19,253.41 64.9,253.7 64.86,253.7 64.85,253.71 64.71,253.75 64.57,253.73 64.54,253.72 64.27,253.99 64.27,254.44 64.49,254.66 66.42,254.66
+3P3V_SB on TOP (solid shape): outline of 99 points within 3.72,81.69 14.74,182.31
+3P3V_SB on TOP (solid shape): outline of 116 points within 20.17,50.37 67.34,69.81
+3P3V_SB on BOTTOM (solid shape): 66.44,53.51 66.44,51.2 65.61,50.37 62.97,50.37 60.4,52.94 60.4,54.07 60.52,54.19 65.76,54.19
+3P3V_SB on BOTTOM (solid shape): 77.91,235.64 77.91,233.87 78.01,233.77 78.02,233.75 78.53,233.16 79.23,233.51 79.88,233.51 80.18,233.21 80.15,233.18 80.05,232.98 80.01,232.76 79.99,232.69 79.91,232.65 79.03,232.65 79,232.68 77.65,232.68 77.64,232.68 77.09,233.23 77.09,235.3 77.48,235.68 77.87,235.68
+3P3V_SB on BOTTOM (solid shape): 59.22,135.21 59.22,133.74 58.87,133.39 58.58,133.39 58.57,133.39 58.21,133.28 58.12,132.91 58.12,132.9 58.12,132.39 58.12,132.38 58.1,132.22 58.16,132.07 58.21,132.01 58.27,131.95 58.28,131.89 58.24,131.83 58.12,131.66 58.1,131.45 58.15,131.31 58.25,131.2 58.27,131.16 58.28,131.12 58.21,131.04 58.09,130.78 58.17,130.52 58.19,130.44 58.16,130.38 57.98,130 58.16,129.61 58.19,129.55 58.18,129.49 58.14,129.43 58.11,129.36 58.21,128.88 58.71,128.85 58.78,128.77 58.78,128.29 58.62,128.13 57.93,128.13 57.76,128.31 57.75,128.32 57.62,128.55 57.39,128.69 57.37,128.69 57.36,128.71 56.96,128.71 56.67,129 56.67,129.57 56.71,129.65 56.79,129.67 56.81,129.65 57.34,129.71 57.3,130.24 57.3,130.81 57.55,131.06 57.55,134.46 58.46,135.37 59.07,135.37
+3P3V_SB on BOTTOM (solid shape): outline of 179 points within 11.08,65.52 28.61,85.62
+3P3V_SB on BOTTOM (solid shape): outline of 367 points within 1.56,178.94 66.8,257.33
+3P3V_SB on L2_VCC: 63.13,50.16 60.36,52.94 60.36,55.22 58.81,56.77 55.66,56.77 55.66,64.54 56.65,65.53 64.95,65.53 65.31,65.17 65.31,64.03 66.07,63.27 66.07,60.6 68.49,58.19 68.49,51.54 67.11,50.16
+3P3V_SB_BOOT_20 on TOP (solid shape): 49.73,53.99 49.73,53.21 49.39,52.87 48.82,52.87 48.08,52.12 47.9,52.12 47.79,52.23 47.79,52.69 48.42,53.32 48.42,53.83 48.91,54.32 49.4,54.32
+3P3V_SB_LG_25 on TOP (solid shape): 47.93,54.27 47.93,53.91 47.77,53.75 46.94,53.75 46.55,53.36 46.55,52.98 46.52,52.95 46.39,52.95 46.33,53.01 46.33,53.9 47.01,54.58 47.62,54.58
+3P3V_SB_LG_25 on TOP (solid shape): 54.42,53.87 54.42,53.22 54.12,52.92 53.72,52.92 53.63,52.83 53.17,52.83 52.98,53.02 52.98,53.86 53.25,54.13 54.16,54.13
+3P3V_SB_LG_25 on BOTTOM (solid shape): 54.01,53.91 54.01,53.23 53.68,52.9 53.2,52.9 52.59,53.51 48.67,53.51 48.44,53.74 46.96,53.74 46.84,53.86 46.84,54.13 47.34,54.62 53.3,54.62
+3P3V_SB_PHASE_25 on TOP (solid shape): 62.62,49.68 64.31,49.68 65.6,48.39 65.6,45.79 65.28,45.47 54.01,45.47 54.01,46.71 53.63,47.1 53.63,52.43 53.78,52.58 59.72,52.58
+3P3V_SB_PHASE_25 on TOP (solid shape): 50.04,52.84 50.04,52.69 49.74,52.39 49.74,51.75 49.94,51.55 49.94,51.38 49.87,51.31 48.53,51.31 48.12,51.72 48.12,51.89 48.71,52.48 48.72,52.48 48.9,52.65 49.46,52.65 49.72,52.91 49.97,52.91
+3P3V_SB_PHASE_25 on BOTTOM (solid shape): 61.7,49.45 64.47,49.45 65.7,48.22 65.7,46.53 65.2,46.03 59,46.03 56.88,48.16 54.31,48.16 54.15,48.31 54.15,51.99 54.31,52.15 59,52.15
+3P3V_SB_PHASE_25 on BOTTOM (solid shape): 50.7,52.78 50.7,51.45 50.85,51.3 50.85,51.29 50.98,51.08 51.19,50.95 51.21,50.94 51.76,50.39 52.25,50.39 53.47,49.18 53.47,47.99 54.08,47.38 55.5,47.38 55.63,47.24 55.63,46.83 55.48,46.68 53.31,46.68 52.89,47.09 52.89,48.71 52.29,49.31 51.3,49.31 49.42,51.19 49.42,52.68 49.77,53.02 50.46,53.02
+3P3V_SB_PHASE_25 on L2_VCC: 54.24,45.47 54.01,45.7 54.01,46.71 53.75,46.97 53.75,47.48 53.37,47.86 53.37,51.16 53.12,51.41 53.12,52.35 53.35,52.58 60,52.58 62.92,49.66 67.11,49.66 67.34,49.42 67.34,47.48 65.33,45.47
