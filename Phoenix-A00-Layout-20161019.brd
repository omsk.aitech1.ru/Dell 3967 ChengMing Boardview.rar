# Allegro board Phoenix-A00-Layout-20161019.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_DA23: length 63.7
  TOP w0.089: 186.79,130.78 186.79,132.03 185.59,133.23 CPU.AR40
  TOP w0.165: DIMM1.177 196.74,90.76 196.06,91.44 196.06,92.04 197.06,93.04 197.06,97.36 186.72,107.7 186.72,109.67 186.92,109.87 187.24,109.87 187.43,110.07 187.43,110.35 187.24,110.55 186.92,110.55 186.72,110.75 186.72,111.03 186.92,111.22 187.29,111.22 187.49,111.42 187.49,111.7 187.29,111.9 186.92,111.9 186.72,112.1 186.72,112.38 186.92,112.57 187.29,112.57 187.49,112.77 187.49,113.05 187.29,113.25 186.92,113.25 186.72,113.45 186.72,113.73 186.92,113.93 187.29,113.93 187.49,114.12 187.49,114.4 187.29,114.6 186.92,114.6 186.72,114.8 186.72,115.08 186.92,115.28 187.29,115.28 187.49,115.48 187.49,115.75 187.29,115.95 186.92,115.95 186.72,116.15 186.72,116.43 186.92,116.63 187.29,116.63 187.49,116.83 187.49,117.11 187.29,117.3 186.92,117.3 186.72,117.5 186.72,117.78 186.92,117.98 187.29,117.98 187.49,118.18 187.49,118.46 187.29,118.66 186.92,118.66 186.72,118.85 186.72,119.13 186.92,119.33 187.29,119.33 187.49,119.53 187.49,119.81 187.29,120.01 186.92,120.01 186.72,120.2 186.72,120.48 186.92,120.68 187.29,120.68 187.49,120.88 187.49,121.16 187.29,121.36 186.97,121.36 186.77,121.56 186.77,121.84 186.97,122.03 187.29,122.03 187.49,122.23 187.49,122.51 187.29,122.71 187,122.71 186.8,122.91 186.8,123.19 187,123.38 187.29,123.38 187.49,123.58 187.49,123.86 187.29,124.06 187,124.06 186.8,124.26 186.8,124.54 187,124.74 187.29,124.74 187.49,124.93 187.49,126.27 186.79,126.97 186.79,130.78
M_DA24: length 55.4
  TOP w0.089: CPU.AW37 181.55,129.24 181.55,126.99 181.77,126.76
  TOP w0.165: 181.77,126.76 181.77,104.3 182.15,103.92 182.15,103.62 181.77,103.24 181.77,101.64 182.15,101.25 182.43,101.25 183.13,101.95 183.4,101.95 183.6,101.75 183.6,101.47 182.91,100.77 182.91,100.5 183.11,100.3 183.39,100.3 184.08,100.99 184.36,100.99 184.56,100.79 184.56,100.51 183.87,99.82 183.87,99.54 184.06,99.34 184.34,99.34 185.04,100.03 185.32,100.03 185.51,99.84 185.51,99.56 184.82,98.86 184.82,98.58 185.02,98.39 185.3,98.39 185.99,99.08 186.27,99.08 186.47,98.88 186.47,98.6 186.27,98.4 185.78,97.91 185.78,97.63 190.32,93.09 190.32,92.46 190.62,92.15 190.62,91.26 191.64,90.23 DIMM1.183
M_DA25: length 57.6
  TOP w0.089: 183.18,128.47 183.18,128.49 183.42,128.73 183.42,129.63 183.05,130.01 182.67,130.01 182.33,130.35 182.33,130.76 181.88,131.2 CPU.AU37
  TOP w0.165: DIMM1.181 193.34,90.28 192.32,91.3 192.32,92.2 191.98,92.55 191.98,93.28 190.97,94.29 190.97,94.82 190.75,95.03 190.23,95.03 189.95,95.31 189.95,95.83 190.67,96.56 190.67,97.52 187.92,100.27 187.92,100.55 188.37,101 188.37,101.28 188.17,101.48 187.89,101.48 187.44,101.03 187.16,101.03 186.97,101.23 186.97,101.51 187.41,101.95 187.41,102.23 187.21,102.43 186.93,102.43 186.49,101.99 186.21,101.99 186.01,102.18 186.01,102.46 186.46,102.91 186.46,103.19 186.26,103.39 185.98,103.39 185.53,102.94 185.25,102.94 185.06,103.14 185.06,103.42 185.5,103.86 185.5,104.14 185.3,104.34 185.02,104.34 184.58,103.9 184.3,103.9 184.1,104.1 184.1,104.38 184.54,104.82 184.54,105.1 184.35,105.3 184.07,105.3 183.72,104.96 183.44,104.96 183.25,105.15 183.25,105.43 183.59,105.78 183.59,106.06 183.18,106.46 183.18,128.47
M_DA26: length 58
  TOP w0.089: 178.94,126.76 179.72,127.54 179.72,129.76 179.93,129.98 180.07,129.98 180.39,130.3 180.39,130.68 180.05,131.02 CPU.AU35
  TOP w0.165: 178.94,126.76 178.72,126.54 178.72,125.56 178.42,125.26 178.42,124.89 178.72,124.58 178.72,100.85 178.29,100.42 178.29,99.05 178.76,98.58 178.76,98.3 178.32,97.87 178.32,97.59 178.52,97.39 178.79,97.39 179.23,97.83 179.51,97.83 179.71,97.63 179.71,97.35 178.78,96.41 178.78,96.13 178.98,95.94 179.26,95.94 180.19,96.87 180.47,96.87 180.67,96.67 180.67,96.39 179.73,95.46 179.73,95.18 179.93,94.98 180.21,94.98 181.15,95.92 181.43,95.92 181.62,95.72 181.62,95.44 180.69,94.5 180.69,94.22 180.89,94.03 181.17,94.03 182.1,94.96 182.38,94.96 182.58,94.76 182.58,94.48 182.33,94.23 182.33,93.95 182.53,93.76 182.81,93.76 183.06,94 183.34,94 184.89,92.46 185.35,92.46 185.66,92.15 185.66,91.24 185.91,90.98 186.32,90.98 186.54,91.21 DIMM1.45
M_DA27: length 57.2
  TOP w0.089: CPU.AV35 179.48,129.91 179.48,127.96 179.14,127.62 177.77,127.62 177.27,127.12 177.27,126.76
  TOP w0.165: DIMM1.190 185.69,88.73 184.74,89.69 184.74,90.55 184.06,91.24 184.06,91.87 182.86,93.07 180.91,93.07 178.14,95.83 178.14,96.85 177.66,97.33 177.66,100.68 178.06,101.08 178.06,117.31 177.86,117.5 177.52,117.5 177.33,117.7 177.33,117.98 177.52,118.18 177.86,118.18 178.06,118.38 178.06,118.66 177.86,118.85 177.47,118.85 177.27,119.05 177.27,119.33 177.47,119.53 177.86,119.53 178.06,119.73 178.06,120.01 177.86,120.21 177.47,120.21 177.27,120.4 177.27,120.68 177.47,120.88 177.86,120.88 178.06,121.08 178.06,121.36 177.86,121.56 177.47,121.56 177.27,121.75 177.27,122.03 177.47,122.23 177.86,122.23 178.06,122.43 178.06,122.71 177.86,122.91 177.47,122.91 177.27,123.11 177.27,123.39 177.47,123.58 177.86,123.58 178.06,123.78 178.06,124.06 177.86,124.26 177.47,124.26 177.27,124.46 177.27,124.74 177.66,125.13 177.66,125.41 177.27,125.8 177.27,126.76
M_DA28: length 56.7
  TOP w0.089: CPU.AU38 183.24,130.96 183.24,130.16 183.94,129.45 183.94,128.47
  TOP w0.165: DIMM1.36 194.19,90.8 193.95,91.04 193.06,91.04 192.66,91.44 192.66,93.6 192.34,93.93 192.34,94.34 192.66,94.67 192.66,94.95 192.47,95.15 191.65,95.15 191.45,95.35 191.45,95.63 191.65,95.82 192.47,95.82 192.66,96.02 192.66,96.3 192.47,96.5 191.65,96.5 191.45,96.7 191.45,96.98 191.65,97.17 192.47,97.17 192.66,97.37 192.66,97.92 192.01,98.58 191.73,98.58 191.28,98.13 191,98.13 190.81,98.33 190.81,98.61 191.25,99.05 191.25,99.33 191.05,99.53 190.77,99.53 190.33,99.09 190.05,99.09 189.85,99.28 189.85,99.56 190.3,100.01 190.3,100.29 190.1,100.49 189.82,100.49 189.37,100.04 189.09,100.04 188.9,100.24 188.9,100.52 189.34,100.96 189.34,101.24 183.94,106.64 183.94,121.88 184.31,122.25 184.31,122.56 183.94,122.92 183.94,123.23 184.31,123.6 184.31,123.91 183.94,124.28 183.94,124.58 184.31,124.95 184.31,125.26 183.94,125.63 183.94,125.93 184.31,126.3 184.31,126.61 183.94,126.98 183.94,128.47
M_DA29: length 56.3
  TOP w0.089: CPU.AV37 181.88,130.25 182.33,129.81 182.33,128.47
  TOP w0.165: 182.33,128.47 182.33,127.43 182.55,127.21 182.55,104.63 183.08,104.1 183.08,103.82 182.91,103.64 182.91,103.36 183.11,103.16 183.39,103.16 183.56,103.34 183.84,103.34 184.04,103.14 184.04,102.86 183.86,102.68 183.86,102.4 184.06,102.2 184.34,102.2 184.52,102.38 184.8,102.38 185,102.18 185,101.9 184.82,101.73 184.82,101.45 185.02,101.25 185.3,101.25 185.47,101.43 185.75,101.43 185.95,101.23 185.95,100.95 185.77,100.77 185.77,100.49 185.97,100.29 186.25,100.29 186.43,100.47 186.71,100.47 186.91,100.27 186.91,99.99 186.73,99.82 186.73,99.54 186.93,99.34 187.21,99.34 187.38,99.52 187.66,99.52 188,99.18 188,98.9 186.87,97.77 186.87,97.49 187.06,97.3 187.34,97.3 188.47,98.43 188.75,98.43 188.95,98.23 188.95,97.95 187.82,96.82 187.82,96.54 188.02,96.34 188.3,96.34 189.14,97.18 189.42,97.18 189.62,96.98 189.62,96.7 188.78,95.86 188.78,95.58 190.96,93.4 190.96,91.44 191.36,91.04 191.82,91.04 192.49,90.37 DIMM1.38
M_DA30: length 59.1
  TOP w0.089: CPU.AT35 180.43,131.94 180.43,131.04 180.63,130.84 180.63,130.17 180.39,129.93 180.39,129.23 180.2,129.04 180.2,128.19 180.73,127.66 180.73,127.36 180.35,126.98 180.35,126.76
  TOP w0.165: 180.35,126.76 180.35,101.06 180.51,100.9 180.51,100.62 179.7,99.81 179.7,99.53 179.9,99.33 180.18,99.33 180.99,100.14 181.27,100.14 181.47,99.94 181.47,99.67 180.66,98.85 180.66,98.57 180.85,98.38 181.13,98.38 181.94,99.19 182.22,99.19 182.42,98.99 182.42,98.71 181.61,97.9 181.61,97.62 181.81,97.42 182.09,97.42 182.9,98.23 183.18,98.23 183.38,98.03 183.38,97.75 182.57,96.94 182.57,96.66 182.76,96.47 183.04,96.47 183.86,97.28 184.14,97.28 184.33,97.08 184.33,96.8 183.52,95.99 183.52,95.71 183.72,95.51 184,95.51 184.81,96.32 185.09,96.32 185.29,96.12 185.29,95.84 184.92,95.48 184.92,95.25 185.17,95 185.4,95 185.77,95.37 186.05,95.37 188.24,93.17 DIMM1.43
M_DA31: length 55.7
  TOP w0.089: 179.71,126.76 179.96,127.01 179.96,129.14 180.05,129.24 CPU.AW35
  TOP w0.165: 179.71,126.76 179.71,126.5 179.36,126.15 179.36,125.82 179.71,125.47 179.71,125.15 179.36,124.8 179.36,124.47 179.71,124.12 179.71,123.8 179.36,123.44 179.36,123.12 179.71,122.77 179.71,122.45 179.36,122.09 179.36,121.77 179.71,121.42 179.71,121.1 179.36,120.74 179.36,120.42 179.71,120.07 179.71,119.74 179.36,119.39 179.36,119.07 179.71,118.72 179.71,118.39 179.36,118.04 179.36,117.72 179.71,117.36 179.71,117.04 179.36,116.69 179.36,116.37 179.71,116.01 179.71,114.99 179.36,114.64 179.36,114.31 179.71,113.96 179.71,113.64 179.36,113.29 179.36,112.96 179.71,112.61 179.71,112.29 179.36,111.93 179.36,111.61 179.71,111.26 179.71,110.94 179.36,110.58 179.36,110.26 179.71,109.91 179.71,109.58 179.36,109.23 179.36,108.91 179.71,108.56 179.71,108.23 179.36,107.88 179.36,107.56 179.71,107.21 179.71,106.88 179.36,106.53 179.36,106.21 179.71,105.85 179.71,105.53 179.36,105.18 179.36,104.86 179.71,104.5 179.71,104.18 179.36,103.83 179.36,103.5 179.71,103.15 179.71,102.83 179.36,102.48 179.36,102.15 179.71,101.8 179.71,100.94 178.93,100.15 178.93,99.31 183.9,94.34 185.78,94.34 186.04,94.08 186.04,93.8 185.77,93.53 185.77,93.25 185.97,93.05 186.25,93.05 186.52,93.32 186.8,93.32 187.49,92.63 187.49,91.31 188.12,90.68 188.12,89.64 187.39,88.91 187.39,87.79 186.83,87.23 186.83,86.89 DIMM1.188
M_DA32: length 60.8
  TOP w0.089: CPU.AY8 153.4,129.34 153.4,124.47
  TOP w0.165: DIMM1.97 137.24,92.84 136.89,93.2 136.89,93.48 137.09,93.68 137.38,93.68 137.57,93.88 137.57,94.16 137.38,94.35 137.09,94.35 136.89,94.55 136.89,94.83 137.09,95.03 137.38,95.03 137.57,95.23 137.57,95.51 137.38,95.71 137.09,95.71 136.89,95.9 136.89,96.18 137.09,96.38 137.38,96.38 137.57,96.58 137.57,96.82 141.96,101.2 142.24,101.2 142.78,100.66 143.06,100.66 143.26,100.86 143.26,101.14 142.72,101.68 142.72,101.96 142.92,102.16 143.2,102.16 144.25,101.11 144.53,101.11 144.72,101.31 144.72,101.59 143.67,102.64 143.67,102.92 143.87,103.12 144.15,103.12 145.18,102.09 145.46,102.09 145.65,102.29 145.65,102.57 144.63,103.59 144.63,103.87 144.83,104.07 145.11,104.07 145.52,103.66 145.8,103.66 146,103.85 146,104.13 145.59,104.55 145.59,104.83 145.78,105.03 146.06,105.03 146.48,104.61 146.76,104.61 146.96,104.81 146.96,105.09 146.54,105.5 146.54,105.78 146.74,105.98 147.02,105.98 147.43,105.57 147.71,105.57 147.91,105.77 147.91,106.05 147.54,106.41 147.54,106.69 147.74,106.89 148.02,106.89 148.39,106.52 148.67,106.52 150.17,108.02 150.17,115.99 153.4,119.22 153.4,124.47
M_DA33: length 63.4
  TOP w0.089: 152.76,124.47 152.76,129.77 152.59,129.94 152.59,130.97 152.74,131.11 152.74,131.89 CPU.AU8
  TOP w0.165: DIMM1.242 137.07,86.32 137.92,87.18 137.92,89.02 137.19,89.75 137.19,90.63 136.25,91.57 136.25,96.66 147.53,107.94 147.81,107.94 148.28,107.48 148.56,107.48 148.75,107.67 148.75,107.95 148.29,108.42 148.29,108.7 149.31,109.71 149.31,110.21 148.86,110.65 148.54,110.65 148.34,110.85 148.34,111.13 148.54,111.33 149.33,111.33 149.53,111.53 149.53,111.81 149.33,112.01 148.54,112.01 148.34,112.2 148.34,112.48 148.54,112.68 149.33,112.68 149.53,112.88 149.53,113.16 149.33,113.36 148.49,113.36 148.29,113.55 148.29,113.83 148.49,114.03 149.33,114.03 149.53,114.23 149.53,114.51 149.33,114.71 148.72,114.71 148.52,114.91 148.52,115.19 148.72,115.38 149.33,115.38 149.53,115.58 149.53,116.25 152.76,119.48 152.76,124.47
M_DA34: length 60.9
  TOP w0.089: CPU.AV6 151,130.66 151,130.13 150.76,129.89 150.76,129.17 150.85,129.09 150.85,126.18 149.91,125.24
  TOP w0.165: 149.91,125.24 149.66,124.99 149.66,120.4 144.49,115.22 143.33,115.22 143.14,115.02 143.14,114.74 143.33,114.55 144.49,114.55 144.69,114.35 144.69,114.07 144.49,113.87 143.33,113.87 143.14,113.67 143.14,113.39 143.33,113.2 144.49,113.2 144.69,113 144.69,112.72 144.49,112.52 143.36,112.52 143.16,112.32 143.16,112.04 143.36,111.84 144.49,111.84 144.69,111.65 144.69,111.37 144.49,111.17 143.49,111.17 143.29,110.97 143.29,110.69 143.49,110.49 144.49,110.49 144.69,110.3 144.69,109.98 144.14,109.43 143.86,109.43 143.73,109.56 143.45,109.56 143.25,109.36 143.25,109.08 143.38,108.95 143.38,108.67 132.69,97.98 132.69,94.13 131.12,92.56 131.12,91.34 130.72,90.93 130.72,90.7 DIMM1.104
M_DA35: length 61.7
  TOP w0.089: 149.43,125.72 149.98,126.27 149.98,129.67 150.31,130 150.51,130 150.76,130.25 150.76,131.11 CPU.AU6
  TOP w0.165: DIMM1.249 130.75,88.23 130.75,89.62 130.31,90.06 130.31,90.9 129.76,91.44 129.76,92.1 132.06,94.4 132.06,98.25 142.5,108.69 142.5,115.65 143.17,116.32 143.45,116.32 143.9,115.87 144.18,115.87 144.37,116.07 144.37,116.35 143.93,116.79 143.93,117.07 144.13,117.27 144.41,117.27 144.88,116.8 145.16,116.8 145.35,117 145.35,117.28 144.89,117.75 144.89,118.03 145.08,118.23 145.36,118.23 145.83,117.76 146.11,117.76 146.31,117.96 146.31,118.24 145.84,118.71 145.84,118.99 146.04,119.18 146.32,119.18 146.79,118.71 147.07,118.71 147.27,118.91 147.27,119.19 146.8,119.66 146.8,119.94 146.99,120.14 147.27,120.14 147.74,119.67 148.02,119.67 149.03,120.68 149.03,125.32 149.43,125.72
M_DA36: length 61.8
  TOP w0.089: 154.67,124.47 154.67,128.41 154.49,128.59 154.49,129.72 154.16,130.05 153.76,130.05 153.32,130.49 CPU.AW8
  TOP w0.165: 154.67,124.47 154.67,118.69 151.44,115.46 151.44,106.21 144.59,99.36 143.11,99.36 142.2,98.45 142.2,96.95 141.96,96.71 139.3,96.71 139.1,96.51 139.1,96.23 139.3,96.04 141.26,96.04 141.46,95.84 141.46,95.56 141.26,95.36 139.17,95.36 138.97,95.16 138.97,94.88 139.17,94.69 141.26,94.69 141.46,94.49 141.46,94.21 141.26,94.01 139.09,94.01 138.89,93.81 138.89,93.53 139.09,93.33 141.26,93.33 141.46,93.14 141.46,92.84 141.05,92.43 139.65,92.43 DIMM1.95
M_DA37: length 62.8
  TOP w0.089: CPU.AV8 153.17,131.04 152.83,130.7 152.83,130.3 153.15,129.98 153.29,129.98 153.65,129.62 153.65,128.57 154.03,128.19 154.03,124.47
  TOP w0.165: 154.03,124.47 154.03,118.96 150.8,115.73 150.8,106.47 150.41,106.08 150.13,106.08 149.78,106.44 149.5,106.44 149.3,106.24 149.3,105.96 149.66,105.61 149.66,105.33 149.46,105.13 149.18,105.13 148.82,105.48 148.54,105.48 148.35,105.28 148.35,105 148.7,104.65 148.7,104.37 148.5,104.17 148.22,104.17 147.87,104.53 147.59,104.53 147.39,104.33 147.39,104.05 147.74,103.69 147.74,103.41 147.55,103.22 147.27,103.22 146.91,103.57 146.63,103.57 146.43,103.37 146.43,103.09 146.79,102.74 146.79,102.46 144.33,100 141.65,100 141.12,99.47 141.12,99.19 141.49,98.81 141.49,98.53 141.3,98.34 141.02,98.34 140.64,98.71 140.36,98.71 140.17,98.51 140.17,98.23 140.54,97.86 140.54,97.58 140.34,97.38 140.06,97.38 139.69,97.75 139.41,97.75 138.21,96.55 138.21,91.5 138.83,90.87 138.83,89.16 138.26,88.59 138.26,87.64 138.48,87.42 138.48,86.71 DIMM1.240
M_DA38: length 59.8
  TOP w0.089: CPU.AW6 151.34,130.1 151.33,130.1 151,129.77 151,129.3 151.09,129.22 151.09,126.01 150.3,125.22 150.3,124.69
  TOP w0.165: 150.3,124.69 150.3,120.14 146.12,115.96 146.12,114.32 145.92,114.12 145.57,114.12 145.37,113.93 145.37,113.65 145.57,113.45 145.92,113.45 146.12,113.25 146.12,112.97 145.92,112.77 145.57,112.77 145.37,112.57 145.37,112.29 145.57,112.1 145.92,112.1 146.12,111.9 146.12,111.62 145.92,111.42 145.57,111.42 145.37,111.22 145.37,110.94 145.57,110.75 145.92,110.75 146.12,110.55 146.12,109.56 145.89,109.33 145.61,109.33 145.42,109.52 145.14,109.52 144.94,109.33 144.94,109.05 145.16,108.83 145.16,108.55 144.96,108.35 144.68,108.35 144.47,108.57 144.19,108.57 143.99,108.37 143.99,108.09 144.2,107.88 144.2,107.6 144.01,107.4 143.73,107.4 143.51,107.61 143.23,107.61 133.33,97.71 133.33,96.91 133.53,96.71 133.97,96.71 134.17,96.51 134.17,96.23 133.97,96.03 133.53,96.03 133.33,95.83 133.33,95.56 133.53,95.36 133.97,95.36 134.17,95.16 134.17,94.88 133.97,94.68 133.53,94.68 133.33,94.48 133.33,93.87 131.46,92.01 131.46,91.44 131.97,90.93 131.97,89.73 131.4,89.15 131.4,88.67 DIMM1.247
M_DA39: length 58.4
  TOP w0.089: 150.93,124.47 150.93,125.46 151.34,125.86 CPU.AY6
  TOP w0.165: 150.93,124.47 150.93,119.87 146.76,115.69 146.76,109.22 143.7,106.16 143.42,106.16 143.24,106.35 142.96,106.35 142.76,106.15 142.76,105.87 142.94,105.68 142.94,105.4 142.75,105.21 142.47,105.21 142.28,105.39 142,105.39 141.8,105.19 141.8,104.91 141.99,104.73 141.99,104.45 141.63,104.09 141.35,104.09 141.14,104.3 140.86,104.3 140.66,104.1 140.66,103.82 140.87,103.61 140.87,103.33 140.53,103 140.25,103 140.04,103.21 139.76,103.21 139.57,103.01 139.57,102.73 139.78,102.52 139.78,102.24 139.58,102.04 139.3,102.04 139.08,102.26 138.8,102.26 138.6,102.06 138.6,101.79 138.82,101.56 138.82,101.28 138.62,101.08 138.34,101.08 138.12,101.31 137.84,101.31 137.64,101.11 137.64,100.83 137.87,100.61 137.87,100.33 137.67,100.13 137.39,100.13 137.16,100.35 136.88,100.35 136.69,100.15 136.69,99.87 136.91,99.65 136.91,99.37 136.71,99.17 136.43,99.17 136.21,99.4 135.93,99.4 135.73,99.2 135.73,98.92 135.95,98.7 135.95,98.42 135.76,98.22 135.48,98.22 135.25,98.44 134.97,98.44 134.78,98.24 134.78,97.96 135,97.74 135,97.46 134.84,97.3 134.84,93.82 132.99,91.97 132.99,91.44 132.31,90.76 132.31,89.16 132.47,89 132.85,89 132.99,89.15 DIMM1.102
M_DA40: length 64.2
  TOP w0.089: 148.96,126.19 149.51,126.74 CPU.AY4
  TOP w0.165: 148.96,126.19 148.39,125.63 148.39,122.5 147.86,121.97 147.86,121.69 148.34,121.21 148.34,120.93 148.15,120.73 147.87,120.73 147.38,121.21 147.1,121.21 141.87,115.98 141.87,110.59 141.67,110.4 141.43,110.4 141.23,110.2 141.23,109.92 141.43,109.72 141.67,109.72 141.87,109.52 141.87,108.95 131.2,98.29 131.2,98.01 131.42,97.78 131.42,97.5 131.22,97.31 130.94,97.31 130.72,97.53 130.44,97.53 130.24,97.33 130.24,97.05 131.41,95.89 131.41,95.61 131.21,95.41 130.93,95.41 129.77,96.57 129.49,96.57 129.29,96.37 129.29,96.09 130.93,94.45 130.93,94.17 130.73,93.97 130.45,93.97 128.81,95.62 128.53,95.62 128.06,95.15 128.06,94.24 128.26,94.04 129.48,94.04 129.67,93.84 129.67,93.56 129.48,93.37 128.26,93.37 128.06,93.17 128.06,91.44 128.46,91.04 129.25,91.04 129.59,90.7 DIMM1.106
M_DA41: length 66.3
  TOP w0.089: CPU.AV4 149.51,131.05 149.14,130.68 149.14,130.24 148.92,130.03 148.44,130.03 147.91,129.5 147.91,128.37 148.37,127.91 148.37,127.53 148,127.16
  TOP w0.165: 148,127.16 147.12,126.29 147.12,124.13 144.35,121.36 144.35,121.08 144.62,120.81 144.62,120.53 144.42,120.34 144.14,120.34 143.88,120.6 143.6,120.6 143.4,120.4 143.4,120.12 143.66,119.86 143.66,119.58 143.47,119.38 143.19,119.38 142.92,119.65 142.64,119.65 142.44,119.45 142.44,119.17 142.71,118.9 142.71,118.62 142.51,118.42 142.23,118.42 141.97,118.69 141.69,118.69 141.49,118.49 141.49,118.21 141.75,117.95 141.75,117.67 141.56,117.47 141.28,117.47 141.01,117.74 140.73,117.74 140.53,117.54 140.53,117.26 140.8,116.99 140.8,116.71 140.29,116.21 140.01,116.21 139.75,116.47 139.47,116.47 139.27,116.28 139.27,116 139.54,115.73 139.54,115.45 138.72,114.63 138.31,114.63 138.11,114.43 138.11,114.15 138.31,113.95 138.98,113.95 139.17,113.76 139.17,113.48 138.98,113.28 138.31,113.28 138.11,113.08 138.11,112.8 138.31,112.6 138.98,112.6 139.17,112.41 139.17,112.13 138.98,111.93 138.31,111.93 138.11,111.73 138.11,111.45 138.31,111.25 138.98,111.25 139.17,111.05 139.17,110.77 138.98,110.58 138.31,110.58 138.11,110.38 138.11,110.1 138.31,109.9 138.98,109.9 139.17,109.7 139.17,109.42 138.98,109.23 138.31,109.23 138.11,109.03 138.11,108.75 138.31,108.55 138.98,108.55 139.17,108.35 139.17,108.06 126.78,95.66 126.78,92.46 126.36,92.05 126.36,91.44 126.76,91.04 127.25,91.04 127.89,90.4 DIMM1.108
M_DA42: length 64.8
  TOP w0.089: CPU.AT1 146.61,133.08 145.86,133.08 145.29,132.51 145.29,130.3 145.07,130.08
  TOP w0.165: DIMM1.258 122.79,88.29 123.47,88.97 123.47,90.6 122.66,91.41 122.66,93.55 122.96,93.85 122.96,95.73 134.28,107.05 134.28,116.78 135.67,118.17 135.67,118.45 135.52,118.6 135.52,118.88 135.72,119.08 136,119.08 136.15,118.92 136.43,118.92 136.63,119.12 136.63,119.4 136.48,119.55 136.48,119.83 136.68,120.03 136.96,120.03 137.11,119.88 137.39,119.88 137.59,120.08 137.59,120.36 137.43,120.51 137.43,120.79 137.63,120.99 137.91,120.99 138.06,120.84 138.34,120.84 138.54,121.03 138.54,121.31 138.39,121.46 138.39,121.74 138.59,121.94 138.87,121.94 139.02,121.79 139.3,121.79 139.5,121.99 139.5,122.27 139.34,122.42 139.34,122.7 139.54,122.9 139.82,122.9 139.97,122.75 140.25,122.75 140.45,122.94 140.45,123.22 140.3,123.38 140.3,123.66 140.5,123.85 140.78,123.85 140.93,123.7 141.21,123.7 141.41,123.9 141.41,124.18 141.26,124.33 141.26,124.61 141.45,124.81 141.73,124.81 141.89,124.66 142.17,124.66 142.36,124.86 142.36,125.14 142.21,125.29 142.21,125.57 142.41,125.76 142.69,125.76 142.84,125.61 143.12,125.61 143.32,125.81 143.32,126.09 143.17,126.24 143.17,126.52 143.36,126.72 143.64,126.72 143.8,126.57 144.08,126.57 144.34,126.83 144.34,129.35 145.07,130.08
M_DA43: length 65.6
  TOP w0.089: CPU.AT2 147.11,133.8 146.35,133.8 146.26,133.71 145.7,133.71 144.78,132.79 144.78,131.63 144.15,131
  TOP w0.165: DIMM1.260 121.09,88.37 121.77,89.05 121.77,90.93 121.14,91.57 121.14,96.38 123.07,98.31 123.07,99.42 123.55,99.89 123.83,99.89 124.3,99.43 124.58,99.43 124.78,99.62 124.78,99.9 124.31,100.37 124.31,100.65 124.51,100.85 124.79,100.85 125.38,100.25 125.66,100.25 125.86,100.45 125.86,100.73 125.26,101.33 125.26,101.61 127.97,104.32 129.65,104.32 132.7,107.37 132.7,111.4 132.01,112.09 132.01,117.18 143.07,128.24 143.07,129.92 144.15,131
M_DA44: length 66
  TOP w0.089: 147.53,127.63 147.66,127.76 147.66,129.65 148.18,130.18 148.18,130.99 CPU.AV3
  TOP w0.165: 147.53,127.63 146.49,126.59 146.49,124.39 137.47,115.38 137.47,114.75 137.27,114.56 136.6,114.56 136.41,114.36 136.41,114.08 136.6,113.88 137.27,113.88 137.47,113.68 137.47,113.4 137.27,113.21 136.55,113.21 136.35,113.01 136.35,112.73 136.55,112.53 137.27,112.53 137.47,112.33 137.47,112.05 137.27,111.85 136.55,111.85 136.35,111.66 136.35,111.38 136.55,111.18 137.27,111.18 137.47,110.98 137.47,110.7 137.27,110.5 136.55,110.5 136.35,110.31 136.35,110.03 136.55,109.83 137.27,109.83 137.47,109.63 137.47,109.35 137.27,109.15 136.55,109.15 136.35,108.95 136.35,108.67 136.55,108.48 137.27,108.48 137.47,108.28 137.47,107.25 125.26,95.03 125.26,94.78 125.45,94.58 125.77,94.58 125.97,94.38 125.97,94.1 125.77,93.9 125.5,93.9 125.31,93.7 125.31,93.42 125.5,93.23 125.78,93.23 126.02,92.98 126.02,91.3 127.04,90.28 127.04,89.58 127.93,88.69 127.93,87.52 127.69,87.28 127.27,87.28 127.04,87.5 DIMM1.253
M_DA45: length 65.2
  TOP w0.089: CPU.AW4 149.51,130.23 149.05,129.78 149.05,127.25 148.48,126.68
  TOP w0.165: 148.48,126.68 147.76,125.96 147.76,122.77 147.34,122.35 147.06,122.35 146.8,122.61 146.52,122.61 146.32,122.41 146.32,122.13 146.58,121.87 146.58,121.59 146.38,121.39 146.1,121.39 145.84,121.65 145.56,121.65 145.36,121.45 145.36,121.17 145.63,120.91 145.63,120.63 140.06,115.07 140.06,114.61 140.32,114.36 140.96,114.36 141.16,114.16 141.16,113.88 140.96,113.68 140.01,113.68 139.81,113.48 139.81,113.2 140.01,113 141.03,113 141.23,112.81 141.23,112.53 141.03,112.33 140.01,112.33 139.81,112.13 139.81,111.85 140.01,111.65 140.96,111.65 141.16,111.46 141.16,111.18 140.96,110.98 140.01,110.98 139.81,110.78 139.81,110.5 140.01,110.3 140.4,110.3 140.6,110.1 140.6,109.82 140.4,109.63 140.01,109.63 139.81,109.43 139.81,109.15 140.01,108.95 140.27,108.95 140.47,108.75 140.47,108.47 140.27,108.28 140.01,108.28 139.81,108.08 139.81,107.8 127.41,95.4 127.41,92.58 127.72,92.27 127.72,91.3 128.74,90.28 128.74,89.82 129.46,89.11 129.46,87.32 129.29,87.15 128.92,87.15 128.74,87.33 DIMM1.251
M_DA46: length 68.4
  TOP w0.089: 145.54,129.61 145.58,129.64 145.58,132.44 145.96,132.82 147.2,132.82 147.34,132.67 147.96,132.67 148.07,132.79 149.07,132.79 CPU.AT4
  TOP w0.165: DIMM1.113 123.64,91.73 123.14,92.24 123.14,92.47 123.64,92.98 123.64,95.45 134.92,106.73 134.92,115.16 135.31,115.55 135.31,115.83 134.97,116.17 134.97,116.45 135.17,116.64 135.45,116.64 135.78,116.31 136.06,116.31 136.26,116.5 136.26,116.78 135.87,117.17 135.87,117.45 136.07,117.65 136.35,117.65 136.74,117.26 137.02,117.26 137.22,117.46 137.22,117.74 136.84,118.11 136.84,118.39 137.04,118.59 137.32,118.59 137.7,118.22 137.98,118.22 138.17,118.41 138.17,118.69 137.79,119.08 137.79,119.36 137.98,119.56 138.26,119.56 138.65,119.17 138.93,119.17 139.13,119.37 139.13,119.65 138.77,120.01 138.77,120.29 138.96,120.49 139.24,120.49 139.61,120.13 139.89,120.13 140.08,120.33 140.08,120.61 139.7,120.99 139.7,121.27 139.89,121.47 140.17,121.47 140.56,121.08 140.84,121.08 141.04,121.28 141.04,121.56 140.66,121.94 140.66,122.22 140.86,122.41 141.14,122.41 141.52,122.04 141.8,122.04 142,122.24 142,122.52 141.61,122.91 141.61,123.18 141.81,123.38 142.09,123.38 142.47,122.99 142.75,122.99 142.76,123 142.95,123.19 142.95,123.47 142.56,123.86 142.56,124.14 142.76,124.34 143.04,124.34 143.43,123.95 143.71,123.95 143.91,124.15 143.91,124.43 143.53,124.8 143.53,125.08 143.73,125.28 144.01,125.28 144.3,124.99 144.69,124.99 144.98,125.29 144.98,129.04 145.54,129.61
M_DA47: length 66.9
  TOP w0.089: 144.62,130.54 145.03,130.95 145.03,132.68 145.71,133.36 146.33,133.36 146.54,133.57 146.96,133.57 147.17,133.35 147.17,133.21 147.49,132.9 147.87,132.9 148.21,133.23 CPU.AT3
  TOP w0.165: DIMM1.115 121.94,95.61 127.01,100.67 127.01,100.95 126.52,101.44 126.52,101.72 126.72,101.92 127,101.92 127.49,101.43 127.77,101.43 127.97,101.63 127.97,101.91 127.38,102.5 127.38,102.78 127.57,102.98 127.85,102.98 128.44,102.39 128.72,102.39 128.92,102.58 128.92,102.86 128.58,103.2 128.58,103.48 128.78,103.68 129.06,103.68 129.4,103.34 129.68,103.34 133.65,107.31 133.65,107.88 133.33,108.2 133.33,108.56 133.65,108.87 133.65,109.23 133.33,109.55 133.33,109.91 133.65,110.22 133.65,110.58 133.33,110.9 133.33,111.26 133.65,111.58 133.65,112.01 133.45,112.2 132.84,112.2 132.65,112.4 132.65,112.68 132.84,112.88 133.45,112.88 133.65,113.08 133.65,113.45 133.45,113.64 132.84,113.64 132.65,113.84 132.65,114.12 132.84,114.32 133.45,114.32 133.65,114.52 133.65,114.8 133.45,115 132.84,115 132.65,115.19 132.65,115.47 132.84,115.67 133.45,115.67 133.65,115.87 133.65,116.15 133.45,116.35 132.84,116.35 132.65,116.55 132.65,116.83 132.84,117.02 133.45,117.02 133.65,117.22 133.65,117.92 143.71,127.98 143.71,129.63 144.62,130.54
M_DA48: length 75.7
  TOP w0.089: CPU.AP1 145.66,135.06 142.96,132.36 142.8,132.36
  TOP w0.165: DIMM1.119 118.54,92.28 119.06,92.79 119.06,93.42 118.14,94.34 118.14,96.69 118.4,96.95 118.93,96.95 119.14,97.16 119.14,97.7 119.35,97.91 119.88,97.91 120.1,98.12 120.1,98.65 120.31,98.86 120.84,98.86 121.17,99.19 121.17,100.18 120.97,100.38 120.45,100.38 120.25,100.57 120.25,100.85 120.45,101.05 120.97,101.05 121.17,101.25 121.17,101.53 120.97,101.73 120.45,101.73 120.25,101.92 120.25,102.2 120.45,102.4 120.97,102.4 121.17,102.6 121.17,102.88 120.97,103.08 120.45,103.08 120.25,103.28 120.25,103.56 120.45,103.75 120.97,103.75 121.17,103.95 121.17,104.23 120.97,104.43 120.45,104.43 120.25,104.63 120.25,104.91 120.45,105.1 120.97,105.1 121.17,105.3 121.17,105.58 120.97,105.78 120.45,105.78 120.25,105.98 120.25,106.26 120.45,106.46 120.97,106.46 121.17,106.65 121.17,106.93 120.97,107.13 120.45,107.13 120.25,107.33 120.25,107.61 120.45,107.81 120.97,107.81 121.17,108.01 121.17,108.29 120.97,108.48 120.45,108.48 120.25,108.68 120.25,108.96 120.45,109.16 120.97,109.16 121.17,109.36 121.17,109.64 120.97,109.83 120.45,109.83 120.25,110.03 120.25,110.31 120.45,110.51 120.97,110.51 121.17,110.71 121.17,110.99 120.97,111.19 120.58,111.19 120.38,111.38 120.38,111.66 120.58,111.86 120.97,111.86 121.17,112.06 121.17,112.45 121.5,112.79 121.78,112.79 121.86,112.79 122.16,113.09 122.16,113.37 122.16,113.45 122.46,113.74 122.74,113.74 122.82,113.74 123.12,114.04 123.12,114.32 123.12,114.4 123.41,114.7 123.69,114.7 123.77,114.7 124.07,115 124.07,115.28 124.07,115.36 124.59,115.87 127.08,115.87 128.28,117.07 128.56,117.07 128.74,116.89 129.02,116.89 129.21,117.09 129.21,117.37 129.04,117.55 129.04,117.83 129.23,118.03 129.51,118.03 129.69,117.85 129.97,117.85 130.17,118.05 130.17,118.33 129.99,118.5 129.99,118.78 130.19,118.98 130.47,118.98 130.65,118.8 130.93,118.8 131.12,119 131.12,119.28 130.95,119.46 130.95,119.74 131.15,119.94 131.43,119.94 131.6,119.76 131.88,119.76 132.08,119.96 132.08,120.24 131.9,120.41 131.9,120.69 132.1,120.89 132.38,120.89 132.56,120.71 132.84,120.71 133.04,120.91 133.04,121.19 132.86,121.37 132.86,121.65 141.17,129.96 141.17,130.73 142.8,132.36
M_DA49: length 79
  TOP w0.089: 142.65,134.52 143.14,134.52 145.23,136.62 145.57,136.62 145.61,136.65 146.45,136.65 146.55,136.55 147.12,136.55 147.34,136.33 148.21,136.33 148.34,136.46 149.08,136.46 CPU.AM4
  TOP w0.165: 142.65,134.52 141.73,134.52 138.96,131.75 138.96,131.08 125.82,117.94 123.72,117.94 117.39,111.62 117.39,111.26 117.2,111.06 116.97,111.06 116.77,110.86 116.77,110.58 116.97,110.39 117.2,110.39 117.39,110.19 117.39,109.91 117.2,109.71 116.82,109.71 116.62,109.51 116.62,109.23 116.82,109.03 117.2,109.03 117.39,108.84 117.39,108.56 117.2,108.36 116.82,108.36 116.62,108.16 116.62,107.88 116.82,107.68 117.2,107.68 117.39,107.49 117.39,107.21 117.2,107.01 116.82,107.01 116.62,106.81 116.62,106.53 116.82,106.33 117.2,106.33 117.39,106.13 117.39,105.85 117.2,105.66 116.82,105.66 116.62,105.46 116.62,105.18 116.82,104.98 117.2,104.98 117.39,104.78 117.39,104.5 117.2,104.31 116.82,104.31 116.62,104.11 116.62,103.83 116.82,103.63 117.2,103.63 117.39,103.43 117.39,103.15 117.2,102.95 116.82,102.95 116.62,102.76 116.62,102.48 116.82,102.28 117.2,102.28 117.39,102.08 117.39,101.8 117.2,101.6 116.82,101.6 116.62,101.4 116.62,101.12 116.82,100.93 117.2,100.93 117.39,100.73 117.39,100.45 117.2,100.25 116.82,100.25 116.62,100.05 116.62,99.77 116.82,99.58 117.2,99.58 117.39,99.38 117.39,99.01 115.9,97.51 115.9,93.44 114.46,92.01 114.46,91.26 115.17,90.55 115.17,89 114.94,88.77 114.51,88.77 114.29,88.99 DIMM1.124
M_DA50: length 77.5
  TOP w0.089: CPU.AP3 148.24,135.06 147.9,134.72 146.47,134.72 146.38,134.82 145.77,134.82 143.98,133.02 143.98,132.64 143.25,131.91
  TOP w0.165: DIMM1.262 119.97,86.9 119.97,87.21 119.56,87.62 119.56,88.21 120.41,89.06 120.41,90.59 119.34,91.67 119.34,92.35 119.87,92.89 119.87,94.01 119.67,94.21 119.18,94.21 118.98,94.4 118.98,94.68 119.18,94.88 119.67,94.88 119.87,95.08 119.87,95.36 119.67,95.56 118.98,95.56 118.78,95.75 118.78,96.03 118.98,96.23 119.67,96.23 119.87,96.43 119.87,96.91 121.8,98.84 121.8,111.79 125.22,115.21 128.25,115.21 128.44,115.4 128.72,115.4 128.89,115.24 129.17,115.24 129.36,115.44 129.36,115.72 129.2,115.88 129.2,116.16 129.4,116.36 129.68,116.36 130.12,115.91 130.4,115.91 130.6,116.11 130.6,116.39 130.15,116.84 130.15,117.12 133.92,120.89 133.92,121.17 133.74,121.34 133.74,121.62 133.94,121.82 134.22,121.82 134.4,121.64 134.68,121.64 134.88,121.84 134.88,122.12 134.7,122.3 134.7,122.58 134.9,122.77 135.18,122.77 135.35,122.6 135.63,122.6 135.83,122.8 135.83,123.08 135.66,123.25 135.66,123.53 135.85,123.73 136.13,123.73 136.31,123.55 136.59,123.55 136.79,123.75 136.79,124.03 136.61,124.21 136.61,124.49 136.81,124.69 137.09,124.69 137.27,124.51 137.55,124.51 137.74,124.71 137.74,124.99 137.57,125.16 137.57,125.44 137.76,125.64 138.04,125.64 138.22,125.47 138.5,125.47 138.7,125.66 138.7,125.94 138.52,126.12 138.52,126.4 138.72,126.6 139,126.6 139.18,126.42 139.46,126.42 139.65,126.62 139.65,126.9 139.48,127.07 139.48,127.35 139.68,127.55 139.96,127.55 140.13,127.38 140.41,127.38 140.61,127.57 140.61,127.85 140.43,128.03 140.43,128.31 140.63,128.51 140.91,128.51 141.09,128.33 141.37,128.33 141.8,128.77 141.8,130.47 143.25,131.91
M_DA51: length 76.7
  TOP w0.089: CPU.AM2 147.68,137.05 147.26,137.47 146.36,137.47 146.27,137.38 145.87,137.38 145.77,137.47 145.07,137.47 144.02,136.42 142.66,136.42
  TOP w0.165: 142.66,136.42 140.56,136.42 123.99,119.85 122.93,119.85 114.66,111.58 114.66,105.82 114.47,105.62 113.51,105.62 113.32,105.43 113.32,105.15 113.51,104.95 114.47,104.95 114.66,104.75 114.66,104.47 114.47,104.27 113.51,104.27 113.32,104.08 113.32,103.8 113.51,103.6 114.47,103.6 114.66,103.4 114.66,102.64 114.29,102.27 113.73,102.27 113.53,102.07 113.53,101.51 113.19,101.17 113.19,93.4 112.42,92.63 112.42,91.44 111.57,90.59 111.57,89.06 112.61,88.02 112.61,87.25 112.35,87 111.97,87 111.74,87.22 111.74,87.82 111.74,87.82 DIMM1.271
M_DA52: length 78.5
  TOP w0.089: 143.7,131.45 144.27,132.02 144.27,132.96 145.88,134.57 146.27,134.57 146.36,134.48 148.38,134.48 148.54,134.65 149.1,134.65 CPU.AP4
  TOP w0.165: DIMM1.117 120.24,92.45 120.51,92.71 120.51,96.65 122.44,98.58 122.44,100.96 122.63,101.15 123.89,101.15 124.09,101.35 124.09,101.63 123.89,101.83 122.63,101.83 122.44,102.03 122.44,102.31 122.63,102.51 125.26,102.51 125.46,102.7 125.46,102.98 125.26,103.18 122.63,103.18 122.44,103.38 122.44,103.66 122.63,103.86 125.9,103.86 126.09,104.05 126.09,104.33 125.9,104.53 122.63,104.53 122.44,104.73 122.44,105.01 122.63,105.21 123.89,105.21 124.09,105.41 124.09,105.69 123.89,105.88 122.63,105.88 122.44,106.08 122.44,111.53 125.48,114.58 130.72,114.58 131.25,115.11 131.25,117.32 142.44,128.5 142.44,130.19 143.7,131.45
M_DA53: length 78.3
  TOP w0.089: 142.66,135.79 143.72,135.79 145.13,137.2 145.7,137.2 145.76,137.13 146.44,137.13 146.54,137.23 146.96,137.23 147.17,137.01 147.17,136.87 147.49,136.55 147.87,136.55 148.21,136.89 CPU.AM3
  TOP w0.165: DIMM1.126 112.59,89.45 112.43,89.28 112.08,89.28 111.91,89.45 111.91,90.41 112.76,91.26 112.76,92.06 113.84,93.13 113.84,94.78 114.04,94.98 114.39,94.98 114.59,95.18 114.59,95.46 114.39,95.65 114.04,95.65 113.84,95.85 113.84,96.13 114.04,96.33 114.39,96.33 114.59,96.53 114.59,96.81 114.39,97 114.04,97 113.84,97.2 113.84,97.48 114.04,97.68 114.39,97.68 114.59,97.88 114.59,98.16 114.39,98.36 114.04,98.36 113.84,98.55 113.84,98.83 114.04,99.03 115.1,99.03 115.3,99.23 115.3,99.51 115.1,99.71 114.04,99.71 113.84,99.9 113.84,100.18 114.04,100.38 115.1,100.38 115.3,100.58 115.3,100.86 115.1,101.06 114.76,101.06 114.56,101.26 114.56,101.54 114.76,101.73 115.1,101.73 115.3,101.93 115.3,111.32 123.2,119.21 124.25,119.21 124.88,119.85 125.16,119.85 125.37,119.64 125.65,119.64 125.84,119.84 125.84,120.12 125.64,120.32 125.64,120.6 125.84,120.8 126.12,120.8 126.32,120.6 126.6,120.6 126.8,120.8 126.8,121.08 126.6,121.28 126.6,121.56 140.83,135.79 142.66,135.79
M_DA54: length 76.3
  TOP w0.089: 142.65,132.99 143.2,132.99 145.51,135.3 146.39,135.3 146.49,135.4 146.96,135.4 147.29,135.06 CPU.AP2
  TOP w0.165: 142.65,132.99 142.53,132.99 140.53,131 140.53,130.66 126.38,116.51 124.33,116.51 119.62,111.8 119.62,111.41 119.42,111.22 119.03,111.22 118.83,111.02 118.83,110.74 119.03,110.54 119.42,110.54 119.62,110.34 119.62,110.06 119.42,109.86 119.03,109.86 118.83,109.67 118.83,109.39 119.03,109.19 119.42,109.19 119.62,108.99 119.62,108.71 119.42,108.51 119,108.51 118.8,108.32 118.8,108.04 119,107.84 119.42,107.84 119.62,107.64 119.62,107.36 119.42,107.16 119,107.16 118.8,106.96 118.8,106.68 119,106.49 119.42,106.49 119.62,106.29 119.62,106.01 119.42,105.81 119,105.81 118.8,105.61 118.8,105.33 119,105.14 119.42,105.14 119.62,104.94 119.62,104.66 119.42,104.46 119.03,104.46 118.83,104.26 118.83,103.98 119.03,103.78 119.42,103.78 119.62,103.59 119.62,103.31 119.42,103.11 119.14,103.11 118.95,102.91 118.95,102.63 119.14,102.43 119.42,102.43 119.62,102.23 119.62,101.96 119.42,101.76 119.15,101.76 118.95,101.56 118.95,101.28 119.15,101.08 119.42,101.08 119.62,100.88 119.62,99.2 117.41,97 117.41,92.89 117.69,92.62 117.69,91.6 118.24,91.04 119.48,91.04 120.07,90.45 120.07,89.2 119.22,88.35 119.22,87.22 118.32,86.32 DIMM1.264
M_DA55: length 76.3
  TOP w0.089: 142.66,135.15 143.43,135.15 145.19,136.92 145.56,136.92 145.58,136.89 CPU.AM1
  TOP w0.165: DIMM1.269 113.44,90.75 114.12,91.43 114.12,92.3 114.51,92.69 114.51,92.96 115.26,93.71 115.26,97.77 115.93,98.44 115.93,111.05 123.46,118.58 125.52,118.58 127.81,120.87 127.81,121.15 127.62,121.34 127.62,121.62 127.82,121.82 128.1,121.82 128.29,121.63 128.57,121.63 128.77,121.83 128.77,122.11 128.55,122.32 128.55,122.6 128.75,122.8 129.03,122.8 129.25,122.58 129.53,122.58 129.72,122.78 129.72,123.06 129.51,123.28 129.51,123.56 129.71,123.75 129.99,123.75 130.2,123.54 130.48,123.54 130.68,123.74 130.68,124.02 130.46,124.23 130.46,124.51 130.66,124.71 130.94,124.71 131.16,124.49 131.44,124.49 131.63,124.69 131.63,124.97 131.42,125.19 131.42,125.47 131.62,125.67 131.9,125.67 132.11,125.45 132.39,125.45 132.59,125.65 132.59,125.93 132.37,126.14 132.37,126.42 132.57,126.62 132.85,126.62 133.07,126.41 133.35,126.41 133.55,126.6 133.55,126.88 133.33,127.1 133.33,127.38 133.53,127.58 133.81,127.58 134.02,127.36 134.3,127.36 134.5,127.56 134.5,127.84 134.29,128.05 134.29,128.33 134.48,128.53 134.76,128.53 134.98,128.32 135.26,128.32 135.46,128.51 135.46,128.79 135.24,129.01 135.24,129.29 135.44,129.49 135.72,129.49 135.93,129.27 136.21,129.27 136.41,129.47 136.41,129.75 136.2,129.97 136.2,130.25 136.39,130.44 136.67,130.44 136.89,130.23 137.17,130.23 137.37,130.43 137.37,130.71 137.15,130.92 137.15,131.2 137.35,131.4 137.63,131.4 137.85,131.18 138.13,131.18 138.32,131.38 138.32,132.01 141.47,135.15 142.66,135.15
M_DA56: length 86.9
  TOP w0.089: CPU.AK3 147.85,138.38 146.55,138.38 146.46,138.48 145.65,138.48 145.56,138.39 144.97,138.39 144.31,137.72 142.66,137.72
  TOP w0.165: 142.66,137.72 140.06,137.72 123.46,121.12 122.41,121.12 110.98,109.69 110.98,109.17 111.18,108.97 111.7,108.97 111.89,108.77 111.89,108.49 111.7,108.29 110.92,108.29 110.72,108.09 110.72,107.81 110.92,107.61 111.7,107.61 111.89,107.42 111.89,107.14 111.7,106.94 110.92,106.94 110.72,106.74 110.72,100.03 110.92,99.83 111.65,99.83 111.84,99.63 111.84,99.35 111.65,99.16 110.92,99.16 110.72,98.96 110.72,98.68 110.92,98.48 111.65,98.48 111.84,98.28 111.84,98 111.65,97.8 110.92,97.8 110.72,97.61 110.72,97.33 110.92,97.13 111.65,97.13 111.84,96.93 111.84,96.65 111.65,96.45 110.92,96.45 110.72,96.26 110.72,95.98 110.92,95.78 111.65,95.78 111.84,95.58 111.84,95.3 111.65,95.1 110.92,95.1 110.72,94.9 110.72,94.62 110.92,94.43 111.65,94.43 111.84,94.23 111.84,93.95 111.65,93.75 110.92,93.75 110.72,93.55 110.72,91.44 109.87,90.59 109.87,89.04 109.15,88.32 109.15,87.25 109.41,87 109.84,87 110.04,87.2 DIMM1.273
M_DA57: length 86.5
  TOP w0.089: 142.66,141.57 143.07,141.57 144.09,140.55 CPU.AH1
  TOP w0.165: 142.66,141.57 138.14,141.57 116.46,119.89 115.17,119.89 114.77,119.48 114.49,119.48 114.26,119.71 113.98,119.71 113.78,119.51 113.78,119.23 114.01,119 114.01,118.72 113.81,118.53 113.53,118.53 113.3,118.75 113.02,118.75 112.82,118.56 112.82,118.28 113.05,118.05 113.05,117.77 112.85,117.57 112.57,117.57 112.35,117.8 112.07,117.8 111.87,117.6 111.87,117.32 112.1,117.09 112.1,116.81 111.9,116.62 111.62,116.62 111.39,116.84 111.11,116.84 110.91,116.65 110.91,116.37 111.14,116.14 111.14,115.86 110.94,115.66 110.66,115.66 110.44,115.89 110.16,115.89 109.96,115.69 109.96,115.41 110.19,115.18 110.19,114.9 109.99,114.7 109.71,114.7 109.48,114.93 109.2,114.93 109,114.73 109,114.45 109.23,114.23 109.23,113.95 106.36,111.07 106.36,109.6 105.77,109.02 105.77,106.63 106.42,105.98 106.42,95.24 103.92,92.75 103.92,90.99 103.41,90.48 103.41,89.07 104.09,88.39 104.09,87.63 104.58,87.14 104.58,86.81 DIMM1.280
M_DA58: length 87.6
  TOP w0.089: 142.66,137.08 144.01,137.08 144.97,138.05 145.69,138.05 145.86,138.21 146.27,138.21 146.34,138.14 148.4,138.14 148.57,138.31 149.1,138.31 CPU.AK4
  TOP w0.165: DIMM1.128 110.89,88.81 110.73,88.65 110.4,88.65 110.21,88.83 110.21,90.45 111.06,91.3 111.06,92.26 112.54,93.74 112.54,100.44 112.15,100.83 112.15,101.11 112.54,101.51 112.54,101.88 112.38,102.05 111.57,102.05 111.36,102.26 111.36,102.54 111.56,102.74 112.76,102.74 112.96,102.93 112.96,103.21 112.76,103.41 111.56,103.41 111.36,103.61 111.36,103.89 111.56,104.09 112.36,104.09 112.56,104.28 112.56,104.56 112.36,104.76 111.66,104.76 111.46,104.96 111.46,105.24 111.66,105.44 112.36,105.44 112.56,105.64 112.56,106.16 112.75,106.36 113.83,106.36 114.03,106.56 114.03,106.84 113.83,107.04 112.75,107.04 112.56,107.23 112.56,107.51 112.75,107.71 113.83,107.71 114.03,107.91 114.03,108.19 113.83,108.39 112.75,108.39 112.56,108.59 112.56,108.87 112.75,109.06 113.83,109.06 114.03,109.26 114.03,109.54 113.83,109.74 112.75,109.74 112.56,109.94 112.56,110.37 122.67,120.48 123.73,120.48 140.32,137.08 142.66,137.08
M_DA59: length 88
  TOP w0.089: CPU.AH2 147.68,140.7 147.27,141.11 144.44,141.11 142.72,142.84 142.66,142.84
  TOP w0.165: 142.66,142.84 142.66,142.84 137.61,142.84 116.06,121.28 113.66,121.28 111.81,119.43 110.55,119.43 104.64,113.52 104.64,110 104.35,109.72 104.35,106.26 105.15,105.46 105.15,95.77 102.55,93.17 102.55,91.01 103.07,90.48 103.07,89.84 103.06,89.82 103.06,89.8 102.39,89.14 102.39,87.55 103.23,86.72 103.23,85.7 103.06,85.52 102.6,85.52 102.39,85.73 DIMM1.282
M_DA60: length 89.8
  TOP w0.089: CPU.AH4 149.08,140.12 148.21,140.12 148.08,139.99 147.34,139.99 147.12,140.21 146.55,140.21 146.45,140.31 145.57,140.31 145.49,140.22 143.79,140.22 143.2,140.81 142.66,140.81
  TOP w0.165: DIMM1.135 104.94,90.97 104.78,90.81 104.43,90.81 104.26,90.97 104.26,92.19 107.06,94.98 107.06,106.54 106.86,106.74 106.61,106.74 106.41,106.94 106.41,107.22 106.61,107.41 106.86,107.41 107.06,107.61 107.06,107.89 106.86,108.09 106.61,108.09 106.41,108.29 106.41,108.57 106.61,108.76 106.86,108.76 107.06,108.96 107.06,109.58 107.44,109.96 107.44,110.24 107.13,110.55 107.13,110.83 107.33,111.03 107.61,111.03 107.91,110.72 108.19,110.72 108.39,110.92 108.39,111.2 108.08,111.51 108.08,111.79 108.28,111.98 108.56,111.98 108.87,111.68 109.15,111.68 109.35,111.87 109.35,112.15 109.04,112.46 109.04,112.74 109.24,112.94 109.52,112.94 109.82,112.63 110.1,112.63 110.3,112.83 110.3,113.11 110,113.42 110,113.7 110.19,113.89 110.47,113.89 110.78,113.59 111.06,113.59 111.26,113.79 111.26,114.07 110.95,114.37 110.95,114.65 111.15,114.85 111.43,114.85 111.74,114.54 112.02,114.54 112.21,114.74 112.21,115.02 111.91,115.33 111.91,115.61 112.1,115.81 112.38,115.81 112.69,115.5 112.97,115.5 113.17,115.7 113.17,115.98 112.86,116.28 112.86,116.56 113.06,116.76 113.34,116.76 113.65,116.45 113.93,116.45 114.12,116.65 114.12,116.93 113.82,117.24 113.82,117.52 114.02,117.72 114.3,117.72 114.6,117.41 114.88,117.41 115.08,117.61 115.08,117.89 114.77,118.19 114.77,118.47 114.97,118.67 115.25,118.67 115.56,118.37 115.84,118.37 138.28,140.81 142.66,140.81
M_DA61: length 86
  TOP w0.089: 142.66,138.99 142.69,138.96 146.39,138.96 146.49,139.06 146.96,139.06 147.29,138.72 CPU.AK2
  TOP w0.165: 142.66,138.99 139.53,138.99 139.26,138.71 138.98,138.71 138.82,138.86 138.54,138.86 138.34,138.67 138.34,138.39 138.5,138.23 138.5,137.95 138.3,137.75 138.02,137.75 137.87,137.91 137.59,137.91 137.39,137.71 137.39,137.43 137.54,137.28 137.54,137 137.34,136.8 137.06,136.8 136.91,136.95 136.63,136.95 136.43,136.75 136.43,136.47 136.59,136.32 136.59,136.04 136.39,135.84 136.11,135.84 135.95,136 135.67,136 135.48,135.8 135.48,135.52 135.63,135.36 135.63,135.09 135.43,134.89 135.15,134.89 135,135.04 134.72,135.04 134.52,134.84 134.52,134.56 134.68,134.41 134.68,134.13 134.48,133.93 134.2,133.93 134.04,134.09 133.76,134.09 133.57,133.89 133.57,133.61 133.72,133.45 133.72,133.17 133.52,132.98 133.24,132.98 133.09,133.13 132.81,133.13 132.61,132.93 132.61,132.65 132.76,132.5 132.76,132.22 132.57,132.02 132.29,132.02 132.13,132.17 131.85,132.17 131.65,131.98 131.65,131.7 131.81,131.54 131.81,131.26 131.61,131.07 131.33,131.07 131.18,131.22 130.9,131.22 130.7,131.02 130.7,130.74 130.85,130.59 130.85,130.31 130.31,129.77 130.03,129.77 129.8,130 129.52,130 129.32,129.8 129.32,129.52 129.55,129.29 129.55,129.01 129.36,128.81 129.08,128.81 128.85,129.04 128.57,129.04 128.37,128.84 128.37,128.56 128.6,128.33 128.6,128.05 128.4,127.86 128.12,127.86 127.89,128.09 127.61,128.09 127.41,127.89 127.41,127.61 127.64,127.38 127.64,127.1 127.16,126.62 126.11,126.62 108.47,108.98 108.47,95.51 108.66,95.32 109.23,95.32 109.43,95.12 109.43,94.84 109.23,94.64 108.66,94.64 108.47,94.44 108.47,94.16 108.66,93.96 109.1,93.96 109.3,93.77 109.3,93.49 109.1,93.29 108.66,93.29 108.47,93.09 108.47,92.66 109.02,92.1 109.02,91.44 108.17,90.59 108.17,88.98 108.34,88.81 DIMM1.275
M_DA62: length 89.4
  TOP w0.089: 142.66,142.2 143,142.2 144.37,140.83 146.48,140.83 146.54,140.88 146.96,140.88 147.17,140.67 147.17,140.53 147.49,140.21 147.87,140.21 148.21,140.55 CPU.AH3
  TOP w0.165: 142.66,142.2 137.88,142.2 116.2,120.52 113.8,120.52 111.72,118.44 111.44,118.44 111.25,118.63 110.97,118.63 110.77,118.43 110.77,118.15 110.96,117.96 110.96,117.68 110.76,117.49 110.48,117.49 110.28,117.69 110,117.69 109.8,117.49 109.8,117.21 110.01,117.01 110.01,116.73 109.81,116.53 109.53,116.53 109.19,116.87 108.91,116.87 108.71,116.68 108.71,116.4 109.11,115.99 109.11,115.71 108.92,115.51 108.64,115.51 108.23,115.92 107.95,115.92 107.75,115.72 107.75,115.44 108.3,114.89 108.3,114.61 108.1,114.42 107.82,114.42 107.27,114.96 106.99,114.96 106.8,114.76 106.8,114.48 107.68,113.6 107.68,113.32 107.49,113.12 107.21,113.12 106.45,113.88 106.17,113.88 105.97,113.68 105.97,113.4 106.71,112.66 106.71,112.33 106.44,112.05 106.16,112.05 105.77,112.44 105.49,112.44 105.29,112.24 105.29,111.96 105.72,111.53 105.72,109.86 105.14,109.28 105.14,106.37 105.79,105.72 105.79,95.51 103.24,92.97 DIMM1.137
M_DA63: length 86
  TOP w0.089: CPU.AK1 144.97,138.72 144.6,138.35 142.66,138.35
  TOP w0.165: DIMM1.130 109.19,90.66 109.36,90.83 109.36,92.33 110.07,93.03 110.07,95.83 109.87,96.03 109.48,96.03 109.28,96.23 109.28,96.51 109.48,96.7 109.87,96.7 110.07,96.9 110.07,97.18 109.87,97.38 109.48,97.38 109.28,97.58 109.28,97.86 109.48,98.05 109.87,98.05 110.07,98.25 110.07,98.53 109.87,98.73 109.4,98.73 109.2,98.93 109.2,99.21 109.4,99.41 109.87,99.41 110.07,99.6 110.07,99.88 109.87,100.08 109.32,100.08 109.13,100.28 109.13,100.56 109.32,100.76 109.87,100.76 110.07,100.96 110.07,101.24 109.87,101.43 109.3,101.43 109.1,101.63 109.1,101.91 109.3,102.11 109.87,102.11 110.07,102.31 110.07,102.59 109.87,102.78 109.32,102.78 109.13,102.98 109.13,103.26 109.32,103.46 109.87,103.46 110.07,103.66 110.07,103.94 109.87,104.14 109.32,104.14 109.13,104.33 109.13,104.61 109.32,104.81 109.87,104.81 110.07,105.01 110.07,105.29 109.87,105.49 109.32,105.49 109.13,105.68 109.13,105.96 109.32,106.16 109.87,106.16 110.07,106.36 110.07,106.64 109.87,106.84 109.3,106.84 109.1,107.04 109.1,107.32 109.3,107.51 109.87,107.51 110.07,107.71 110.07,107.99 109.87,108.19 109.3,108.19 109.1,108.39 109.1,108.67 109.3,108.86 109.87,108.86 110.07,109.06 110.07,109.68 122.14,121.75 123.2,121.75 123.57,122.13 123.57,122.41 123.35,122.63 123.35,122.91 123.54,123.11 123.82,123.11 124.05,122.88 124.33,122.88 124.53,123.08 124.53,123.36 124.3,123.59 124.3,123.87 124.5,124.06 124.78,124.06 125,123.84 125.28,123.84 125.48,124.04 125.48,124.32 125.26,124.54 125.26,124.82 125.45,125.02 125.73,125.02 125.96,124.79 126.24,124.79 126.44,124.99 126.44,125.27 126.21,125.5 126.21,125.78 126.41,125.97 126.69,125.97 126.91,125.75 127.19,125.75 139.8,138.35 142.66,138.35
M_DB0: length 99.1
  TOP w0.089: v1(179.6,143.75) CPU.AD34
  L3_GND w0.089: 189.9,146.41 189.62,146.41 189.21,146 185.79,146 183.98,144.19 180.04,144.19 v1(179.6,143.75)
  L3_GND w0.14: DIMM2.3 222.24,84.29 222.43,84.47 222.43,86.6 222.92,87.1 222.92,88.21 222.43,88.7 222.43,90.55 221.58,91.4 221.58,93.09 220.83,93.84 220.83,94.4 219.93,95.29 219.93,109.73 220.12,109.92 220.37,109.92 220.56,110.11 220.56,110.38 220.37,110.57 220.12,110.57 219.93,110.76 219.93,111.03 220.12,111.22 220.42,111.22 220.61,111.41 220.61,111.68 220.42,111.87 220.12,111.87 219.93,112.06 219.93,112.33 220.12,112.52 220.42,112.52 220.61,112.71 220.61,112.98 220.42,113.17 220.12,113.17 219.93,113.36 219.93,113.63 220.12,113.82 220.42,113.82 220.61,114.01 220.61,114.28 220.42,114.47 220.12,114.47 219.93,114.66 219.93,114.93 220.12,115.12 220.42,115.12 220.61,115.31 220.61,115.58 220.42,115.77 220.12,115.77 219.93,115.96 219.93,116.23 220.12,116.42 220.42,116.42 220.61,116.61 220.61,116.88 220.42,117.07 220.12,117.07 219.93,117.26 219.93,117.97 208.17,129.73 208.17,135.09 196.86,146.41 189.9,146.41
M_DB1: length 98.1
  TOP w0.089: v1(180.51,143.75) CPU.AD35
  L3_GND w0.089: v1(180.51,143.75) 180.66,143.89 184.05,143.89 185.9,145.75 189.9,145.75
  L3_GND w0.14: DIMM2.148 221.39,79.01 222.06,79.68 222.06,81.73 221.27,82.52 221.27,84.07 222.06,84.87 222.06,87.16 221.58,87.65 221.58,88.2 222.06,88.68 222.06,90.4 221.21,91.25 221.21,92.36 220.18,93.39 220.18,94.13 219.29,95.02 219.29,117.7 216.65,120.33 216.27,120.33 216,120.6 216,120.99 207.53,129.46 207.53,134.82 196.61,145.75 189.9,145.75
M_DB2: length 97.7
  TOP w0.089: CPU.AH34 v1(179.6,140.09)
  L3_GND w0.089: v1(179.6,140.09) 180.05,140.54 180.59,140.54 180.63,140.58 182.95,140.58 183.4,141.04 185.75,141.04 186.26,141.55 189.87,141.55
  L3_GND w0.14: DIMM2.12 214.59,81.82 214.78,82 214.78,82.99 215.63,83.84 215.63,86.8 214.78,87.65 214.78,88.2 215.26,88.68 215.26,90.78 214.78,91.26 214.78,92.72 213.51,93.99 213.51,110.36 213.7,110.55 214.24,110.55 214.43,110.74 214.43,111.01 214.24,111.2 213.7,111.2 213.51,111.39 213.51,111.66 213.7,111.85 214.24,111.85 214.43,112.04 214.43,112.31 214.24,112.5 213.7,112.5 213.51,112.69 213.51,112.96 213.7,113.15 214.24,113.15 214.43,113.34 214.43,113.61 214.24,113.8 213.7,113.8 213.51,113.99 213.51,114.26 213.7,114.45 214.24,114.45 214.43,114.64 214.43,114.91 214.24,115.1 213.7,115.1 213.51,115.29 213.51,116.09 212.93,116.67 212.66,116.67 212.27,116.28 212,116.28 211.81,116.47 211.81,116.74 212.2,117.13 212.2,117.4 212.01,117.59 211.74,117.59 211.35,117.2 211.08,117.2 210.89,117.39 210.89,117.66 211.28,118.05 211.28,118.32 211.09,118.51 210.82,118.51 210.43,118.12 210.16,118.12 209.97,118.31 209.97,118.58 210.36,118.97 210.36,119.24 202.76,126.83 202.76,130.45 202.95,130.64 203.14,130.64 203.33,130.83 203.33,131.1 203.14,131.29 202.95,131.29 202.76,131.48 202.76,131.75 202.95,131.94 203.14,131.94 203.33,132.13 203.33,132.4 203.14,132.59 202.95,132.59 202.76,132.78 202.76,133.67 194.88,141.55 189.87,141.55
