# Allegro board Phoenix-A00-Layout-20161019.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SATA_LED#: length 288.9
  TOP w0.089: U4.AD44 56.7,112.67 56.55,112.52 v1(56.55,112.27)
  TOP w0.102: v1(26.45,76.96) 27.15,77.66 30.04,77.66 30.66,77.04 35.23,77.04 39.37,81.18 42.18,81.18 42.6,81.61 45.49,81.61 46.84,82.95 v1(47.73,82.95) ; RNO2.3 204.05,16.01 203.64,15.6 203.64,12.93 203.11,12.4 RIO10.1 201.51,13.3 201.51,15.07 202.55,16.11 202.55,19.59 v1(202.98,20.02) ; v1(54.97,97.41) 54.69,97.13 52.76,97.13 52.68,97.05 51.37,97.05 50.87,97.56 50.55,97.56 49.94,98.18 XDP_PCH.35
  BOTTOM w0.089: v1(56.55,112.27) 56.17,112.27 55.56,111.66 55.56,111.25
  BOTTOM w0.102: v1(26.45,76.96) 29.75,73.66 29.75,72.72 37.91,64.56 44.12,64.56 44.94,63.74 53.75,63.74 54.06,63.43 65.35,63.43 66.24,62.54 66.63,62.54 69.12,62.54 76.46,55.19 81.16,55.19 83.64,52.72 85.68,52.72 92.07,46.32 98.3,46.32 99.6,45.02 102.09,45.02 103.35,43.76 106.39,43.76 109.24,40.92 116.8,40.92 118.37,39.34 121.34,39.34 122.1,38.58 137.12,38.58 138.1,37.6 151.84,37.6 154.1,35.33 172.43,35.33 174.27,37.17 189.37,37.17 195.46,31.08 195.46,26 200.64,20.83 202.17,20.83 v1(202.98,20.02) ; v1(47.73,82.95) 47.95,82.95 48.72,83.72 48.72,85.91 49.57,86.77 53.21,86.77 54.52,88.07 54.52,89.03 53.47,90.07 53.47,91.01 53.25,91.23 53.25,94.73 54.97,96.44 v1(54.97,97.41) 54.31,98.07 54.31,99.63 54.74,100.06 54.74,100.7 54.95,100.9 54.95,101.83 55.15,102.03 55.15,105.71 55.74,106.3 55.74,110.71 v2(55.56,110.89) 55.56,111.25
SATA_RXN0: length 116.3
  TOP w0.089: v1(65.13,117.88) 65.23,117.88 65.47,118.11 U4.G35
  TOP w0.102: CSA3.1 118.56,64.54 118.25,64.54 117.98,64.81 117.98,66.5 117.86,66.61 117.62,66.61 v3(117.28,66.27)
  BOTTOM w0.089: 68.36,120.04 68.34,120.04 68.33,120.03 68.05,120.03 67,118.99 65.93,118.99 65.37,118.42 65.37,118.12 v1(65.13,117.88)
  BOTTOM w0.102: v3(117.28,66.27) 117.54,66.53 117.86,66.53 118.08,66.75 118.08,67.43 117.44,68.07 114.61,68.07 110.85,71.83 101.6,71.83 99.57,69.8 96.64,69.8 94.6,71.84 94.6,72.91 94.98,73.29 94.98,73.78 94.6,74.16 v2(94.6,76.2) 94.6,77.56 95.29,78.25 95.29,82.48 95.88,83.08 95.88,91.88 98.33,94.34 98.33,97 99.55,98.22 99.55,103.67 101.4,105.53 101.4,110.4 96.23,115.57 77.21,115.57 74.59,118.19 73.73,118.19 72.61,119.3 72.45,119.3 71.71,120.04 68.36,120.04
SATA_RXN0_C: length 8
  TOP w0.102: SATA0.5 119.97,70.41 119.86,70.31 119.86,66.36 120.83,65.4 120.83,64.66 120.6,64.43 120.16,64.43 CSA3.2
SATA_RXN1: length 135.1
  TOP w0.089: U4.D39 67.02,116.64 v1(67.09,116.57)
  TOP w0.102: CSA11.1 135.67,63.98 135.67,63.64 135.4,63.37 134.75,63.37 133.59,64.53 133.59,67.11 v3(133.36,67.35)
  BOTTOM w0.089: v1(67.09,116.57) 66.84,116.57 66.6,116.8 66.6,116.93 66.88,117.2 67.66,117.2 68.66,118.21 69.21,118.21 69.69,117.73 69.85,117.73 69.85,117.72 69.88,117.72
  BOTTOM w0.102: v3(133.36,67.35) 133.67,67.35 133.81,67.49 133.81,68.02 133.28,68.55 131.68,68.55 130.14,67.01 126.23,67.01 v2(125.86,66.63) 124.9,65.67 124.9,65.14 124.55,64.79 124.02,64.79 122.34,63.12 117.2,63.12 111.86,68.45 106.43,68.45 105.41,69.47 101.54,69.47 100.29,68.22 95.97,68.22 92.56,71.64 92.56,77.78 93.71,78.93 93.71,83.13 94.31,83.73 94.31,92.54 96.76,94.99 96.76,97.66 97.98,98.88 97.98,104.33 99.4,105.75 99.4,110.01 95.41,114 76.51,114 73.9,116.61 73.05,116.61 71.94,117.72 69.88,117.72
SATA_RXN1_C: length 7.4
  TOP w0.102: CSA11.2 135.51,65.53 135.51,65.75 136.05,66.29 136.42,66.29 138.1,67.97 138.1,70.31 138.2,70.41 SATA1.5
SATA_RXN2: length 136.2
  TOP w0.089: v1(66.23,116.22) 66.23,116.03 U4.F41
  TOP w0.102: v3(140.57,66.04) 140.23,65.7 140.23,64.18 CSA7.1
  BOTTOM w0.089: v1(66.23,116.22) 66.37,116.07 68.18,116.07 68.49,115.76 69.85,115.76 69.85,115.77 69.88,115.77
  BOTTOM w0.102: 69.88,115.77 70.04,115.77 70.11,115.7 72.3,115.7 72.6,115.39 73.45,115.39 76.01,112.83 94.81,112.83 98.23,109.41 98.23,106.23 96.76,104.76 96.76,101.77 95.03,100.04 95.03,95.12 92.62,92.7 92.62,91.44 93.14,90.92 93.14,84.33 90.53,81.72 90.53,72 95.48,67.06 100.96,67.06 101.03,66.98 102.83,66.98 103.31,67.46 105.63,67.46 107.13,65.96 112.68,65.96 116.7,61.95 123.95,61.95 v2(126.85,64.85) 127.76,65.76 133.71,65.76 134.83,66.88 139.91,66.88 140.32,66.47 140.32,66.29 v3(140.57,66.04)
SATA_RXN2_C: length 5
  TOP w0.102: CSA7.2 140.23,62.48 140.23,62.03 139.29,61.09 138.94,61.09 138.1,60.25 138.1,59.91 138.2,59.81 SATA2.5
SATA_RXN3: length 60.3
  TOP w0.089: v1(65.98,114.62) 66.15,114.44 66.51,114.44 U4.D43
  TOP w0.102: CM3.2 104.47,120.84 104.73,120.57 104.73,117.07 102.34,114.68 102.34,109.42 99.14,106.22 96.58,106.22 95.99,106.81 95.54,106.81 v3(95.14,107.2)
  BOTTOM w0.089: 69.88,112.81 69.85,112.81 69.85,112.8 69.71,112.8 69.54,112.97 69.54,113.2 68.57,114.17 65.76,114.17 65.49,114.43 65.49,114.81 65.64,114.96 65.79,114.96 65.98,114.77 v1(65.98,114.62)
  BOTTOM w0.102: v3(95.14,107.2) 95.14,106.92 95,106.78 94.6,106.78 93.96,107.42 93.96,109.75 93.05,110.67 81.04,110.67 79.54,109.17 79.02,109.17 78.63,109.55 78.15,109.55 77.39,108.79 76.82,108.79 v2(76.44,109.17) 75.37,109.17 72.31,112.23 70.94,112.23 70.36,112.81 69.88,112.81
SATA_RXP0: length 116.3
  TOP w0.089: U4.E35 65.98,118.14 v1(65.98,117.78)
  TOP w0.102: v3(117.28,67.16) 117.63,66.81 117.95,66.81 118.18,66.58 118.18,64.89 118.33,64.74 118.56,64.74 CSA4.1
  BOTTOM w0.089: 68.36,119.84 68.34,119.84 68.33,119.84 68.13,119.84 67.08,118.8 66.01,118.8 65.56,118.35 65.56,117.79 65.71,117.64 65.84,117.64 v1(65.98,117.78)
  BOTTOM w0.102: v3(117.28,67.16) 117.14,67.02 117.14,66.87 117.28,66.73 117.78,66.73 117.88,66.83 117.88,67.35 117.36,67.87 114.53,67.87 110.77,71.63 101.68,71.63 99.65,69.6 96.55,69.6 94.39,71.75 v2(94.39,73.53) 94.39,75.58 94.01,75.96 94.01,76.44 94.39,76.82 94.39,77.65 95.08,78.34 95.08,82.57 95.68,83.16 95.68,91.97 98.13,94.42 98.13,97.09 99.35,98.31 99.35,103.76 101.2,105.61 101.2,110.31 96.15,115.37 77.12,115.37 74.51,117.98 73.64,117.98 72.52,119.1 72.36,119.1 71.63,119.84 68.36,119.84
SATA_RXP0_C: length 8
  TOP w0.102: SATA0.6 119.56,70.41 119.66,70.31 119.66,66.28 120.62,65.32 120.62,64.75 120.52,64.64 120,64.64 119.86,64.78 CSA4.2
SATA_RXP1: length 135.1
  TOP w0.089: v1(66.03,116.95) 66.03,117.11 66.3,117.37 U4.E37
  TOP w0.102: CSA12.1 135.36,64.23 135.47,64.13 135.47,63.73 135.31,63.58 134.83,63.58 133.79,64.61 133.79,67.21 133.94,67.35 v3(134.25,67.35)
  BOTTOM w0.089: 69.88,117.93 69.85,117.93 69.85,117.92 69.77,117.92 69.29,118.4 68.58,118.4 67.58,117.39 66.8,117.39 66.36,116.95 v1(66.03,116.95)
  BOTTOM w0.102: v3(134.25,67.35) 134.01,67.58 134.01,68.1 133.36,68.75 131.6,68.75 130.06,67.21 126.11,67.21 126.1,67.22 125.62,67.22 125.27,66.88 125.27,66.34 v2(124.31,65.38) 122.26,63.32 117.28,63.32 111.95,68.66 106.51,68.66 105.49,69.67 101.46,69.67 100.21,68.43 96.06,68.43 92.76,71.72 92.76,77.69 93.91,78.84 93.91,83.05 94.51,83.65 94.51,92.45 96.96,94.9 96.96,97.57 98.18,98.79 98.18,104.24 99.6,105.67 99.6,110.09 95.49,114.2 76.6,114.2 73.98,116.81 73.13,116.81 72.02,117.93 69.88,117.93
SATA_RXP1_C: length 7.4
  TOP w0.102: CSA12.2 135.31,65.52 135.31,65.84 135.97,66.5 136.34,66.5 137.89,68.06 137.89,70.31 137.79,70.41 SATA1.6
SATA_RXP2: length 136.2
  TOP w0.089: v1(66.92,115.64) 66.73,115.82 66.54,115.82 U4.E41
  TOP w0.102: CSA8.1 140.03,64.18 140.03,65.7 v3(139.68,66.04)
  BOTTOM w0.089: 69.88,115.56 69.85,115.56 69.85,115.57 68.41,115.57 68.1,115.88 67.02,115.88 66.94,115.79 66.94,115.66 v1(66.92,115.64)
  BOTTOM w0.102: 69.88,115.56 69.96,115.56 70.03,115.49 72.21,115.49 72.52,115.19 73.36,115.19 75.93,112.62 94.72,112.62 98.03,109.32 98.03,106.32 96.56,104.85 96.56,101.86 94.83,100.13 94.83,95.2 92.41,92.79 92.41,91.36 92.93,90.83 92.93,84.41 90.33,81.81 90.33,71.92 95.4,66.85 100.87,66.85 100.95,66.78 102.91,66.78 103.39,67.26 105.55,67.26 107.04,65.76 112.6,65.76 116.61,61.75 124.04,61.75 125.23,62.94 v2(125.81,62.94) 125.81,63.53 126.56,64.27 127.1,64.27 127.44,64.61 127.44,65.15 127.85,65.56 133.79,65.56 134.91,66.68 139.82,66.68 140.12,66.38 140.12,66.18 139.98,66.04 v3(139.68,66.04)
SATA_RXP2_C: length 5
  TOP w0.102: SATA2.6 137.79,59.81 137.89,59.91 137.89,60.33 138.86,61.3 139.21,61.3 140.03,62.11 140.03,62.48 CSA8.2
SATA_RXP3: length 60.3
  TOP w0.089: v1(66.11,115.25) 66.43,115.25 66.53,115.15 66.53,114.96 U4.E42
  TOP w0.102: CM4.2 104.94,120.59 104.94,116.98 102.55,114.59 102.55,109.34 99.23,106.02 96.49,106.02 95.91,106.6 95.43,106.6 v3(95.14,106.31)
  BOTTOM w0.089: 69.88,112.6 69.85,112.6 69.85,112.61 69.63,112.61 69.35,112.9 69.35,113.12 68.5,113.97 65.68,113.97 65.3,114.35 65.3,114.89 65.56,115.15 66.01,115.15 v1(66.11,115.25)
  BOTTOM w0.102: v3(95.14,106.31) 94.88,106.58 94.52,106.58 93.76,107.33 93.76,109.67 92.96,110.46 81.12,110.46 79.62,108.97 v2(78.39,108.97) 77.85,108.97 77.47,108.59 76.19,108.59 75.81,108.97 75.28,108.97 72.22,112.03 70.85,112.03 70.27,112.6 69.88,112.6
SATA_TXN0: length 118.8
  TOP w0.089: v3(69.57,119.04) 69.76,119.04 69.91,118.9 69.91,118.63 69.79,118.52 69.04,118.52 68.88,118.35 67.64,118.35 67.41,118.12 U4.C36
  TOP w0.102: CSA2.1 122.47,64.72 122.33,64.72 122.03,65.02 122.03,66.6 121.81,66.82 121.5,66.82 v3(121.16,67.16)
  BOTTOM w0.102: v3(69.57,119.04) 69.71,119.04 69.84,118.91 69.84,118.64 70.12,118.36 72.27,118.36 73.34,117.3 74.2,117.3 76.82,114.68 95.82,114.68 100.52,109.98 100.52,105.9 98.66,104.04 98.66,98.59 97.44,97.37 97.44,94.7 94.99,92.25 94.99,83.45 94.4,82.85 94.4,78.64 93.24,77.49 93.24,71.93 96.27,68.91 99.94,68.91 101.18,70.15 105.78,70.15 106.04,70.41 110.9,70.41 114.22,67.09 114.9,67.09 v2(115.28,66.71) 116.29,65.7 116.29,65.16 116.63,64.82 120.92,64.82 121.97,65.87 121.97,66.59 121.65,66.91 121.41,66.91 v3(121.16,67.16)
SATA_TXN0_C: length 8.2
  TOP w0.102: CSA2.2 123.79,64.72 123.9,64.62 124.5,64.62 124.6,64.72 124.6,65.77 123.47,66.9 123.47,70.31 123.37,70.41 SATA0.3
SATA_TXN1: length 136.6
  TOP w0.089: v3(70.14,116.72) 70.14,116.92 70.26,117.04 70.57,117.04 70.77,116.84 70.77,116.53 70.5,116.26 69.93,116.26 69.12,117.07 U4.B38
  TOP w0.102: v3(132.71,66.73) 132.47,66.73 132.19,66.45 132.19,65.07 134.53,62.74 136.67,62.74 137.55,63.62 137.55,64.01 137.33,64.23 CSA10.1
  BOTTOM w0.102: v3(70.14,116.72) 70.33,116.72 70.46,116.85 70.46,117.06 70.8,117.4 71.57,117.4 72.89,116.08 73.73,116.08 76.3,113.51 95.21,113.51 98.92,109.8 98.92,105.95 97.47,104.51 97.47,99.08 96.25,97.86 96.25,95.35 93.33,92.42 93.33,91.74 93.82,91.25 93.82,83.93 92.84,82.95 92.84,78.77 92.06,77.98 92.06,71.45 95.77,67.74 100.57,67.74 101.81,68.99 105.16,68.99 106.81,67.34 107.87,67.34 108.25,67.72 108.73,67.72 109.11,67.34 v2(111.03,67.34) 112.28,67.34 116.98,62.64 123.09,62.64 126.97,66.52 130.35,66.52 131.34,67.52 132.1,67.52 132.45,67.16 132.45,66.99 v3(132.71,66.73)
SATA_TXN1_C: length 9.3
  TOP w0.102: CSA10.2 137.35,65.52 137.35,66.02 138.46,67.13 140.78,67.13 141.7,68.06 141.7,70.31 141.6,70.41 SATA1.3
SATA_TXN2: length 139
  TOP w0.089: U4.B39 67.78,116.52 67.99,116.31 68.93,116.31 69.73,115.51 70.16,115.51 70.16,115.5 70.19,115.5
  TOP w0.102: CSA6.1 141.85,63.77 142.2,64.12 142.2,64.4 142.87,65.07 142.87,65.49 142.72,65.64 142.43,65.64 142.27,65.47 v3(142.27,65.28) ; 70.19,115.5 70.81,115.5 71.18,115.13 71.18,113.76 71.63,113.31 72.41,113.31 72.98,113.89 v3(72.98,113.89)
  BOTTOM w0.102: v3(72.98,113.89) 72.78,113.89 72.65,114.02 72.65,114.33 72.75,114.43 73.15,114.43 75.64,111.94 94.06,111.94 97.33,108.67 97.33,106.6 95.87,105.14 95.87,102.16 94.14,100.43 94.14,95.51 90.43,91.8 90.43,86.72 89.7,85.99 89.7,85.51 90.08,85.13 v2(90.08,83.08) 90.08,82.54 89.64,82.11 89.64,71.63 95.11,66.17 100.46,66.17 100.53,66.09 103.24,66.09 103.72,66.57 105.24,66.57 106.74,65.07 112.29,65.07 116.31,61.06 125.33,61.06 129.07,64.8 140.89,64.8 141.82,65.73 142.14,65.73 142.27,65.6 v3(142.27,65.28)
SATA_TXN2_C: length 4.1
  TOP w0.102: CSA6.2 142.07,62.47 142.07,61.26 141.7,60.9 141.7,59.91 141.6,59.81 SATA2.3
SATA_TXN3: length 51.9
  TOP w0.089: v3(69.82,114.12) 69.82,114.33 69.69,114.47 69.35,114.47 69.12,114.69 69.12,115.3 68.77,115.66 68.28,115.66 U4.A41
  TOP w0.102: CM2.2 102.9,120.59 102.9,119.76 103.06,119.6 103.06,116.1 101.85,114.89 101.85,109.69 100.09,107.93 96.57,107.93 v3(96.25,107.61)
  BOTTOM w0.089: v3(69.82,114.12) 69.82,114.36 69.88,114.41
  BOTTOM w0.102: 69.88,114.41 69.93,114.46 70.13,114.46 71.69,112.9 72.34,112.9 74.37,110.87 75.81,110.87 76.19,110.49 76.68,110.49 77.06,110.87 v2(78.34,110.87) 80.47,110.87 80.86,111.25 93.3,111.25 94.57,109.98 94.57,108.99 95.61,107.95 95.91,107.95 v3(96.25,107.61)
SATA_TXP0: length 118.7
  TOP w0.089: v3(70.56,119.04) 70.5,119.1 70.21,119.1 70.1,118.99 70.1,118.55 69.87,118.33 69.12,118.33 68.96,118.16 67.87,118.16 U4.B36
  TOP w0.102: CSA1.1 122.53,64.51 122.25,64.51 121.82,64.94 121.82,66.51 121.72,66.61 121.51,66.61 v3(121.16,66.27)
  BOTTOM w0.102: v3(70.56,119.04) 70.3,119.3 70.14,119.3 70.04,119.2 70.04,118.73 70.2,118.57 72.36,118.57 73.43,117.5 74.29,117.5 76.9,114.88 95.9,114.88 100.72,110.07 100.72,105.81 98.86,103.96 98.86,98.51 97.65,97.29 97.65,94.62 95.19,92.17 95.19,83.36 94.6,82.77 94.6,78.56 93.45,77.4 93.45,72.02 96.35,69.11 99.86,69.11 101.1,70.36 105.7,70.36 105.95,70.61 110.98,70.61 114.3,67.29 115.52,67.29 115.87,66.95 115.87,66.41 v2(116.87,65.41) 117.25,65.03 120.84,65.03 121.77,65.95 121.77,66.51 121.57,66.7 121.24,66.7 121.06,66.51 121.06,66.37 v3(121.16,66.27)
SATA_TXP0_C: length 8.2
  TOP w0.102: SATA0.2 123.78,70.41 123.68,70.31 123.68,66.98 124.81,65.85 124.81,64.63 124.58,64.41 124.07,64.41 CSA1.2
SATA_TXP1: length 136.6
  TOP w0.089: v3(71.24,116.72) 70.58,116.07 69.85,116.07 69.04,116.88 67.97,116.88 67.9,116.81 67.55,116.81 67.29,117.07 U4.C38
  TOP w0.102: v3(131.82,66.73) 131.99,66.57 131.99,64.99 134.44,62.53 136.75,62.53 137.75,63.54 137.75,64.03 CSA9.1
  BOTTOM w0.102: v3(131.82,66.73) 131.96,66.6 132.1,66.6 132.25,66.75 132.25,67.08 132.01,67.31 131.42,67.31 130.43,66.32 127.06,66.32 123.17,62.43 116.9,62.43 112.2,67.13 111.65,67.13 111.27,66.75 110.79,66.75 110.41,67.13 v2(108.49,67.13) 106.73,67.13 105.08,68.78 101.9,68.78 100.65,67.54 95.68,67.54 91.86,71.37 91.86,78.06 92.64,78.85 92.64,83.04 93.62,84.01 93.62,91.17 93.12,91.66 93.12,92.51 96.05,95.43 96.05,97.95 97.27,99.17 97.27,104.59 98.71,106.03 98.71,109.72 95.12,113.31 76.21,113.31 73.65,115.87 72.81,115.87 71.49,117.2 70.88,117.2 70.67,116.98 70.67,116.84 70.78,116.72 v3(71.24,116.72)
SATA_TXP1_C: length 9.3
  TOP w0.102: SATA1.2 142.01,70.41 141.91,70.31 141.91,67.97 140.86,66.93 138.55,66.93 137.55,65.93 137.55,65.52 CSA9.2
SATA_TXP2: length 139.1
  TOP w0.089: U4.A39 68.19,116.5 69.01,116.5 69.81,115.7 70.16,115.7 70.16,115.7 70.19,115.7
  TOP w0.102: 70.19,115.7 70.89,115.7 71.38,115.21 71.38,113.84 71.71,113.51 72.32,113.51 72.52,113.72 72.52,114.22 72.4,114.35 72.19,114.35 v3(71.99,114.15) ; CSA5.1 142.4,64.04 142.4,64.31 143.08,64.99 143.08,65.57 142.81,65.84 142.59,65.84 v3(142.27,66.17)
  BOTTOM w0.102: v3(142.27,66.17) 142.03,65.93 141.73,65.93 140.8,65 128.98,65 125.25,61.26 116.39,61.26 112.38,65.28 106.82,65.28 105.33,66.78 103.64,66.78 103.16,66.29 100.62,66.29 100.54,66.37 95.19,66.37 89.85,71.71 89.85,82.02 90.67,82.84 90.67,83.33 90.28,83.71 v2(90.28,85.75) 90.28,86.29 90.63,86.64 90.63,91.72 94.34,95.43 94.34,100.35 96.07,102.07 96.07,105.05 97.53,106.51 97.53,108.76 94.15,112.14 75.73,112.14 73.24,114.63 72.67,114.63 72.45,114.41 72.45,114.17 72.32,114.05 72.09,114.05 v3(71.99,114.15)
SATA_TXP2_C: length 4.1
  TOP w0.102: CSA5.2 142.27,62.49 142.27,61.18 141.91,60.81 141.91,59.91 142.01,59.81 SATA2.2
SATA_TXP3: length 51.9
  TOP w0.089: v3(69.82,115) 69.82,114.75 69.73,114.66 69.43,114.66 69.31,114.77 69.31,115.38 68.84,115.85 68.28,115.85 U4.A40
  TOP w0.102: v3(96.25,108.5) 96.62,108.14 100.01,108.14 101.65,109.77 101.65,114.97 102.86,116.19 102.86,119.52 102.7,119.68 102.7,120.62 102.48,120.84 CM1.2
  BOTTOM w0.089: v3(69.82,115) 69.82,114.79 69.88,114.74
  BOTTOM w0.102: 69.88,114.74 69.95,114.66 70.22,114.66 71.78,113.1 72.43,113.1 74.46,111.07 v2(76.44,111.07) 77.72,111.07 78.1,111.46 78.58,111.46 78.96,111.07 80.39,111.07 80.77,111.46 93.39,111.46 94.78,110.07 94.78,109.08 95.7,108.16 95.91,108.16 v3(96.25,108.5)
SATAGP0: length 47
  TOP w0.089: v1(55.02,118.11) 55.24,118.11 U4.AG36
  TOP w0.102: RS13.1 56,89.43 49.51,89.43 49,89.94 49,90.96 v1(49.02,90.98) ; v1(51.61,110.6) 50.83,109.82 R90.2 51.34,109.16 51.34,105.35 R85.2
  BOTTOM w0.089: v1(55.02,118.11) 54.77,118.11 54.2,117.54 54.2,115.94 53.68,115.43 53.43,115.43 51.6,113.59 51.6,111.25
  BOTTOM w0.102: v1(49.02,90.98) 49.02,91.35 48.55,91.82 48.55,93.42 49.99,94.87 49.99,97.9 50.78,98.69 50.78,102.11 51.26,102.59 51.26,110.04 51.61,110.39 v1(51.61,110.6) 51.6,110.62 51.6,111.25
SATAGP0_R: length 4.8
  TOP w0.102: v1(58.2,89.74) 58.2,89.98 RS13.2 57.94,92.26 XDP_PCH.4
SATAGP1: length 39.3
  TOP w0.089: U4.AG35 55.24,118.87 v1(55.02,118.87)
  TOP w0.102: R91.2 50.17,102.32 v1(50.17,103) 50.17,104.85 50.83,105.51 R98.2 ; v1(49.54,97.76) 50.4,96.9 51.2,96.9 51.28,96.82 52.78,96.82 52.85,96.9 55.1,96.9 56.44,98.24 XDP_PCH.9
  BOTTOM w0.089: 51.14,111.25 51.14,111.61 51.37,111.83 51.37,113.68 52.13,114.44 52.13,117.6 52.45,117.91 52.45,118.2 53.22,118.97 54.92,118.97 v1(55.02,118.87)
  BOTTOM w0.102: 51.14,111.25 51.14,110.24 50.96,110.06 50.96,108.71 50.3,108.05 v2(50.3,105.78) 50.3,104.79 50.17,104.66 v1(50.17,103) 49.82,102.64 49.82,98.04 v1(49.54,97.76)
SATAGP2: length 36.4
  TOP w0.089: U4.AG39 55.24,116.59 v1(55.02,116.59) ; v1(52.61,112.14) 52.1,111.63 52.1,111.25
  TOP w0.102: v1(51.8,97.79) 52.03,98.02 53.09,98.02 53.75,97.36 54.31,97.36 54.85,97.9 55.65,97.9 55.94,98.2 XDP_PCH.11 ; R99.2 52.48,105.35 52.48,109.16 R101.2 52.1,109.79 52.1,111.25
  BOTTOM w0.089: 52.28,111.25 52.28,111.81 v1(52.61,112.14) ; v1(55.02,116.59) 54.59,116.15 54.59,115.8 53.84,115.05 53.59,115.05 52.05,113.51 52.05,112.7 52.1,112.65
  BOTTOM w0.102: v1(51.8,97.79) 51.8,99.03 52.28,99.52 52.28,102.44 52.41,102.57 52.41,103.84 v2(52.11,104.13) 52.5,104.52 52.5,105.63 51.82,106.31 51.82,107.04 52.5,107.72 52.5,109.46 52.28,109.68 52.28,111.25 ; 52.1,112.65 v1(52.61,112.14)
SATAGP3: length 36
  TOP w0.089: U4.AD35 56.34,118.87 v1(56.17,118.87)
  TOP w0.102: v1(50.58,111.05) 49.56,110.03 R103.2 50.04,109.19 50.04,105.96 v1(49.56,105.49) 49.31,105.23 R100.2 ; v1(49.06,95.4) 49.26,95.2 51.39,95.2 51.94,94.65 XDP_PCH.28
  BOTTOM w0.089: 50.58,111.25 50.58,111.36 51.14,111.92 51.14,114.27 v2(51.49,114.62) 51.27,114.83 51.27,115.98 51.49,116.2 51.49,117.23 52.26,117.99 52.26,118.28 53.14,119.16 54.48,119.16 54.74,119.43 55.48,119.43 56.04,118.87 v1(56.17,118.87)
  BOTTOM w0.102: v1(50.58,111.05) 50.58,111.25 ; v1(49.06,95.4) 49.13,95.48 49.13,97.6 48.29,98.44 48.29,98.75 48.07,98.98 48.07,100.73 48.57,101.23 48.57,104.28 49.08,104.79 49.08,105 v1(49.56,105.49)
SATAGP4: length 40.3
  TOP w0.089: v1(56.12,120.27) 56.5,120.65 U4.AD31
  TOP w0.102: XDP_PCH.30 51.44,94.64 51.11,94.97 48.7,94.97 v1(48.34,95.33) ; R108.2 49.55,106.24 v1(48.85,105.54) 48.29,104.98 RP26.1 48.8,104.2 48.8,102.81 R104.2
  BOTTOM w0.089: v1(56.12,120.27) 55.71,119.86 54.72,119.86 54.21,119.35 53.06,119.35 52.06,118.36 52.06,118.07 51.3,117.31 51.3,116.27 50.91,115.88 50.91,112.09 50.07,111.25
  BOTTOM w0.102: v1(48.34,95.33) 48.9,95.88 48.9,97.5 48.06,98.34 48.06,98.66 47.63,99.09 47.63,100.62 48.34,101.33 48.34,104.37 48.85,104.88 v1(48.85,105.54) 50.07,106.76 50.07,109.94 v2(50.21,110.08) 50.05,110.24 50.05,111.23 50.07,111.25
SATAGP5: length 38.1
  TOP w0.089: v1(56.17,117.47) 56.6,117.05 U4.AD38
  TOP w0.102: R109.2 v1(51.98,105.54) 51.47,105.03 51.47,102.17 R105.2 ; v1(51.47,90.09) 51.23,90.09 RS14.1
  BOTTOM w0.089: 51.98,111.25 51.82,111.4 51.82,113.55 53.51,115.24 53.76,115.24 54.39,115.86 54.39,116.54 54.85,117 55.18,117 55.66,117.47 v1(56.17,117.47)
  BOTTOM w0.102: v1(51.47,90.09) 51.29,90.09 50.58,90.81 50.58,94.39 50.22,94.74 50.22,97.8 50.88,98.46 50.88,98.46 51.01,98.59 51.01,102.01 51.49,102.5 51.49,105.05 v1(51.98,105.54) 51.49,106.02 51.49,108.46 v2(51.86,108.83) 52.05,109.02 52.05,111.18 51.98,111.25
SATAGP5_R: length 3.2
  TOP w0.102: XDP_PCH.34 50.44,92.27 50.83,91.87 RS14.2 50.99,91.38 v1(51.46,90.91)
SATAGP6: length 33.2
  TOP w0.089: U4.AC43 57.21,114.61 57.45,114.37 57.45,113.9 57.99,113.36 57.99,112.31 56.93,111.25
  TOP w0.102: RS17.1 49.56,89.79 49.69,89.66 53.48,89.66 v1(54.1,90.29) ; v1(56.29,100.97) 56.68,101.35 56.68,104.46 R6604.2 56.68,105.47 56.68,109.28 R6603.2 56.17,110.49 56.93,111.25
  BOTTOM w0.102: v1(56.29,100.97) 55.84,100.51 55.84,91.24 54.89,90.29 v1(54.1,90.29)
SATAGP6_R: length 2.4
  TOP w0.102: XDP_PCH.36 v1(49.94,92.07) 49.94,91.75 RS17.2
SATAGP7: length 25.7
  TOP w0.089: 57.44,111.25 58.22,112.04 58.22,112.67 58.18,112.72 58.18,113.44 57.7,113.92 U4.AB44
  TOP w0.102: v1(56.9,95.55) 57.44,95.02 XDP_PCH.6 ; R6606.2 56.93,105.47 56.93,106.62 57.44,107.12 R6605.2 v1(57.44,108.33) 57.44,111.25
  BOTTOM w0.102: v1(56.9,95.55) 57.18,95.83 57.18,96.42 56.98,96.62 56.98,100.27 57.28,100.57 57.28,101.67 56.85,102.1 56.85,106.83 v2(57.44,107.41) v1(57.44,108.33)
SD4_WAKE: length 24.2
  TOP w0.089: U4.AE44 56.28,113.96 56.28,113.84 56.32,113.79 56.32,113.06 55.85,112.59 55.85,112.36 54.74,111.25
  TOP w0.102: XDP_PCH.33 50.44,98.06 50.71,97.79 50.96,97.79 51.47,97.28 52.59,97.28 v1(52.89,97.59) ; 54.74,111.25 54.06,110.57 54.06,110.44 v1(54.01,110.39) 54.26,110.13 RP25.1
  BOTTOM w0.102: v1(54.01,110.39) 54.91,109.48 54.91,107.76 54.35,107.2 54.35,104.61 v2(54.26,104.52) 54.69,104.09 54.69,102.22 54.49,102.02 54.49,101.09 54.29,100.89 54.29,100.25 52.89,98.86 v1(52.89,97.59)
SER_IRQ: length 287.1
  TOP w0.089: v1(48.85,126.82) 48.85,126.93 U4.BA17
  TOP w0.102: v1(122.21,47.75) 122.08,47.75 121.19,48.64 119.01,48.64 116.21,51.44 95.54,51.44 94.78,50.67 88.37,50.67 84.84,54.2 84.84,56.85 78.09,63.61 78.09,71.17 v1(77.88,71.37) ; v1(209.2,37.59) 209.23,37.59 210.02,38.38 210.02,38.68 209.8,38.89 SIO_5553.127 ; v1(31.15,126.11) 30.58,126.11 R6586.2
  BOTTOM w0.089: 43.23,126.44 43.71,126.44 44.51,127.24 48.43,127.24 v1(48.85,126.82)
  BOTTOM w0.102: v1(122.21,47.75) 122.59,48.13 135,48.13 135.59,48.72 152.85,48.72 156.25,45.33 164.74,45.33 165.74,46.33 172.36,46.33 174.75,48.72 188.63,48.72 200.65,36.7 205.9,36.7 206.27,37.07 v2(206.31,37.07) 208.68,37.07 v1(209.2,37.59) ; 43.23,126.44 38.26,126.44 38.01,126.19 35.29,126.19 34.04,127.43 32.47,127.43 v1(31.15,126.11) 28.86,123.83 28.86,115.54 27.36,114.05 26.85,114.05 24.16,111.35 24.16,109.28 28.62,104.83 39.09,104.83 40.17,103.76 41.37,103.76 43.34,101.78 43.34,90.22 42.68,89.56 42.68,82.08 45.03,79.73 45.03,76.15 46.79,74.39 46.79,73.97 49.15,71.62 52.9,71.62 55.75,74.47 59.98,74.47 60.61,73.84 62.11,73.84 62.59,73.36 62.59,72.56 63.08,72.07 65.62,72.07 66.07,72.52 68.14,72.52 68.52,72.14 77.12,72.14 v1(77.88,71.37)
SER_SENCE#: length 44.7
  TOP w0.089: U4.L44 63.52,113.59 v1(64.63,112.48)
  TOP w0.102: v1(56.4,84.25) 56.4,84.21 56.29,84.11 55.5,84.11 R663.2 50.04,83.31 WF_BT_USB.10
  BOTTOM w0.089: 65.86,111.25 v1(64.63,112.48)
  BOTTOM w0.102: 65.86,111.25 67.22,109.89 67.22,107.64 67.85,107 67.85,103.92 66.24,102.31 64.36,102.31 63.79,101.73 v2(63.79,100.46) 63.28,99.95 63.28,93.56 57.63,87.9 57.63,86.83 56.4,85.6 v1(56.4,84.25)
SERIRQ: length 10.1
  TOP w0.102: RK36.2 55.86,208.34 55.86,207.42 56.4,206.88 v1(56.4,206.11) 56.65,205.86 56.65,202.79 57.15,202.29 57.97,202.29 58.8,201.46 BRIDGE.N8
  BOTTOM w0.102: v1(56.4,206.11) v2(57,206.7)
SERVICE_MODE_1: length 6.4
  TOP w0.102: RS161.2 147.75,45.06 144.41,45.06 P3.1
SIO_24M_CLOCKI: length 69.4
  TOP w0.102: R6393.1 31.67,127.3 23.17,127.3 22.48,127.99 18.4,127.99 16.9,126.49 v1(15.91,126.49) ; RB11.1 14.91,157.1 17.76,159.94 23.73,159.94 27.19,156.49 27.19,155.48 27.27,155.39 27.27,152.76 v1(26.78,152.27)
  BOTTOM w0.102: v1(26.78,152.27) 26.19,152.27 22.64,148.72 v2(22.64,146.81) 22.64,146.4 19.73,143.5 19.73,142.77 14.36,137.4 14.36,127.66 15.53,126.49 v1(15.91,126.49)
SIO_24M_CLOCKI_LPC: length 45.2
  TOP w0.102: UF3.1 24.2,146.46 23.56,145.82 22.91,145.82 22.26,145.16 22.26,144.35 21.83,143.92 v1(21.27,143.92) ; v1(15.91,125.86) 16.95,125.86 18.6,127.51 22.28,127.51 23.32,126.47 25.27,126.47 RF177.2 26.23,126.47 27.43,126.47 RF76.2 28.75,126.82 31.45,126.82 31.85,126.43 R6615.1
  BOTTOM w0.102: v1(21.27,143.92) 21.09,143.74 21.09,143.23 v2(19.7,141.84) 19.57,141.84 14.89,137.16 14.89,128.17 16.37,126.7 16.37,126.31 v1(15.91,125.86)
SIO_24M_PCICLK: length 292
  TOP w0.102: v1(216.49,38.35) SIO_5553.16 ; v1(52.92,83.75) 52.72,83.95 49.24,83.95 48.27,84.92 48.27,85.76 47.35,86.68 44.79,86.68 42.4,84.28 41.49,84.28 41.26,84.05 34.47,84.05 33.88,84.64 31.76,84.64 31.12,85.28 29.46,85.28 27.98,86.76 27.45,86.76 24.7,89.51 24.7,101 22.76,102.93 22.76,113.35 19.37,116.74 19.37,121.18 17.66,122.9 17.66,123.84 19.07,125.25 20.61,125.25 21.85,124 26.2,124 27.07,124.87 31.62,124.87 R6394.1 ; v1(76.46,78.04) 76.46,73.64 75.31,72.48 75.31,63.44 79.33,59.41 79.33,54.78 85.07,49.05 96.25,49.05 97.8,50.6 114.61,50.6 v1(116.95,48.26)
  BOTTOM w0.102: v1(216.49,38.35) 215.55,38.35 215.3,38.1 v2(214.92,38.1) 214.56,37.74 210.24,37.74 209.96,38.02 208.39,38.02 208.21,37.85 200.69,37.85 188.98,49.56 177.55,49.56 175.57,51.54 174.35,51.54 169.98,47.17 165.4,47.17 164.4,46.18 156.58,46.18 153.2,49.56 135.24,49.56 134.71,49.02 121.32,49.02 120.06,47.76 117.44,47.76 v1(116.95,48.26) ; v1(76.46,78.04) 75.81,78.69 68.65,78.69 68.29,78.33 64.86,78.33 63.92,79.27 62.53,79.27 61.93,79.87 57.41,79.87 57.18,79.64 55.64,79.64 52.92,82.37 v1(52.92,83.75)
SIO_24M_TCM: length 44.4
  TOP w0.102: v1(22.13,148.34) 22.64,148.84 22.64,149.67 RF179.1 22.58,150.62 23.15,151.19 23.15,152.4 22.89,152.65 22.89,153.16 22.75,153.3 UF2.22 ; RF177.1 24.73,125.86 23.07,125.86 22.03,126.9 18.85,126.9 17.17,125.22 v1(15.91,125.22)
  BOTTOM w0.102: v1(15.91,125.22) 15.68,125.22 13.37,127.53 v2(13.37,134.24) 13.37,135.13 13.75,135.51 13.75,137.65 19.12,143.02 19.12,144.79 19.6,145.28 19.6,146.32 21.04,147.75 21.55,147.75 v1(22.13,148.34)
SIO_CAP1: length 4
  TOP w0.102: v1(210.09,35.86) CO18.1 208.31,37.64 208.31,38.35 208.45,38.49 SIO_5553.128
SIO_CLOCKI: length 309.9
  TOP w0.102: v1(212.83,40.16) 212.89,40.1 SIO_5553.7 ; RF178.2 21.57,145.02 v1(21.57,144.5) ; v1(16.39,123.92) 16.39,123.94 19,126.54 21.88,126.54 22.92,125.5 26.34,125.5 26.82,125.98 RF76.1 ; v1(27.73,85.41) 27.37,85.78 26.4,85.78 25.9,86.28 24.36,86.28 23.27,87.37 23.27,100.38 21.34,102.32 21.34,109.37 17.91,112.8 17.91,120.63 16.04,122.51 v1(16.04,122.68) ; v1(15.55,128.19) 16.01,128.65 17.19,128.65 17.73,129.18 22.97,129.18 23.36,128.8 25.09,128.8 RF176.2
  BOTTOM w0.102: v1(21.57,144.5) 21.72,144.35 21.72,143.76 21.5,143.53 21.5,142.63 19.59,140.72 19.34,140.72 v2(18.7,140.08) 15.25,136.63 15.25,128.5 v1(15.55,128.19) 15.58,128.17 15.58,127.99 16.77,126.8 16.77,126.21 16.44,125.88 16.44,123.97 v1(16.39,123.92) 16.39,123.04 v1(16.04,122.68) ; v1(212.83,40.16) 212.15,40.84 211.06,40.84 209.74,39.52 205.25,39.52 204.35,40.42 200.36,40.42 188.57,52.2 178.06,52.2 177.3,52.96 173.15,52.96 169.06,48.87 162.8,48.87 162.22,48.3 156.47,48.3 153.79,50.98 134.63,50.98 134.09,50.44 120.38,50.44 119.48,49.54 115.52,49.54 111.11,53.96 91.28,53.96 87.28,57.96 85.36,57.96 79.13,64.19 72.17,64.19 70.49,65.87 60.64,65.87 55.26,65.87 54.95,66.18 46.15,66.18 45.33,67 39.04,67 32.49,73.55 32.49,76.2 28.07,80.62 28.07,83.44 27.85,83.67 27.85,85.3 v1(27.73,85.41)
SIO_GP004: length 3.4
  TOP w0.102: RO19.2 223.43,54.44 v1(222.94,53.96) 222.16,53.96 221.69,53.49 SIO_5553.68
SIO_GP010: length 3.5
  TOP w0.102: SIO_5553.25 220.09,35.9 219.28,35.08 v1(219.28,34.76) 218.85,34.34 RO4.2
SIO_GP011: length 5.7
  TOP w0.102: RO8.2 219.87,35.35 220.49,35.98 SIO_5553.26 220.49,39.2 v1(220.26,39.43)
SIO_GP016: length 2.9
  TOP w0.102: R6523.1 226.09,38.49 v1(225.66,38.93) 225.66,39.02 224.98,39.69 SIO_5553.36
SIO_GP026: length 8.7
  TOP w0.102: v1(220.76,45.14) 221.32,45.69 SIO_5553.51 225.18,45.69 225.38,45.9 228.52,45.9 RO166.2
SIO_GP071: length 6.3
  TOP w0.102: v1(210.6,38.35) 210.6,38.84 210.14,39.29 SIO_5553.126 208.42,39.29 208.08,38.96 208.08,36.11 RO2.2
SIO_PCIAUX_G: length 2.3
  TOP w0.102: QS11.G1 215.68,57.23 v1(215.18,56.73) 214.96,56.51 RO100.1
SIO_PECI_R: length 6.8
  TOP w0.102: RO12.2 224.82,32.19 224.82,34.54 223.79,35.58 v1(223.43,35.58) 223.35,35.58 222.91,36.01 222.87,36.01 222.49,36.39 SIO_5553.31
SIO_PWRGD: length 8.4
  TOP w0.102: RO174.1 207.4,38.39 207.4,40 207.89,40.49 SIO_5553.123 210,40.49 211.92,42.42 v1(212.76,42.42)
SIO_QO1A_B: length 1.8
  TOP w0.102: QO1.2 203.62,45.34 204.16,45.87 v1(204.2,45.87) 204.63,45.44 RO168.2
SIO_QO1B_B: length 4.8
  TOP w0.102: RO172.2 200.12,43.56 RO171.1 200.57,44.13 200.57,45.09 200.82,45.34 QO1.5 201.66,45.34 v1(202.22,45.9)
SIO_QO2A_B: length 2.3
  TOP w0.102: RO43.2 204.3,49.8 v1(204.3,49.25) 204.3,48.91 203.65,48.26 QO2.2
SIO_QO2B_B: length 3.8
  TOP w0.102: v1(198.03,49.15) 198.23,48.95 RO45.1 199.56,48.95 RO44.2 200.25,48.26 QO2.5
SIO_QO3A_B: length 5.7
  TOP w0.102: QO3.2 9.43,71.15 9.53,71.25 9.98,71.25 10.08,71.15 QO3.3 10.08,69.61 v1(9.79,69.32) 9.56,69.09 8.1,69.09 RO46.2
SIO_QO3B_B: length 5.7
  TOP w0.102: QO3.5 9.43,73.15 9.3,73.28 8.54,73.28 8.13,72.87 8.13,72.42 RO53.1 6.83,71.69 v1(6.76,71.75) 6.76,71.44 RO50.2
SIO_QO4A_B: length 4.4
  TOP w0.102: RO170.2 RO48.1 201.77,50.99 202.22,50.55 QO4.2 202.22,49.83 v1(201.89,49.5)
SIO_QO4B_B: length 3.6
  TOP w0.102: QO4.5 202.22,51.99 202.6,51.61 v1(203.39,51.61) 203.91,52.13 RO54.1 204.06,52.07 RO51.2
SIO_QO5A_B: length 5.6
  TOP w0.102: RO55.2 214.47,60.41 ; 214.47,60.41 v1(214.48,60.41) ; 214.47,60.41 214.47,58.1 214.16,57.78 QO5.3 213.79,57.29 213.65,57.15 213.27,57.15 213.14,57.28 QO5.2
SIO_QO5B_B: length 3.2
  TOP w0.102: 213.14,59.82 213.14,60.58 213.39,60.83 RO56.2 RO57.1 211.72,61.15 v1(211.68,61.11)
SIO_RSMRST#: length 438.2
  TOP w0.102: 88.96,145.16 88.96,142.82 88.07,141.94 88.07,136.79 87.18,135.9 87.18,134.91 88.4,133.69 88.4,132.3 88.4,128.71 89.82,127.28 89.82,126.47 89.95,126.34 89.95,114.3 86.37,110.72 v1(86.37,109.65) ; 88.96,145.16 v1(88.95,145.16) ; 88.96,145.16 88.96,145.16 88.96,145.51 86.98,147.49 86.69,147.49 85.23,148.95 79.72,148.95 76.2,152.48 76.2,154.9 71.16,159.94 68.89,159.94 66.27,162.56 53.96,162.56 46.39,154.99 46.39,154.2 v1(45.88,153.7) ; v3(128.62,194.36) 128.62,194.68 R89.1 ; v1(124.27,206.85) 124.11,207 124.11,208.28 123.93,208.46 123.35,208.46 122.59,209.22 115.89,209.22 114.71,208.04 114.71,200.88 107.73,193.9 107.73,177.87 112.86,172.74 112.86,165.13 104.6,156.87 103.74,156.87 98.35,151.47 97.11,151.47 96.29,150.65 96.07,150.65 94.78,149.35 94.14,149.35 v1(94.01,149.48) ; R6418.2 v1(40.29,143.38) ; v1(126.68,67.64) 129.17,65.15 130.52,65.15 134.53,61.14 134.53,58.15 136.49,56.18 146.36,56.18 v1(148.3,54.25) ; v1(93.89,106.04) 93.89,105.28 94.14,105.03 101.63,105.03 v1(101.89,104.78) ; SIO_5553.58 224.97,48.49 v1(225.99,49.51) 225.99,49.61 R6531.1
  BOTTOM w0.102: v1(124.27,206.85) 123.77,206.85 121.46,204.54 121.46,202.96 121.06,202.56 120.68,202.56 120.51,202.39 120.51,198.65 121.57,197.59 121.57,196.53 122.65,195.45 127.03,195.45 128.13,194.36 v3(128.62,194.36) ; v1(45.88,153.7) 44.21,152.02 43.62,152.02 42.1,150.5 42.1,148.62 41.44,147.96 41.44,144.53 v1(40.29,143.38) ; v1(88.95,145.16) 90.21,145.16 93.4,148.36 93.4,148.89 93.73,149.22 93.76,149.22 v1(94.01,149.48) ; v1(126.68,67.64) 126.68,69.39 124.89,71.18 113.95,71.18 113.58,70.82 112.58,70.82 109.96,73.43 101.84,73.43 99.45,75.82 96.68,75.82 95.79,76.71 95.79,82.31 96.36,82.88 96.36,91.52 101.89,97.05 101.89,98.7 101.15,99.43 101.15,103.4 101.89,104.14 v1(101.89,104.78) ; v1(93.89,106.04) 93.28,106.65 93.28,108.66 91.96,109.98 86.7,109.98 v1(86.37,109.65) ; v1(225.99,49.51) 225.85,49.38 225.85,48.88 v2(225.03,48.05) 223.03,46.05 222.71,46.05 221.85,45.19 221.85,44.91 221,44.06 221,43.6 220.61,43.21 215.78,43.21 214.56,44.42 212.32,44.42 211.89,44.86 210.04,44.86 207.55,42.37 206.78,42.37 205.83,43.32 205.83,45.24 205.65,45.42 205.23,45.42 203.83,44.02 201.89,44.02 200.51,45.39 199.19,45.39 196.53,48.06 196.53,51.09 195.7,51.92 192.83,51.92 188.95,55.8 178.34,55.8 177.52,56.62 171.88,56.62 171.25,55.99 171.25,55.13 167.68,51.56 157.02,51.56 154.1,54.48 149.84,54.48 149.31,53.95 148.6,53.95 v1(148.3,54.25)
SIO_SLP_S4#_R: length 3
  TOP w0.102: 215.68,59.82 215.68,60.32 215.93,60.58 216.38,60.58 RO102.2 217.14,60.83 v1(217.14,60.23)
SIO_SLP_SUS: length 4.6
  TOP w0.102: RO81.2 221.39,53.87 220.49,52.97 SIO_5553.71 220.49,51.66 219.92,51.08 v1(219.39,51.08)
SIO_SLP_WLAN_N_R: length 2.2
  TOP w0.102: v1(207.83,58.12) 207.83,57.44 RO118.2 208.63,57.4 QV72.G
SLEEVE: length 7.4
  TOP w0.203: 181.94,24.21 182.13,24.03 UA1.18
  TOP w0.254: 181.94,24.21 180.37,24.21
  TOP w0.508: v1(174.23,27.18) 174.23,27.69 QA4.D ; v1(175.67,24.85) 176.31,24.21 IO_FBI7.1
  BOTTOM w0.508: v1(174.23,27.18) 174.23,26.29 v1(175.67,24.85)
SLEEVE_J:
  vias: v1(172.37,22.81) v1(173.01,22.81) v1(178.21,3.76) v1(178.85,4.14) v1(180.88,4.4) v1(180.88,3.76)
SLP_A#: length 361.9
  TOP w0.102: v1(27.17,149.16) 28.58,150.57 28.9,150.57 29.7,151.37 29.7,154.06 28.81,154.95 28.81,158.07 24.12,162.76 15.98,162.76 14.43,164.3 14.43,190.77 RB10.2 ; v1(26.73,86.61) 26.47,86.87 24.6,86.87 23.86,87.61 23.86,100.65 21.92,102.59 21.92,113 18.54,116.39 18.54,120.84 16.77,122.61 16.77,122.9 15.4,124.27 15.4,127.06 16.08,127.74 16.9,127.74 v1(17.03,127.86) 17.41,127.86 18.14,128.6 22.73,128.6 23.42,127.91 33.09,127.91 R6662.2 ; RO2.1 208.57,34.73 v1(208.57,34.42)
  BOTTOM w0.102: v1(26.73,86.61) 26.39,86.28 26.39,82.48 27.49,81.38 27.49,80.38 28.99,78.88 28.99,77.02 31.15,74.86 31.15,73.42 38.61,65.96 44.82,65.96 45.65,65.14 54.51,65.14 54.83,64.83 69.96,64.83 71.64,63.15 78.69,63.15 84.93,56.92 86.85,56.92 90.85,52.92 110.67,52.92 116.44,47.16 119.71,47.16 121.32,45.54 134.54,45.54 136.22,47.22 152.15,47.22 155.68,43.69 173.2,43.69 175.72,46.21 183.54,46.21 186.9,42.85 190.78,42.85 199.57,34.06 205.49,34.06 205.88,33.67 207.94,33.67 208.57,34.3 v1(208.57,34.42) ; v1(17.03,127.86) 17.03,130.05 16.5,130.57 16.5,136.27 22.94,142.71 22.94,143.85 22.72,144.08 22.72,144.91 26.96,149.16 v1(27.17,149.16)
SLP_S0_N: length 5.4
  TOP w0.089: U4.BC26 47.1,123.12 45.2,123.12 44.56,122.48 v1(44.56,121.79)
  BOTTOM w0.089: v1(44.56,121.79) 43.47,121.79 43.23,121.56
  BOTTOM w0.102: TPS1.1 43.23,121.56
SLP_S3#: length 436.2
  TOP w0.102: PQ49.G1 104.05,139.01 103.79,139.27 103.08,139.27 102.5,138.69 101.84,138.69 v1(101.75,138.77) ; v1(77,82.55) 78.77,80.77 78.77,63.89 91,51.66 116.64,51.66 v1(116.75,51.56) ; v1(207.65,41.35) 207.71,41.29 SIO_5553.121 ; v1(98.05,138.94) 98.56,138.43 PQ4.G1 ; R6660.2 27.47,130.99 24.17,130.99 23.51,130.33 20.04,130.33 19.84,130.12 16.62,130.12 v1(16.29,129.79) ; RB8.2 12.99,183.32 12.99,163.88 15.43,161.44 23.15,161.44 28.13,156.46 28.13,154.67 28.88,153.91 28.88,152.37 27.83,151.33 26.92,151.33 v1(26.8,151.44) ; v1(46.65,160.22) 46.65,161.05 47.94,162.34 50.92,162.34 52.92,164.34 67.02,164.34 68.91,162.44 70.25,162.44 70.74,161.96 72,161.96 77.29,156.67 78.77,156.67 79.51,155.93 79.51,153.1 81.65,150.96 86.1,150.96 87.56,149.5 89.04,149.5 91.18,147.36 91.18,145.88 93.12,143.93 v1(93.12,136.14) ; v1(90.13,135.59) 89.86,135.32 89.86,134.33 89.95,134.24 89.95,130.1 90.7,129.36 90.97,129.09 90.97,126.99 91.09,126.86 91.09,113.4 89.52,111.82 89.52,108.05 89.59,107.98 v1(89.59,107.75)
  BOTTOM w0.102: v1(101.75,138.77) 101.63,138.65 98.34,138.65 v1(98.05,138.94) 97.87,138.76 95.98,138.76 93.74,136.52 93.51,136.52 v1(93.12,136.14) 92.65,135.67 90.22,135.67 v1(90.13,135.59) ; v1(77,82.55) 77.4,82.96 84.53,82.96 87.41,85.83 87.41,89.35 85.68,91.08 83.16,91.08 77.63,96.62 77.63,101.96 82.61,106.93 87.43,106.93 88.25,107.75 v1(89.59,107.75) ; v1(207.65,41.35) 206.43,41.35 204.96,42.82 201.39,42.82 200.78,43.43 199.46,43.43 189.14,53.75 178.7,53.75 177.99,54.46 172.48,54.46 168.39,50.37 162.11,50.37 161.54,49.8 157.09,49.8 154.41,52.48 133.96,52.48 133.42,51.94 119.72,51.94 118.83,51.05 117.25,51.05 v1(116.75,51.56) ; v1(16.29,129.79) 16.05,130.04 16.05,136.46 16.42,136.83 21.85,142.27 21.85,143.38 22.19,143.73 22.19,145.1 26.06,148.96 26.06,150.69 v1(26.8,151.44) 27,151.24 27.6,151.24 31.67,155.31 v2(31.67,156.44) 34.27,159.04 34.27,160.56 35.25,161.54 36.42,161.54 36.8,161.16 39.95,161.16 40.2,160.91 45.97,160.91 v1(46.65,160.22)
SLP_S4#: length 538.5
  TOP w0.102: v1(223.17,61.98) 222.66,61.47 218.16,61.47 RO102.1 ; v1(152.69,73.66) 150.02,73.66 149.66,74.02 147.79,74.02 147.43,74.37 147.05,74.37 146.71,74.04 U139.2 146.71,71.78 146.31,71.37 146.31,70.87 147.68,69.49 147.68,66.8 v1(146.57,65.68) ; PQ19.G1 221.52,72.39 v1(221.78,72.64) 222.03,72.9 222.03,73.28 222.28,73.53 223.43,73.53 225.46,71.5 225.46,70.41 v1(226.02,69.85) ; v1(100.24,63.88) 101.38,63.88 ; v1(88.04,77.47) 89.49,78.92 89.49,86.94 v1(89.59,87.05) ; R6661.2 34.55,127.48 33.9,127.48 33.23,128.14 23.51,128.14 22.83,128.83 17.87,128.83 17.34,128.3 16.31,128.3 v1(16.21,128.19) 15.17,127.15 15.17,124.17 16.54,122.8 16.54,122.51 18.27,120.78 18.27,116.33 21.69,112.91 21.69,102.49 23.63,100.56 23.63,87.52 24.51,86.64 26.04,86.64 26.53,86.15 27.73,86.15 29.21,84.67 30.87,84.67 31.5,84.03 33.59,84.03 34.18,83.44 41.51,83.44 41.74,83.68 42.65,83.68 44.78,85.8 46.88,85.8 v1(47.02,85.94) ; v1(222.56,57.93) 222.56,57.3 221.9,56.64 221.9,55.05 RO22.1 221.29,53.43 SIO_5553.69 ; PQ24.G1 98.71,100.51 99.12,100.1 99.6,100.1 100.44,100.94 100.44,102.16 100.11,102.49 v1(95.03,102.49) ; PQ55.G1 116.58,37.97 116.38,38.17 116.38,39.64 118.24,41.5 118.24,49.07 116.11,51.21 96.83,51.21 95.84,50.22 85.55,50.22 80.5,55.27 80.5,59.9 76.5,63.9 76.5,71.77 77.86,73.13 77.86,76.35 v1(77.63,76.58) ; RB3.1 14.21,189.98 14.21,164.21 15.88,162.53 24.02,162.53 28.58,157.97 28.58,154.86 29.47,153.97 29.47,151.78 28.77,151.08 v1(28.73,151.08)
  BOTTOM w0.102: v1(221.78,72.64) 221.14,72.64 217.67,76.12 181.62,76.12 181.06,75.56 177.2,75.56 176.69,75.06 173.52,75.06 172.75,75.82 158.55,75.82 155.66,72.93 153.42,72.93 v1(152.69,73.66) ; v1(89.59,87.05) 89.59,91.8 93.66,95.86 93.66,101.12 v1(95.03,102.49) ; v1(47.02,85.94) 47.02,84.84 46.35,84.17 46.35,82.73 45.75,82.12 45.75,80.95 46.56,80.14 46.8,80.14 47.04,79.9 47.04,79.26 47.38,78.92 47.79,78.92 48.19,79.32 48.19,80.65 49.23,81.69 52.71,81.69 53.65,80.75 53.65,80.29 55.89,78.05 59.95,78.05 60.03,77.98 60.7,77.98 60.97,77.7 62.34,77.7 64.04,76 65.53,76 65.96,76.43 68.66,76.43 69.37,77.14 73.87,77.14 74.51,77.77 75.14,77.77 76.33,76.58 v1(77.63,76.58) 85.35,76.58 86.62,77.85 87.66,77.85 v1(88.04,77.47) 88.35,77.16 88.35,70.92 89.29,69.98 89.29,68.86 93.94,64.21 99.91,64.21 v1(100.24,63.88) 100.57,64.21 102.63,64.21 104.03,62.81 106.78,62.81 107.54,63.58 109.6,63.58 110.13,64.11 111.92,64.11 115.9,60.12 125.72,60.12 129.45,63.86 144.37,63.86 146.2,65.68 v1(146.57,65.68) ; v1(28.73,151.08) 28.04,151.08 26.36,149.4 26.36,148.93 22.49,145.06 22.49,143.99 22.72,143.76 22.72,142.81 16.28,136.37 16.28,130.48 16.8,129.96 16.8,128.78 v1(16.21,128.19) ; v1(226.02,69.85) 226.02,66.85 223.17,64.01 v1(223.17,61.98) 222.88,61.68 222.88,58.24 v1(222.56,57.93)
SLP_S5#: length 392.7
  TOP w0.089: v1(49.51,130.05) 49.33,129.87 49.21,129.87 48.88,129.55 U4.BA13
  TOP w0.102: v1(204.63,54.86) 204.12,54.36 200.82,54.36 197.59,51.13 197.59,42.39 199.47,40.51 201.25,40.51 203.66,38.1 RO24.1 ; v1(27.8,145.49) 27.47,145.82 27.47,146.63 26.68,147.42 26.68,149.85 29.11,152.28 29.11,154.01 28.35,154.76 28.35,157.2 27.18,158.37 v1(27.18,158.39) 27.18,159.05 23.93,162.31 15.79,162.31 13.98,164.11 13.98,187.54 RB9.2 ; v1(29.65,133.11) 29.23,133.53 24.58,133.53 23.14,132.09 21.6,132.09 v1(21.55,132.14) ; RO7.2 v1(212.63,54.48)
  BOTTOM w0.089: v1(49.51,130.05) 49.06,130.51 48.67,130.51 48.36,130.19 44.29,130.19 44.2,130.28 43.23,130.28
  BOTTOM w0.102: 43.23,130.28 42.96,130.28 41.56,128.88 39.78,128.88 38.95,129.72 37.1,129.72 35.52,131.29 30.49,131.29 29.65,132.13 v1(29.65,133.11) 28.54,133.11 27.89,132.45 27.89,130.74 27.49,130.35 27.49,125.4 27.8,125.1 27.8,115.99 26.93,115.12 26.42,115.12 23.09,111.8 23.09,108.84 28.2,103.74 37.33,103.74 39.1,101.97 39.1,91.07 41.84,88.32 41.84,81.12 43.01,79.95 43.01,79.39 43.47,78.94 43.47,76.53 45.95,74.04 45.95,73.63 48.8,70.78 53.24,70.78 56.1,73.63 59.52,73.63 61.02,72.14 61.82,72.14 63.15,70.8 69.8,70.8 70.07,71.07 76.58,71.07 77.34,70.31 80.74,70.31 87.75,63.29 89.56,63.29 93.59,59.26 113.28,59.26 114.8,57.73 115.28,57.73 126.98,57.73 131.33,62.09 147.63,62.09 148.23,61.49 154.65,61.49 155.26,62.1 164.72,62.1 167.2,64.59 178.18,64.59 181.56,61.21 192.79,61.21 196.47,57.54 197.64,57.54 198.24,56.94 199.88,55.3 204.2,55.3 v1(204.63,54.86) 204.86,54.64 212.48,54.64 v1(212.63,54.48) ; v1(21.55,132.14) 21.39,132.29 21.39,136.89 27.21,142.71 27.21,144.02 27.8,144.6 v1(27.8,145.49)
SLP_SUS#: length 361
  TOP w0.102: R6423.2 37.75,127.38 v1(37.24,127.89) ; v1(14.64,75.11) 14.64,76.96 15.91,78.23 18.85,78.23 PD2.1 19.91,77.18 PR25.2 21.91,76.2 23.85,74.26 30.43,74.26 31.38,75.21 36,75.21 40.14,79.35 43.23,79.35 v1(43.45,79.57) ; PR276.2 39.78,50.93 38.72,51.99 38.72,54 37.88,54.84 v1(37.88,55.37) ; RO81.1 v3(221.39,56.26) ; PR320.2 68.54,74.55 68.99,75.01 69.58,75.01 70.39,74.19 70.39,72.01 v1(69.76,71.37)
  BOTTOM w0.102: v3(221.39,56.26) 221.01,56.64 218.85,56.64 217.2,54.99 212.12,54.99 212,54.86 205.27,54.86 204.6,55.52 199.98,55.52 198.47,57.03 197.33,58.17 196.76,58.17 v2(196.25,58.67) 193.48,61.44 181.66,61.44 178.28,64.82 167.11,64.82 164.62,62.33 155.16,62.33 154.55,61.72 148.32,61.72 147.73,62.31 131.24,62.31 126.88,57.96 115.18,57.96 114.93,57.96 112.42,60.47 110.88,60.47 110.42,60.02 96.93,60.02 96.51,60.44 92.73,60.44 89.66,63.52 87.85,63.52 80.83,70.54 77.61,70.54 76.62,71.53 69.91,71.53 v1(69.76,71.37) 69.41,71.03 63.25,71.03 61.91,72.36 61.12,72.36 59.62,73.86 56.01,73.86 53.15,71.01 48.9,71.01 46.18,73.72 46.18,74.14 43.7,76.62 43.7,79.32 v1(43.45,79.57) 43.45,79.84 42.07,81.21 42.07,88.42 39.56,90.93 39.56,102.41 37.77,104.2 28.39,104.2 23.55,109.03 23.55,111.61 26.6,114.66 27.11,114.66 28.25,115.8 28.25,125.29 27.95,125.59 27.95,130.16 29.04,131.25 29.88,131.25 30.3,130.84 32.32,130.84 33.47,129.69 34.88,129.69 36.69,127.89 v1(37.24,127.89) ; v1(37.88,55.37) 37.24,56.01 36.11,56.01 29.24,62.88 23.25,62.88 19.74,66.39 19.74,68.82 14.64,73.92 v1(14.64,75.11)
SLP_SUS#_PCH: length 9.5
  TOP w0.089: U4.BB13 47.8,129.38 46.77,129.38 46.72,129.43 45.01,129.43 43.91,128.33 43.19,128.33
  TOP w0.102: 43.19,128.33 40.68,128.33 39.74,127.38 R6423.1
SLP_SUS_FET_R: length 4.5
  TOP w0.102: PR26.1 16.99,74.17 PR24.2 16.86,74.04 PQ9.D 14.13,74.04 v1(13.75,74.42)
SLP_WLAN_N: length 290.3
  TOP w0.089: v1(50.17,130.07) 50.17,129.64 U4.AV13
  TOP w0.102: RO118.1 206.24,57.4 204.48,55.65 204.48,55.35 v1(204,54.86)
  BOTTOM w0.089: 43.23,130.51 44.24,130.51 44.37,130.38 48.27,130.38 48.6,130.71 49.54,130.71 v1(50.17,130.07)
  BOTTOM w0.102: v1(204,54.86) 203.79,55.07 199.79,55.07 198.01,56.85 197.55,57.31 196.37,57.31 192.69,60.99 181.47,60.99 178.09,64.36 167.3,64.36 164.81,61.87 155.35,61.87 154.74,61.26 148.13,61.26 147.54,61.86 131.42,61.86 127.07,57.51 115.37,57.51 114.71,57.51 113.19,59.03 93.5,59.03 89.47,63.06 87.66,63.06 80.64,70.08 77.25,70.08 76.49,70.84 70.16,70.84 69.89,70.57 63.06,70.57 61.72,71.91 60.93,71.91 59.43,73.41 56.2,73.41 53.34,70.55 48.71,70.55 45.73,73.53 45.73,73.95 43.24,76.43 43.24,78.84 42.78,79.3 42.78,79.85 41.61,81.02 41.61,88.23 38.87,90.97 38.87,101.88 37.75,103 28.62,103 22.87,108.75 22.87,111.89 26.33,115.35 26.84,115.35 27.57,116.08 27.57,125 27.26,125.31 27.26,130.44 27.65,130.83 27.65,134.16 30.83,137.34 34.91,137.34 v2(34.93,137.36) 39.33,137.36 39.64,137.05 39.64,129.37 39.91,129.11 41.44,129.11 42.84,130.51 43.23,130.51
SMB_DDR4_CLK: length 356.3
  TOP w0.102: v1(102.4,102.62) 102.14,102.87 101.53,102.87 100.59,103.81 92.8,103.81 89.6,107.01 89.27,107.01 87.28,109 87.28,110.9 90.41,114.02 90.41,126.53 90.28,126.66 90.28,128.8 89.26,129.82 89.26,133.89 88.51,134.64 88.51,135.8 v1(88.58,135.86) ; SIO_5553.81 216.49,53.54 v1(216.44,53.59) 216.31,53.72 RO26.2 ; v1(130.37,70.72) 130.1,70.99 128.35,70.99 126.61,69.25 126.61,68.25 126.14,67.78 126.14,66.2 129.86,62.48 130.84,62.48 v1(132.24,61.09) ; v1(105.34,153.36) 105.76,153.36 105.95,153.54 106.08,153.54 116.37,163.83 116.37,174.54 111.13,179.77 111.13,186.49 117.21,192.58 117.21,199.12 118.96,200.86 122.09,200.86 123.01,201.78 125.54,201.78 126.18,202.41 126.6,202.41 126.73,202.54 129.78,202.54 130.57,203.33 131.42,203.33 131.66,203.09 131.66,202.79 131.78,202.67 v1(131.99,202.67) 131.66,202.34 131.66,201.04 132.03,200.67 132.03,200.27 132.16,200.14 XDP_CPU.53 ; RG3.2 149.82,219.77 149.92,219.67 149.92,217.96 144.58,212.63 144.58,209.93 144.82,209.7 145.37,209.7 v1(145.66,209.41)
  BOTTOM w0.102: v1(131.99,202.67) 131.82,202.67 131.69,202.79 131.69,203.08 135.39,206.78 141.91,206.78 144.82,209.69 145.38,209.69 v1(145.66,209.41) ; v1(88.58,135.86) 88.7,135.86 89.11,136.27 90.23,136.27 90.81,136.85 91.88,136.85 92.52,137.49 93.34,137.49 95.58,139.72 96.36,139.72 96.37,139.73 96.4,139.73 100.89,144.22 100.89,146.53 103.28,148.92 103.28,150.9 105.34,152.96 v1(105.34,153.36) ; v1(216.44,53.59) 215.93,53.09 211.98,53.09 208.78,49.89 207.84,49.89 206.29,51.44 205.35,51.44 204.94,51.03 202.64,51.03 201.61,52.06 201.61,52.72 199.89,54.45 199.55,54.45 197.76,56.24 197.1,56.24 192.58,60.76 181.34,60.76 177.96,64.13 167.43,64.13 164.89,61.59 155.56,61.59 155.01,61.04 148.03,61.04 147.49,61.58 133.78,61.58 133.08,60.87 132.46,60.87 v1(132.24,61.09) ; v1(102.4,102.62) 102.72,102.3 102.72,99.37 102.94,99.15 102.94,94.69 100.34,92.09 100.34,91.92 100.15,91.72 DIMM1.141 99.78,91.66 99.78,88.93 99.12,88.26 99.12,87.68 99.68,87.12 99.68,85.09 100.03,84.74 100.03,82.91 DIMM2.141 99.8,82.68 99.8,79.96 99.07,79.22 99.07,78.61 99.68,78 101.07,78 101.43,77.65 101.43,76.75 102.08,76.1 105.29,76.1 106.23,75.16 109.18,75.16 110.15,76.12 124.61,76.12 129.74,70.99 130.1,70.99 v1(130.37,70.72)
SMB_DDR4_DATA: length 357.1
  TOP w0.102: SIO_5553.79 217.29,53.69 v1(217.33,53.72) RO25.2 ; v1(130.37,71.51) 130.08,71.22 128.26,71.22 126.39,69.35 126.39,68.35 125.92,67.88 125.92,66.11 129.77,62.26 130.75,62.26 131.67,61.33 131.67,60.87 v1(131.61,60.71) ; v1(89.07,135.37) 88.87,135.37 88.74,135.24 88.74,134.74 89.49,133.99 89.49,129.91 90.51,128.9 90.51,126.72 90.63,126.59 90.63,113.93 87.51,110.81 87.51,109.09 89.36,107.24 89.7,107.24 92.9,104.04 100.69,104.04 101.63,103.1 102.12,103.1 v1(102.4,103.38) ; XDP_CPU.51 131.66,200.15 131.8,200.28 131.8,200.58 131.43,200.95 131.43,202.34 v1(131.1,202.67) 131.33,202.67 131.43,202.77 131.43,203 131.33,203.1 130.66,203.1 129.88,202.31 126.82,202.31 126.7,202.18 126.27,202.18 125.63,201.55 123.1,201.55 122.19,200.63 119.05,200.63 117.44,199.03 117.44,192.48 111.36,186.4 111.36,179.86 116.59,174.63 116.59,163.74 106.17,153.31 106.04,153.31 105.9,153.18 v1(105.9,152.8) ; v1(145.66,210.2) 145.51,210.2 145.24,209.93 144.91,209.93 144.81,210.03 144.81,212.53 150.15,217.87 150.15,219.67 150.25,219.77 RG4.2
  BOTTOM w0.102: v1(102.4,103.38) 102.92,102.85 102.92,99.46 103.17,99.21 103.17,94.6 100.57,92 100.57,91.43 100.01,90.87 100.01,88.77 99.84,88.61 DIMM1.285 99.91,87.86 99.91,85.19 100.26,84.84 100.26,83.36 100.54,83.08 100.54,82.44 100.01,81.91 100.01,79.08 DIMM2.285 99.84,78.42 100.06,78.21 101.16,78.21 101.63,77.73 101.63,76.83 102.14,76.33 105.39,76.33 105.43,76.28 105.43,76.24 106.31,75.36 109.1,75.36 110.06,76.33 124.7,76.33 129.83,71.2 130.06,71.2 v1(130.37,71.51) ; v1(105.9,152.8) 105.51,152.8 103.51,150.8 103.51,148.82 101.12,146.43 101.12,144.13 96.48,139.5 95.67,139.5 93.44,137.26 92.62,137.26 91.97,136.62 90.9,136.62 90.33,136.04 89.22,136.04 89.01,135.83 89.01,135.43 v1(89.07,135.37) ; v1(217.33,53.72) 216.47,52.86 212.07,52.86 208.87,49.66 207.75,49.66 206.2,51.21 205.44,51.21 205.04,50.8 202.55,50.8 201.38,51.97 201.38,52.63 199.79,54.22 199.45,54.22 197.66,56.01 197.01,56.01 192.49,60.53 181.24,60.53 177.87,63.91 167.53,63.91 164.99,61.37 155.66,61.37 155.1,60.81 147.94,60.81 147.4,61.35 133.88,61.35 133.17,60.64 132.1,60.64 132.04,60.71 v1(131.61,60.71) ; v1(131.1,202.67) 131.35,202.67 131.46,202.78 131.46,203.18 133,204.72 133,204.72 134.86,206.57 135.29,207.01 141.82,207.01 144.73,209.92 145.23,209.92 145.51,210.2 v1(145.66,210.2)
SMBCLK: length 488.1
  TOP w0.089: v1(49.23,114.63) 49.37,114.5 U4.AW44
  TOP w0.102: RX19.1 67.03,234.91 67.13,234.81 67.34,234.81 67.58,235.05 67.75,235.05 v1(68.04,235.34) 68.34,235.05 69.77,235.05 70.52,234.3 74.76,234.3 RX175.1 ; v1(45.67,84.35) 45.42,84.6 45.42,84.85 45.18,85.09 44.76,85.09 43.77,84.1 43.77,83.23 43.52,82.98 42.02,82.98 41.59,82.56 38.71,82.56 35.99,79.83 27.59,79.83 27.32,80.1 26.91,80.1 v1(26.65,80.37) ; RK51.2 27.69,192.89 30.03,192.89 30.39,192.53 33.57,192.53 v1(33.84,192.8) 34.11,192.53 34.26,192.53 RK10.2 ; v1(36.07,160.02) 35.76,160.33 35.12,160.33 33.31,162.13 33.31,171.32 33.97,171.98 34.27,171.98 v1(34.55,172.26) ; v1(53.88,225.3) 53.78,225.4 53.78,225.83 53.68,225.93 50.99,225.93 49.65,224.59 47.34,224.59 46.84,225.09 46.84,225.53 v1(46.5,225.86) ; RO163.2 217.46,59.37 217.46,57.66 v1(217.2,57.4) 217.2,56.96 216.82,56.58 216.82,54.23 216.89,54.16 SIO_5553.80
  BOTTOM w0.089: 49.16,111.96 49.16,112.5 49.59,112.93 49.59,113.51 49.04,114.06 49.04,114.44 v1(49.23,114.63)
  BOTTOM w0.102: v1(36.07,160.02) 35.85,160.24 35.4,160.24 34.99,159.82 34.99,157.97 30.74,153.73 30.74,149.52 28.24,147.02 26.44,147.02 24.34,144.92 24.34,143.81 23.86,143.33 23.86,141.74 19.71,137.59 19.71,126.29 18.19,124.77 18.19,118.24 18.58,117.86 18.58,116.44 17.18,115.04 17.18,106.25 25.26,98.17 25.26,93.49 27,91.74 27.58,91.74 28.51,90.81 28.51,88.98 28.07,88.54 27.49,88.54 24.42,85.47 24.42,83.06 26.02,81.46 26.02,80.38 26.29,80.11 26.39,80.11 v1(26.65,80.37) ; 49.16,111.96 49.16,110.14 48.06,109.05 48.06,107.8 48.04,107.78 48.04,105.07 44.94,101.98 44.94,86.34 45.41,85.87 45.41,84.61 v1(45.67,84.35) 45.67,84.07 45.9,83.84 45.9,83 45.27,82.37 45.27,80.78 45.94,80.11 45.94,79.32 47.29,77.97 47.9,77.97 49.16,79.22 52.94,79.22 56.29,75.87 59.88,75.87 60.99,74.75 62.49,74.75 63.23,74.02 65.46,74.02 66.05,73.43 68.52,73.43 68.9,73.05 80.26,73.05 83.05,70.26 84.06,70.26 85.42,68.9 85.42,67.13 88.2,64.36 90,64.36 93.08,61.28 96.85,61.28 97.28,60.85 110.08,60.85 110.54,61.31 112.77,61.31 115.28,58.8 126.54,58.8 130.89,63.15 144.76,63.15 146.1,64.49 146.93,64.49 147.99,65.55 154.36,65.55 155.05,66.24 158.34,66.24 158.62,65.96 159.57,65.96 159.95,65.58 178.17,65.58 181.85,61.9 194.25,61.9 198.34,57.81 200.05,57.81 201.22,56.64 205.14,56.64 205.47,56.31 213.39,56.31 214.74,57.66 215.68,57.66 216.31,57.02 216.82,57.02 v1(217.2,57.4) ; v1(34.55,172.26) 34.83,171.98 34.94,171.98 35.72,172.76 35.72,174.09 32.88,176.94 32.88,192.25 33.14,192.52 33.56,192.52 v1(33.84,192.8) 34.12,192.52 34.39,192.52 34.81,192.94 34.81,215.59 36.84,217.62 37.77,217.62 39.03,218.87 39.96,218.87 41.33,220.24 42.59,220.24 43.29,220.94 43.29,222.75 44.42,223.88 45.45,223.88 46.84,225.27 46.84,225.53 v1(46.5,225.86) ; v1(53.88,225.3) 53.78,225.4 53.78,230.22 54.45,230.89 59.04,230.89 60.13,229.79 63.29,229.79 64.37,230.88 65.11,230.88 65.82,231.59 65.82,234.13 66.74,235.05 67.75,235.05 v1(68.04,235.34)
