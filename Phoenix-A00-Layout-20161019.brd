# Allegro board Phoenix-A00-Layout-20161019.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VCC_AUD: length 18.9
  TOP w0.203: UA1.26 183.78,20.48 183.44,20.14 183.3,20.14
  TOP w0.508: FBA1.2 194.11,19.08 194.11,17.3 192.89,16.08 v1(191.3,16.08) 188.63,16.08 187.1,14.56 185.83,14.56 184.77,13.49 181.69,13.49 180.75,14.43
VCC_OBS_AB: length 3.4
  TOP w0.102: R118.1 131.08,196.85 v1(130.35,196.85) 129.66,197.53 XDP_CPU.43
VCC_OBS_CD: length 16.6
  TOP w0.102: R119.1 134.09,205.68 134.09,203.35 136.28,201.17 v1(136.56,201.17) ; XDP_CPU.44 129.66,203.24 v1(129.48,203.07)
  BOTTOM w0.102: v1(136.56,201.17) 135.72,202.01 133.45,202.01 133.06,201.62 130.62,201.62 129.48,202.76 v1(129.48,203.07)
VCC_OBS_R: length 12.6
  TOP w0.102: v1(48.17,97.28) 47.94,97.51 XDP_PCH.43 ; XDP_PCH.44 47.94,92.14 RS21.2 47.39,91.06 48.17,91.06 v1(48.42,91.31)
  BOTTOM w0.102: v1(48.42,91.31) 48.32,91.41 v2(48.32,94.11) 48.32,94.46 47.91,94.87 47.91,97.03 v1(48.17,97.28)
VCC_OPC_R: length 8
  TOP w0.254: CPU.AB37 181.88,145.12 v1(182.35,145.59) 182.35,145.56 CPU.AB38
  BOTTOM w0.254: v1(182.35,145.59) 182.35,145.44 181.74,144.83 181.09,144.83 180.82,145.11 180.2,145.11 v2(179.74,144.65) 179.34,144.65 178.96,144.27 177.53,144.27 R6641.2
VCCEOPIO_R: length 5.1
  TOP w0.254: CPU.AJ25 v3(171.38,139.19) 171.82,138.74 CPU.AJ26
  BOTTOM w0.102: R6640.1 173.4,139.84 174.2,139.04 v2(174.3,139.04)
  BOTTOM w0.254: R6640.1 172.22,140.03 v3(171.38,139.19)
VCCGT_HSN_1: length 3.6
  TOP w0.102: PR185.1 v1(223.83,172.47)
  TOP w0.508: PC152.2 226.6,171.83 225.97,172.47 PR185.1
VCCGT_HSN_2: length 2.6
  TOP w0.102: v1(228.25,154.48) PC167.2
  TOP w0.508: PR192.1 227.43,153.35 PC167.2
VCCGT_PWM1_10: length 56
  TOP w0.203: v1(232.51,157.92) 232.51,158.31 231.42,159.39 PU11.2 ; v1(222.89,195.2) 223.55,194.55 PU7.47
  BOTTOM w0.203: v1(222.89,195.2) 223.4,194.69 224.21,194.69 226.4,196.88 232.44,196.88 234.73,194.59 234.73,160.15 v1(232.51,157.92)
VCCGT_PWM2_10: length 72.5
  TOP w0.203: v3(223.76,195.2) 223.95,195.01 PU7.46 ; PU12.2 230.91,142.12 v1(232.06,140.97)
  BOTTOM w0.203: v1(232.06,140.97) 232.06,141.76 232.8,142.49 233.33,142.49 235.14,144.3 235.14,194.65 232.58,197.21 226.19,197.21 224.19,195.2 v3(223.76,195.2)
VCCGT_SENSE: length 62.3
  TOP w0.203: PR161.1 232.32,184.15 228.46,180.29 225.76,180.29 v1(225.2,180.85)
  TOP w0.305: CPU.F39 v3(184.15,160.19)
  BOTTOM w0.102: v3(184.15,160.19) 184.43,160.47 v2(185.06,160.47) 185.6,160.47 186.14,161.01 186.55,161.01 186.98,161.44 186.98,166.37 187.04,166.43 187.04,166.49
  BOTTOM w0.203: v1(225.2,180.85) 224.82,180.47 215.72,180.47 214.07,178.82 213.23,178.82 209.04,174.62 197.67,174.62 196.45,173.4 194.3,173.4 190.58,169.67 190.22,169.67 187.04,166.49
VCCGTX2_L31: length 1.2
  BOTTOM w0.406: R6638.2 176.78,155.6 176.83,155.6 v3(176.86,155.63)
  vias: v1(179.6,158.32)
VCCHDA_BA15: length 7.3
  TOP w0.254: U4.BA15 48.92,129.06 v1(48.98,129.06)
  TOP w0.508: RP42.2 43.21,129.62 v1(43.85,129.62)
  BOTTOM w0.356: v1(48.98,129.06) 48.83,129.06 48.34,129.54 47.76,129.54 47.51,129.29 v2(46.52,129.29) 46.18,129.62 v1(43.85,129.62)
VCCIO_EN: length 5.8
  TOP w0.102: v1(105.46,138.05) PU14.1 106.28,137.3 PC197.1 PR215.2 104.49,137.08 104.7,137.29 PQ49.D2
  BOTTOM w0.102: v1(105.46,138.05) v2(105.46,137.26)
VCCIO_PG: length 75.4
  TOP w0.102: PQ46.D 117.25,153.16 v1(116.62,153.16) ; PU13.3 141.38,194.5 PR202.2 PC181.1 140.24,194.36 140.77,193.83 140.77,191.87 140.46,191.55 139.54,191.55 137.99,190 129.75,190 129.48,190.26 125.8,190.26 125.45,189.92 120.53,189.92 117.6,186.99 117.6,163.76 110.68,156.83 110.68,156.08 v1(109.96,155.37)
  BOTTOM w0.102: v1(116.62,153.16) 116.11,153.67 115.08,153.67 v2(114.21,154.55) 113.38,155.37 v1(109.96,155.37)
VCCIO_SENSE: length 64.4
  TOP w0.102: CPU.AF4 149.51,142.37 148.95,141.82 145.61,141.82 145.25,142.18 144.63,142.18 142.64,144.16 142.02,144.16
  TOP w0.254: PR223.2 112.62,140.78 112.2,141.2 v1(112.05,141.2) ; v1(116.19,129.67) 120.08,129.67 130.54,140.13 133.57,140.13 137.6,144.16 142.02,144.16
  BOTTOM w0.254: v1(116.19,129.67) 116.19,130.4 116.47,130.68 116.72,130.68 121.85,135.82 121.85,139.7 120.99,140.56 v2(120.12,140.56) 119.84,140.84 112.41,140.84 v1(112.05,141.2)
VCCK_V12: length 13
  TOP w0.254: CG22.2 147.38,227.58 148.3,226.67 RTK_VGA.25 ; 152.45,228.35 152.18,228.08 RTK_VGA.19
  TOP w0.508: CG22.2 146.29,227.76 146.01,228.04 v1(146.01,228.24)
  BOTTOM w0.508: v1(152.69,231.78) 151.54,230.63 148.39,230.63 v1(146.01,228.24)
VCCOPC_R: length 2.3
  BOTTOM w0.102: 175.3,139.66 175.65,139.32 v1(175.78,139.32) ; R6639.1 176.46,140.03 v2(176.57,139.91)
  BOTTOM w0.254: R6639.1 175.3,139.66
VCCPGPPA: length 10.8
  TOP w0.254: v1(48.19,119.87) 48.19,120.11 U4.BA31
  TOP w0.508: R6566.1 40.36,119.25 C1678.1 v1(41.05,119.19)
  BOTTOM w0.254: v1(48.19,119.87) 47.55,119.24 v2(47.47,119.24) 45.25,119.24 44.33,118.31 42.76,118.31 42.39,118.68 41.37,118.68 41.05,119 v1(41.05,119.19)
VCCPGPPCD_BA45:
  vias: v1(46.62,112.29)
VCCPLL_OC_R: length 4.2
  TOP w0.508: R6500.1 155.31,141.86 v1(155.13,141.67) 154.08,140.63 CPU.AJ9
VCCPRIM_AL22: length 19.1
  TOP w0.254: U4.AL22 52.87,124.5 v3(52.83,124.5) ; v1(58.07,111.12) 58.33,110.87 RP36.1
  BOTTOM w0.254: v1(58.07,111.12) 58.07,116.97 57.69,117.35 57.69,119.89 56.7,120.88 v2(54.36,120.88) 53.91,120.88 53.19,121.6 53.19,124.14 v3(52.83,124.5)
VCCPRIM_BE3:
  vias: v1(42.15,137.92)
VCCSA_SENSE: length 153.3
  TOP w0.102: CPU.AD5 150.39,144.2 149.99,144.6 v1(149.97,144.6)
  TOP w0.254: v1(104.43,129.16) 106.94,126.64 115.3,126.64 116.14,125.81 116.14,123.75 115.73,123.34 v1(115.73,123.24) ; v1(110.68,154.31) 110.68,154.79 111.46,155.57 111.46,156.65 118.34,163.53 118.34,177.16 119.26,178.07 119.26,186.15 v1(120.58,187.47) 122.34,189.23 125.74,189.23 126.08,189.58 129.2,189.58 129.46,189.31 138.27,189.31 139.83,190.87 140.89,190.87 141.32,190.43 143.03,190.43 PR208.1
  BOTTOM w0.254: v1(149.97,144.6) 148.83,145.75 138.03,145.75 115.73,123.44 v1(115.73,123.24) ; v1(110.68,154.31) 110.14,154.31 109.58,153.75 109.58,148.45 106.76,145.63 106.76,143.56 109.61,140.71 109.61,137.15 108.52,136.06 108.52,134.98 107.25,133.71 107.25,132.18 104.43,129.36 v1(104.43,129.16)
VCCSOKET: length 44.1
  TOP w0.203: CPU.C38 182.8,162.47 v3(183.23,162.04) ; PR149.1 v1(212.28,183.55)
  BOTTOM w0.102: v3(183.23,162.04) 182.91,162.35 182.91,166.8 183.45,167.34 183.45,167.46
  BOTTOM w0.203: 183.45,167.46 183.45,167.89 187.92,172.36 189.21,172.36 194.39,177.55 196.38,177.55 196.76,177.16 206.87,177.16 211.11,181.41 211.11,182.5 212.15,183.55 v1(212.28,183.55)
VCCSPI: length 9.5
  TOP w0.406: v1(39.32,114.01) 39.32,114.18 40.07,114.94 RA14.2
  TOP w0.508: RA13.2 RA10.2 RA11.2 RA14.2
  BOTTOM w0.406: v1(39.32,114.01) 39.82,113.5 40.72,113.5 41.83,112.4 v2(43.04,112.4) v1(43.98,112.4)
VCCST_PWRGD_1V: length 44.6
  TOP w0.102: CPU.U2 v1(147.23,151.05) 146.56,151.05 146.44,150.93 145.6,150.93 144.67,151.86 141.57,151.86 139.13,154.31 127.54,154.31 123.12,149.89 123.12,144.59 122.15,143.62 121.28,142.75 120.37,142.75 R6298.1 R6296.1 119.22,141.6 118.4,141.6 118.02,141.22 116.56,141.22 R6546.1
VDD10: length 6.4
  TOP w0.203: RTK_LAN.3 111.25,229.99 111.51,230.25 ; 113.57,227.84 113.54,227.8 RTK_LAN.30
  TOP w0.508: 111.51,230.25 112.66,231.39 CL46.1 ; 113.57,227.84 CL45.1 v1(115.29,228.57)
  vias: v1(115.02,231.55) v1(115.73,231.52) v1(120.38,222.73) v1(120.43,224.41) v1(120.43,223.77)
VDD_DAC_33: length 1.6
  TOP w0.254: CG20.2 154.9,223.17 RTK_VGA.9
  vias: v1(154.54,222.35)
VDDA_1P5V: length 41.8
  TOP w0.381: v1(51.72,194.44) 52.38,194.44 53.25,195.3 54.3,195.3 BRIDGE.F13
  TOP w0.406: 54.14,197.36 54.17,197.4 BRIDGE.H13
  TOP w0.508: 54.14,197.36 53.79,197.7 52.01,197.7 v1(51.85,197.87) ; v1(51.72,194.44) 51.21,193.93 CK6.1 CK1.1 CK4.1 ; v1(53.6,183.26) 53.63,183.23 53.63,181.14 55.82,178.94 57.29,178.94 57.69,179.35 61.65,179.35 65.18,182.88 FBK1.2
  BOTTOM w0.508: 51.09,197.36 51.09,195.07 v1(51.72,194.44) 50.55,193.27 50.55,189.38 51.21,188.72 v2(51.21,187.07) 51.21,185.64 v1(53.6,183.26)
  vias: v1(51.85,197.23)
VDDA_3P3V: length 4.3
  TOP w0.381: BRIDGE.D13 54.33,194.2 v1(54.1,193.97) 52.87,192.74 52.87,190.93
VDDQ_SN: length 2.9
  TOP w0.102: PR47.1 205.98,70.48 v1(206.38,70.08)
  TOP w0.508: PR47.1 205.27,69.95 205.57,69.65 PC37.2
VDDQ_VTT_REFEN: length 17.7
  TOP w0.254: PU3.3 158.47,70.48 PR53.2 PR55.1 v1(159.55,71.12) ; PQ20.3 152.04,65.28 151.59,65.72 PC49.1 150.68,65.95 v1(150.68,67.08)
  BOTTOM w0.254: v1(150.68,67.08) 150.68,67.56 151.32,68.2 153.14,68.2 153.27,68.07 155.35,68.07 158.4,71.12 v1(159.55,71.12)
VSS_AB10: length 10.4
  TOP w0.089: U4.AB10 v1(58.5,131.52)
  TOP w0.102: RP34.1 61.69,139.89 v1(60.99,139.19)
  BOTTOM w0.089: v1(58.5,131.52) 59.4,132.42 v2(59.4,133.12) 59.4,135.84 60.49,136.93 60.49,137.95
  BOTTOM w0.102: 60.49,137.95 60.49,138.68 v1(60.99,139.19)
VSS_AB11: length 10.6
  TOP w0.089: v1(58.53,130.83) 58.04,130.35 U4.AB11
  TOP w0.102: RP35.1 61.69,138.87 v1(60.99,138.18)
  BOTTOM w0.089: v1(58.53,130.83) 59.15,131.45 59.15,131.71 60.15,132.71 v2(60.15,135.02) 59.75,135.43 59.75,135.89 60.99,137.13 60.99,137.95
  BOTTOM w0.102: 60.99,137.95 v1(60.99,138.18)
VSSGT_SENSE: length 62.5
  TOP w0.203: v1(226.22,180.85) 226.25,180.82 228.23,180.82 231.3,183.9 PR153.1
  TOP w0.305: CPU.F38 v3(183.25,160.2)
  BOTTOM w0.102: v3(183.25,160.2) 183.25,159.99 183.6,159.64 185.08,159.64 186.15,160.71 186.7,160.71 187.04,161.05
  BOTTOM w0.203: 187.04,161.05 187.36,161.37 187.36,166.3 190.35,169.29 191.12,169.29 194.84,173.02 196.6,173.02 197.83,174.24 209.13,174.24 213.32,178.44 214.23,178.44 215.88,180.09 225.46,180.09 v1(226.22,180.85)
VSSSAIO_SENSE: length 141.7
  TOP w0.102: CPU.AE4 149.09,142.87 149.09,142.24 148.87,142.02 145.7,142.02 145.33,142.38 144.78,142.38 142.62,144.55 142.02,144.55
  TOP w0.254: v1(110.14,153.54) 110.14,154.81 111.08,155.75 111.08,156.81 117.96,163.69 117.96,177.31 118.88,178.23 118.88,186.72 121.78,189.61 125.58,189.61 125.92,189.96 129.36,189.96 129.62,189.69 138.11,189.69 139.67,191.25 PJP19.2 ; v1(116.7,130.18) 116.82,130.05 119.92,130.05 130.39,140.51 133.34,140.51 137.38,144.55 142.02,144.55
  BOTTOM w0.254: v1(116.7,130.18) 116.75,130.18 122.23,135.66 122.23,139.86 120.87,141.22 112.81,141.22 112.3,141.73 v2(110.17,141.73) 109.13,141.73 107.14,143.71 107.14,145.47 110.09,148.42 110.09,153.49 v1(110.14,153.54)
VSSSOKET: length 45
  TOP w0.203: CPU.D38 v3(182.35,162.03) ; v1(212.25,184.53) 212.63,184.15 PR148.1
  BOTTOM w0.102: v3(182.35,162.03) 182.66,162.34 182.66,167.46
  BOTTOM w0.203: 182.66,167.46 182.66,167.64 187.71,172.69 189.08,172.69 194.26,177.88 196.51,177.88 196.89,177.5 206.73,177.5 210.47,181.24 v2(210.47,181.74) 210.47,182.75 v1(212.25,184.53)
1P0V_PCH_BOOT_25: length 3.5
  TOP w0.254: PU5.20 63.16,80.13
  TOP w0.635: 63.16,80.13 62.19,81.1 PC64.1 62.09,81.1 v1(61.39,81.8)
1P0V_PCH_EN: length 4.6
  TOP w0.254: PU5.2 65.45,77.48 64.98,77.01 v1(64.98,76.81) 64.33,76.81 PC262.1 PR70.2 64.3,75.25 64.3,74.44
1P0V_PCH_FB: length 4.5
  TOP w0.254: PU5.5 66.95,77.48 67.13,77.3 67.13,76.88 66.71,76.45 PR74.1 PR75.2 66.96,75.44 v1(67.34,75.82) 67.72,75.44 PR73.1
1P0V_PCH_FB_R: length 2.5
  TOP w0.102: v1(70.31,75.08) 69.96,75.44 PR73.2
  TOP w0.254: PJP4.1 PR73.2
1P0V_PCH_PG: length 4.7
  TOP w0.254: PC62.1 PR68.2 62.25,76.77 v1(63.18,77.7) 63.37,77.9 PU5.1
1P0V_PCH_PHASE:
  vias: v1(64.55,85.98) v1(65.31,85.34) v1(65.31,84.33) v1(65.44,80.77) v1(66.33,86.36) v1(66.45,80.77) v1(67.47,86.36) v1(67.47,80.77) v1(68.74,86.36) v1(69.76,85.22)
1P0V_PCH_SS: length 3.9
  TOP w0.254: PU5.23 62.92,78.63 62.8,78.51 v1(61.35,78.51) 61.35,78.19 PC72.1
1P0V_PCH_TON: length 2
  TOP w0.254: PR67.1 68.61,77.85 v1(68.56,77.8) 68.47,77.9 PU5.6
1P0V_PCH_VCCDSW: length 10.4
  TOP w0.254: v1(49.28,120.95) 49.03,120.95 U4.BA29 ; C1645.1 v1(41.69,119.19)
  BOTTOM w0.254: v1(49.28,120.95) v2(48.48,120.95) 47.73,120.21 45.71,120.21 44.2,118.69 43.39,118.69 42.9,119.19 v1(41.69,119.19)
1P0V_PCH_VCCF24_FB_R: length 3.5
  TOP w0.152: U4.K2 63.74,134.61 63.65,134.52 U4.K3
  TOP w0.254: U4.K2 63.74,135.15
  TOP w0.305: 63.74,135.15 63.74,136.05 64.14,136.45 64.14,136.9 64.7,137.46
  vias: v1(64.83,137.77)
1P0V_PCH_VIN: length 2.5
  TOP w0.254: PU5.22 63.8,79.13 63.68,79.01 61.93,79.01 PC61.1
  vias: v1(65.44,79.25) v1(66.45,79.25) v1(67.47,79.25) v1(73.06,78.03)
1P0V_VCCAMPHYPLL_FB_R:
  vias: v1(69.46,111.47)
1P0V_VCCAPLL_FB_R: length 23.3
  TOP w0.152: v1(53.23,126.69) 52.91,126.69 52.45,126.23 U4.AN19
  BOTTOM w0.254: v1(53.23,126.69) 53.23,129.43 52.28,130.38 52.28,132.56 v1(52.66,132.94)
  BOTTOM w0.508: v1(54.82,145.67) 54.82,144.02 v2(53.02,142.22) 50.83,140.03 50.83,137.21 50.66,137.03 50.66,135.48 52.66,133.48 v1(52.66,132.94)
+1P0V_PCH_AUX: length 493.2
  TOP w0.152: U4.R17 61.12,126.88 v3(61.07,126.84) ; U4.AC23 v1(56.92,124.07) U4.AE23 ; v1(57.7,122.52) U4.AA28 ; U4.AA26 v1(58.47,123.3) U4.Y25 ; v1(56.92,122.52) U4.AC28 ; v3(61.27,125.67) U4.R19 ; v1(59.25,127.17) U4.V17 ; U4.AJ20 v1(54.6,125.62) U4.AJ21 v1(54.6,124.85) U4.AJ23 v1(54.6,124.07) U4.AJ25 ; U4.AC26 v1(57.7,123.3) ; U4.U20 v1(60.02,125.62) ; U4.V28 v1(59.25,121.75) ; v1(60.02,123.3) U4.U25 ; U4.AE26 v1(56.92,123.3) ; v1(59.25,122.52) U4.V26 ; U4.U23 v1(60.02,124.07) ; U4.U26 v1(60.02,122.52) ; v1(60.02,124.85) U4.U21 ; v3(61.98,128.11) U4.N17 ; U4.AA23 v1(58.47,124.07) U4.Y23
  TOP w0.203: v1(59.14,79.43) 59.06,79.5 59.06,81.76 62.77,85.47 62.77,89.92 62.26,90.42 62.26,94.62 62.64,95
  TOP w0.254: v3(56.1,128.42) 56.25,128.27 U4.AD15 ; R87.1 129.28,208.01 v1(129.28,208.53) ; v3(56.92,127.17) U4.AC17 ; v1(68.04,77.14) PJP4.2 ; RS21.1 47.92,90.44 49.23,89.13 57.13,89.13 57.23,89.03 v1(60.23,89.03) ; v1(74.96,77.32) 74.96,84.66 74.1,85.52 74.1,88.87 PC67.1 ; v1(86.62,76.91) 86.19,76.48 86.19,71.12 95.64,61.67 127.64,61.67 v1(130.93,58.38)
  TOP w0.356: QO2.4 200.7,48.91 v1(200.51,49.09)
  TOP w0.508: v3(130.52,194.58) 131.22,195.28 R118.2 ; v1(87.66,127.63) 87.66,126.85 88.83,125.68 88.83,115.04 84.87,111.07 v1(84.87,109.26) ; v1(102.4,154.81) 104.02,156.44 104.96,156.44 113.49,164.97 113.49,172.82 108.24,178.08 108.24,193.36 114.33,199.45 RH1.2 115.32,199.81 115.32,201.93 115.83,202.44 v1(116.11,202.44) ; v1(93.43,105.59) 93.43,105.08 93.99,104.52 101.13,104.52 v1(101.35,104.29) ; CS97.1 64.98,104.12 v1(64.64,104.12) ; v1(136.56,201.8) 134.88,203.48 134.88,205.09 R119.2 ; v1(126.4,208.74) 125.48,209.65 v1(123.48,209.65) ; CS111.1 61.18,91.51 v1(60.61,92.07) ; R6513.1 101.42,97.41 v1(101.17,97.16) 101.17,96.81 PQ23.D ; C1668.1 63.99,143.13 L62.1 64.3,143.18 C1677.1 64.3,144.81 62.26,146.84 62.26,148.62 61.88,149 60.03,149 59.47,149.56 58.53,149.56 58.35,149.38 56.93,149.38 56.52,148.97 C1679.1 55.09,148.65 54.39,147.95 L60.1 v1(53.35,147.75) ; RP36.2 58.78,108.92 v1(59.22,109.35)
  TOP w0.889: PCE7.1 63.3,95.88 ; PCE7.1 64.24,94.95 ; PCE7.1 65.18,95.88 ; PCE7.1 64.24,96.82
  BOTTOM w0.254: v1(63.15,90.3) 61.5,90.3 v1(60.23,89.03) ; v1(136.56,201.8) 136.05,202.31 133.31,202.31 132.92,201.92 130.75,201.92 130.36,202.31 130.36,203.92 129.09,205.19 129.09,207.72 129.28,207.9 v1(129.28,208.53) ; v1(59.14,79.43) 59.39,79.17 61.66,79.17 62.24,78.59 63.63,78.59 64.57,77.65 67.53,77.65 v1(68.04,77.14) ; v1(86.62,76.91) 85.78,76.07 76.21,76.07 v1(74.96,77.32) ; v1(130.93,58.38) 131.81,57.49 141.47,57.49 144.39,60.41 147.01,60.41 147.55,59.87 155.53,59.87 156.09,60.43 165.38,60.43 165.55,60.6 179.85,60.6 180.85,59.59 192.08,59.59 196.6,55.07 197.27,55.07 200.39,51.95 200.39,49.22 v1(200.51,49.09)
  BOTTOM w0.508: v1(123.48,209.65) 121.72,209.65 117.61,205.54 117.61,203.94 v1(116.11,202.44) ; v1(87.66,127.63) v2(91.35,127.63) 92.1,128.38 92.1,128.74 93.43,130.07 95.12,130.07 95.91,129.29 99.44,129.29 99.95,129.79 103.41,129.79 106,132.38 106,133.78 107.42,135.2 107.42,136.45 108.69,137.72 108.69,140.36 105.87,143.18 105.87,146.05 108.67,148.84 108.67,153.49 107.35,154.81 v1(102.4,154.81) ; v1(93.43,105.59) 92.82,106.2 92.82,108.48 91.78,109.52 89.03,109.52 88.32,108.81 87.71,108.81 86.9,108 86.13,108 v1(84.87,109.26) 81.29,109.26 79.71,107.67 73.72,107.67 v1(72.55,108.84) ; v1(51.85,143) 52.9,143 54.14,144.23 54.14,146.96 v1(53.35,147.75) ; v1(129.28,208.53) 129.08,208.74 v1(126.4,208.74) 126.4,208.43 125.94,207.98 124.29,207.98 123.59,207.28 123.59,207.28 121.03,204.72 121.03,204.69 119.97,203.63 119.97,197.03 122.05,194.94 126.91,194.94 128.18,193.68 129.88,193.68 130.52,194.32 v3(130.52,194.58)
  BOTTOM w0.559: 100.67,99.09 100.67,103.61 v1(101.35,104.29)
  vias: v1(64.17,94.74) v1(64.3,97.03) v1(65.31,95.88) v1(66.33,92.58) v1(66.33,89.15) v1(67.47,92.58) v1(67.47,89.15) v1(68.74,92.58) v1(68.74,89.15) v1(68.87,96.9) v1(68.87,96.14) v1(68.87,95.38) v1(68.87,94.23) v1(68.87,93.47) v1(71.03,109.73) v1(71.18,111.12) v1(71.81,111.2) v1(71.79,108.28) v1(72.32,110.77) v1(100.52,97.21)
+1P0V_PCH_SN:
  vias: v1(73.44,87.25)
+1P0V_VCCST: length 790.6
  TOP w0.102: CPU.V4 149.75,149.93 150.18,149.93 CPU.V5
  TOP w0.203: v1(135.08,209.22) 135.08,208.52 R6680.1 ; RO12.1 224.63,30.1 223.05,30.1 222.79,30.35 222.79,33.59 CO12.2 223.16,34.1 221.69,35.56 SIO_5553.29 221.69,38.4
  TOP w0.254: R117.1 131.99,208.61 131.8,208.8 131.8,209.31 v3(131.55,209.55) ; v1(132.88,209.8) 132.88,210.2 130.49,212.58 115.25,212.58 112.22,209.56 112.22,201.89 95.33,185 95.33,164.83 99.12,161.05 99.12,156.11 v1(98.45,155.44) ; v1(135.03,179.45) 135.1,179.45 R51.1 ; R116.1 120.2,192.35 119.54,192.35 C70.1 118.46,192.6 v3(118.15,192.28) ; v1(220.15,41.07) 220.15,40.36 221.69,38.82 221.69,38.4 ; v1(115.55,124.26) 115.55,125.63 114.92,126.26 106.43,126.26 v1(103.67,129.03) ; v1(224.86,179.59) 228.65,179.59 229.57,180.52 v1(232.75,180.52) ; v1(232.61,74.45) 231.92,75.13 231.92,85.53 230.42,87.03 229.27,87.03 227.06,89.24 227.06,92.71 224.84,94.92 224.84,103.09 228.18,106.43 228.18,116.92 222.49,122.61 222.49,131.57 226.09,135.18 v1(226.09,136.52)
  TOP w0.356: CPU.V5 v3(150.88,149.23) CPU.V6
  TOP w0.381: R6585.1 55.41,143.76 53.37,145.8 v1(53.37,146.05) ; v1(40.9,85.52) 41.89,85.52 44.28,87.91 47.86,87.91 49.16,86.61 54.77,86.61 55.43,85.95 56.29,85.95 v1(56.88,85.37) ; RS227.1 46.52,145.54 v1(46.77,145.8) ; v1(86.11,87.48) 89.19,87.48 90.48,88.77 90.48,90.63 94.99,95.14 94.99,97.33 95.4,97.74 96.61,97.74 97.16,97.19 97.16,96.57 97.85,95.88 98.33,95.88 PQ23.S
  TOP w0.508: R52.1 R9.1 R7.1 R8.1 197.85,173.43 v1(197.14,172.72) ; PR130.1 PR131.2 PR132.2 PR69.2 223.93,180.52 PC93.1 v1(224.86,179.59) ; PQ23.S 98.52,95.12 101.63,95.12 102.52,96.01 103.15,96.01 PR49.1
  BOTTOM w0.254: v1(135.03,179.45) 135.03,180.94 134.42,181.55 134.42,187.11 130.91,190.62 130.48,190.62 129.97,191.13 121.52,191.13 120.57,192.09 118.35,192.09 v3(118.15,192.28) 117.3,193.13 117.3,202.06 119.57,204.32 119.57,205.31 121.9,207.64 122.91,207.64 124.57,209.3 131.3,209.3 v3(131.55,209.55) 131.81,209.8 v1(132.88,209.8) 134.5,209.8 v1(135.08,209.22) ; v1(98.45,155.44) 98.56,155.33 107.6,155.33 108.52,154.41 109.2,153.73 109.2,148.61 106.38,145.79 106.38,143.4 109.23,140.55 109.23,137.31 108.14,136.22 108.14,135.14 106.87,133.87 106.87,132.34 103.67,129.14 v1(103.67,129.03) ; v1(232.61,74.45) 232.89,74.16 232.89,63.78 231.15,62.03 231.15,49.02 231.43,48.74 231.43,45.52 229.73,43.81 226.73,43.81 226.04,43.13 222.77,43.13 220.71,41.07 v1(220.15,41.07) ; v1(226.09,136.52) 226.09,138.3 227.74,139.95 229.55,139.95 230.56,140.97 230.56,141.93 234.2,145.56 234.2,154.41 233.28,155.32 232.57,155.32 231.58,156.31 231.58,158.4 233.79,160.61 233.79,179.48 v1(232.75,180.52)
  BOTTOM w0.381: v1(40.9,85.52) 40.9,87.91 38.27,90.54 38.27,91.81 37.04,93.04 37.04,99.01 34.45,101.6 31.29,101.6 30.49,102.4 28.31,102.4 22.2,108.51 22.2,112.07 26.08,115.95 26.58,115.95 26.97,116.34 26.97,124.68 26.66,124.98 26.66,131.05 27.02,131.4 27.02,131.64 27.02,131.64 27.02,134.39 31.29,138.66 34.7,138.66 35.61,139.56 36.34,139.56 39.66,142.88 39.66,143.76 40.29,144.4 40.29,145.81 39.66,146.44 39.66,148.45 40.05,148.84 40.05,150.51 45.43,155.89 49.25,155.89 50.99,154.15 50.99,148.44 v1(53.37,146.05) 53.12,145.8 v1(46.77,145.8) ; v1(56.88,85.37) 58,86.49 58,87.6 62.01,91.62 79.84,91.62 82.81,88.65 85,88.65 86.11,87.53 v1(86.11,87.48)
  BOTTOM w0.508: 150.84,146.5 152.43,144.91 152.97,144.91 153.42,144.46 153.86,144.46 154.32,144 154.32,141.3 154.83,140.79 155.35,140.79 156.49,139.65 156.49,139.36 157.23,138.62 157.95,138.62 158.3,138.96 167.06,138.96 167.25,139.14 167.66,139.14 168.16,139.65 168.47,139.65 169.15,140.33 169.15,141.57 172.32,144.75 172.32,153.12 173.21,154.01 177.08,154.01 177.63,154.56 177.63,157.27 178.62,158.25 178.62,158.53 179.21,159.13 186.22,159.13 187.84,160.76 187.84,166.1 190.55,168.81 191.32,168.81 195.04,172.53 196.95,172.53 v1(197.14,172.72) 197.81,173.39 v2(200.73,173.39) 201.07,173.74 209.51,173.74 212.53,176.76 214.84,176.76 215.27,177.19 216.09,177.19 216.89,176.38 217.87,176.38 219.79,178.31 222.52,178.31 223.29,179.07 224.34,179.07 v1(224.86,179.59)
  BOTTOM w0.838: 146.73,147.02 138.31,147.02 v1(115.55,124.26) 114.61,123.32 114.61,122.69 113.66,121.75 110.49,121.75 103.03,114.29 103.03,105.79 103.75,105.07 v1(103.75,100.86) v1(103.75,100.02)
  vias: v3(151.78,149.22)
+1P2V_VDDQ_BOOT_20:
  vias: v1(211.41,68.3)
+1P2V_VDDQ_BOOT_R20: length 2.8
  TOP w0.508: v1(209.15,67.22) 208.69,67.68 PR40.2 PC36.1
+1P2V_VDDQ_CS: length 3.2
  TOP w0.203: PR48.1 215.87,68.98 v1(215,69.86) 215,70.05 214.05,71 PU2.2
+1P2V_VDDQ_EN: length 9.8
  TOP w0.203: PQ19.D2 220.89,71.52 220,70.63 v1(220,70.1) 218.8,70.1 218.41,70.48 216.6,70.48 215.96,69.85 PR42.2 215.87,70.38 215.63,70.61 215.11,70.61 214.22,71.5 PU2.3
+1P2V_VDDQ_FB: length 5.3
  TOP w0.254: PR51.1 PR50.1 PC41.1 PR52.1 215.71,71.12 v1(215.05,71.78) 214.83,72 PU2.4
+1P2V_VDDQ_FB_R: length 4.3
  TOP w0.102: v1(218.25,71) 218.25,71.98 PC42.1
  TOP w0.254: PJP2.1 PC42.1 PC41.2 PR50.2
+1P2V_VDDQ_LG_30: length 9.4
  TOP w0.508: PQ17.4 202.69,74.36 v1(202.73,74.4)
  BOTTOM w0.508: v1(210.6,73.03) 210.35,72.77 207.17,72.77 205.54,74.4 v1(202.73,74.4)
+1P2V_VDDQ_PHASE_20: length 10.6
  TOP w1.27: PL2.1 192.4,67.37 ; PL2.1 194.81,67.37 ; PL2.1 193.6,68.58
  BOTTOM w0.508: v1(202.6,68.63) 206.07,68.63 207.82,70.38 v1(207.82,71.37)
  vias: v1(191.93,72.52) v1(192.06,73.91) v1(192.06,70.99) v1(192.06,69.22) v1(192.06,67.18) v1(193.71,73.91) v1(193.71,72.52) v1(193.71,70.99) v1(193.71,69.22) v1(195.23,67.06) v1(195.87,73.91) v1(195.87,72.52) v1(195.87,70.99) v1(195.87,69.22) v1(197.52,73.28) v1(197.52,71.88) v1(197.52,70.23) v1(199.17,73.28) v1(199.17,71.86) v1(199.17,70.23) v1(200.82,73.28) v1(200.82,71.75) v1(200.82,70.23)
+1P2V_VDDQ_RF: length 2.3
  TOP w0.102: PR46.2 214.23,73.91 v1(214.51,73.64)
  TOP w0.254: PU2.5 213.65,72.77 213.71,72.83 213.71,73.15
  TOP w0.508: 213.71,73.15 PR46.2
+1P2V_VDDQ_UG_20: length 7.4
  TOP w0.508: PR44.1 v1(206.41,65.91)
  BOTTOM w0.508: v1(209.75,70.79) 209.75,70.53 206.41,67.18 v1(206.41,65.91)
+1P2V_VDDQ_UG_R20: length 9.1
  TOP w0.508: v1(202.6,66.87) PR45.1 204.44,66.87 PR44.2 ; PQ15.4 v1(197.52,69.02)
  BOTTOM w0.508: v1(197.52,69.02) 200.63,69.02 202.6,67.06 v1(202.6,66.87)
+1P2V_VDDQ_VCC:
  vias: v1(208.45,73.72)
+1P2V_VDDQ_VIN: length 3.8
  TOP w0.889: 172.07,62.74 PCE1.1 ; PCE1.1 171.13,61.8 ; PCE1.1 170.19,62.74 ; PCE1.1 171.13,63.68
  vias: v1(169.2,63.37) v1(169.2,62.1) v1(170.09,63.37) v1(170.09,62.1) v1(172.63,63.37) v1(172.63,62.1) v1(176.44,63.37) v1(176.44,62.1) v1(185.81,65.48) v1(186.57,64.52) v1(187.21,65.48) v1(188.09,64.52) v1(188.6,65.48) v1(189.49,64.52) v1(190.13,65.48) v1(191.14,64.52) v1(191.65,65.48) v1(192.46,64.54) v1(193.84,65.41) v1(194.22,64.39) v1(195.11,65.41) v1(196.63,64.9) v1(196.63,63.88) v1(197.65,66.17) v1(197.65,64.77) v1(197.65,63.12) v1(199.3,66.17) v1(199.3,64.75) v1(199.3,63.12) v1(200.95,66.17) v1(200.95,64.64) v1(200.95,63.12) v1(202.22,62.74) v1(202.34,63.75)
+1P5V_VA:
  vias: v1(197.45,20.38)
+1P5V_VA_ADJ:
  vias: v1(201.81,20.16)
+3P3V_AUX: length 1036.7
  TOP w0.203: v1(130.46,191.41) 130.36,191.52 130.36,193.36 131.36,194.36 131.64,194.36 132.42,195.14 R86.1 ; R6619.1 v1(77.41,219.9) ; U4.BA20 48.22,126.39 v1(48.22,126.82) ; SIO_5553.27 220.89,35.57 220.89,35.56 ; U4.AN5 v1(51.58,132.91)
  TOP w0.254: v1(55.02,115.82) 54.72,115.52 U4.AJ41 ; v1(147.2,210.79) 153.4,210.79 154.01,211.4 154.01,215.52 160.99,222.5 163.23,222.5 164.5,223.77 168.84,223.77 169.68,224.61 172.19,224.61 174.02,222.78 184.61,222.78 187.41,225.58 190.3,225.58 191.17,226.44 191.17,231.76 RG22.1 ; v1(94.52,215.01) 93.18,215.01 87.52,220.67 84.65,220.67 83.75,219.77 79.9,219.77 79.13,219 78.31,219 v1(77.41,219.9) ; v1(130.46,191.41) 131.73,191.41 132.04,191.72 136.23,191.72 137.47,192.96 137.47,204.24 138.13,204.9 138.13,206.81 137.47,207.47 137.47,208.43 134.53,211.38 134.53,211.58 v1(133.89,212.22) ; U4.AD41 56.65,115.52 v1(57.2,116.07) ; v1(52.74,115.32) 53,115.57 U4.AL41 ; PR279.1 106.14,66.29 105.32,66.29 102.27,63.25 v1(102.27,62.89) ; R6665.1 217.65,128.75 221.53,124.86 221.53,122.42 227.32,116.63 227.32,106.65 224.08,103.41 224.08,94.61 226.3,92.39 226.3,88.93 228.95,86.27 230.06,86.27 230.84,85.49 230.84,77.21 229.84,76.21 v1(229.84,75.81) ; v3(126.53,191.77) 125.96,191.77 R88.1
  TOP w0.33: R6649.1 42.32,123.63 R6413.1 42.39,123.7 C1689.2
  TOP w0.381: BRIDGE.J11 v1(56,198.59) ; v1(92.41,136.14) 92.41,144.12 90.81,145.73 90.81,147.21 88.89,149.13 87.4,149.13 85.94,150.59 80.4,150.59 77.84,153.16 77.84,155.6 71.85,161.59 70.59,161.59 70.1,162.08 68.76,162.08 66.87,163.97 53.08,163.97 51.01,161.9 48.72,161.9 48.32,161.51 v1(48.01,161.51) ; v1(97.57,139.57) 97.67,139.67 99.67,139.67 100.34,140.34 101.48,140.34 101.68,140.14 PR15.2 102.27,140.78 PR216.1
  TOP w0.406: QO4.1 201.31,50.55 v1(200.95,50.55)
  TOP w0.457: v1(52.74,90.17) 52.42,90.49 RH5.1 ; R6391.1 35.42,127.75 v1(35.42,127.66)
  TOP w0.508: v1(226.6,62.36) 226.35,62.61 217.08,62.61 216.19,63.5 211.73,63.5 203.09,54.86 200.69,54.86 v1(199.61,53.78) 197.16,51.33 197.16,42.21 199.3,40.08 200.13,40.08 205.09,35.12 RO39.1 206.15,33.48 207.93,31.7 v1(207.93,28.57) ; v1(226.6,62.36) 225.69,61.45 223.53,61.45 222.91,60.83 219.24,60.83 v1(218.98,60.58) 218.92,60.52 RO163.1 RO80.1 218.98,58.99 R508.1 ; v1(226.6,62.36) 230.16,62.36 v1(231.68,60.83) ; v1(47.18,103.1) 47.18,103.72 R71.2 ; PR68.1 62.47,75.88 62.79,75.56 PR70.1 63.09,75.44 v1(63.54,74.99) ; C1689.2 43.34,124.59 v1(43.85,125.09) ; v1(216.06,61.09) RO55.1 ; v1(160.31,60.93) 159.01,60.93 155.61,57.53 155.61,52.49 155.35,52.23 155.35,48 153.55,46.2 RS161.1 150.02,45.96 150.02,42.7 150.67,42.05 RS222.1 RS159.1 ; 218.28,69.5 219.76,69.5 220.12,69.14 227.93,69.14 v1(229.74,70.94) ; 218.28,69.5 218.28,69.06 217.36,68.14 PR43.1 ; 218.28,69.5 217.93,69.85 PR42.1 ; v1(48.01,161.51) 47.5,161 47.5,158.65 44.71,155.85 44.71,152.61 45.88,151.43 v1(45.88,151.37) ; PR381.1 109.95,71.06 111.59,69.42 111.59,64.06 v1(110.52,62.99) ; 57.69,83.31 57.69,77.8 58.61,76.89 v1(59.09,76.89) ; 57.69,83.31 57.69,87.12 56.93,87.88 R6533.1 55.21,88.01 54.71,88.52 v1(53.75,88.52) ; 57.69,83.31 R663.1 ; v1(55.25,180.42) 55.25,180.85 54.58,181.52 RK27.1 54.26,182.31 v1(54.26,182.75) ; R112.2 54.01,103.7 v1(54.01,103.25) ; RH4.1 v1(63.79,108.33) RU46.1 ; RO179.1 v1(226.73,30.1) ; R68.1 62.69,103.77 v1(62.69,103.25) 62.69,102.86 R6618.1 ; R69.2 v1(48.55,108.08) RU174.1 ; v1(64.5,103.4) 64.5,102.81 63.99,102.3 RS129.1 ; RB7.2 RB1.1 13.5,185.23 13.5,163.99 15.61,161.87 23.54,161.87 v1(25.46,159.96) ; RH10.1 v1(65.44,108.33) R6669.1 ; RS233.1 v1(46.13,107.7) RP38.1 ; v1(129.7,63.37) 131.69,63.37 134.08,60.98 v1(134.08,60.6) ; v1(77.63,225.55) 77.02,225.55 70.87,219.41 v1(68.87,219.41) ; R99.1 v1(51.98,103.25) R105.1 ; R6604.1 v1(56.17,103.38) R6608.1 ; R6573.2 57.61,102.86 v1(57.61,103.35) 57.61,103.9 R6606.1 ; R91.1 v1(50.83,103.25) R85.1 ; RK28.1 v1(49.37,207.64) 49.37,210.5 v1(49.69,210.82) ; RO32.1 v1(232.32,48.64) ; 220.89,35.56 CO10.2 221.08,34.1 221.62,33.56 221.62,31.49 220.93,30.8 RS90.1 RS89.1 v1(218.85,29.46) ; R67.1 61.2,103.87 v1(61.2,103.24) 61.2,102.76 RP41.2 ; RP40.2 v1(54.26,108.08) RP25.2 ; RH6.2 R19.2 R6352.1 R6392.1 v1(35.59,121.92) ; CK38.1 v1(54.39,209.93) 55.85,209.93 58.04,212.12 63.31,212.12 v1(64.68,213.49) ; v1(61.2,100.97) 59.8,100.97 59.14,101.63 59.14,102.26 58.55,102.84 v1(58.55,103.33) 58.55,103.67 RS127.1 ; RX165.1 v1(66.07,215.52) ; RH8.1 60.54,107.84 v1(60.54,108.13) 60.54,108.34 60.65,108.45 60.65,108.69 RH9.1 ; R6566.2 37.37,118.8 v1(37.37,118.49) 37.28,118.4 37.28,115.03 36.77,114.53 32.97,114.53 32.61,114.89 R74.1 R77.2 32.55,116.14 C1764.2 31.31,115.93 30.5,115.93 30.02,115.44 ; C1684.2 v1(44.17,106.87) ; R104.1 49.31,102.55 v1(49.31,103.12) R100.1 ; RO187.1 v1(232.32,46.61) ; RF59.2 40.95,105.41 v1(41.23,105.69) ; v1(60.87,99.82) 62.36,99.82 63.46,100.91 64.9,100.91 66.33,102.34 v1(66.33,103.63) R6668.1
  BOTTOM w0.203: v1(130.46,191.41) 130.19,191.41 130.12,191.49 126.8,191.49 v3(126.53,191.77) ; v1(77.41,219.9) 77.46,219.95 77.46,225.39 v1(77.63,225.55) ; v1(133.89,212.22) 133.61,211.94 120.8,211.94 120.06,211.2 109.99,211.2 107.38,213.82 96.67,213.82 95.47,215.01 v1(94.52,215.01)
  BOTTOM w0.254: v1(55.02,115.82) 55.38,116.18 57.08,116.18 v1(57.2,116.07) ; v1(229.74,70.94) 229.74,75.7 v1(229.84,75.81) ; v1(147.2,210.79) 146.85,211.15 136.86,211.15 135.26,212.75 134.42,212.75 v1(133.89,212.22)
  BOTTOM w0.381: v1(97.57,139.57) 97.57,139.51 97.19,139.13 95.82,139.13 93.59,136.89 92.98,136.89 92.98,136.89 92.86,136.89 92.41,136.45 v1(92.41,136.14)
  BOTTOM w0.508: v1(62.69,103.25) 62.84,103.4 v1(64.5,103.4) 64.83,103.07 65.77,103.07 v1(66.33,103.63) 66.33,107.44 v1(65.44,108.33) v1(63.79,108.33) ; 55.04,197.21 55.04,196.25 53.27,194.49 53.27,192.28 52.93,191.93 52.93,189.42 52.15,188.65 52.15,186 54.26,183.9 v1(54.26,182.75) ; 55.04,197.21 52.99,199.26 52.99,201.4 52.23,202.16 52.23,203.24 52.67,203.67 52.67,205.06 51.22,206.5 50.52,206.5 v1(49.37,207.64) ; 55.04,197.21 56,198.17 v1(56,198.59) ; v1(53.75,88.52) 53.75,88.77 52.74,89.79 v1(52.74,90.17) 52,89.43 50.53,89.43 50.01,89.95 48.49,89.95 ; v1(226.6,62.36) 229.74,65.49 v1(229.74,70.94) ; v1(51.58,132.91) 50.83,132.91 50.3,132.38 47.02,132.38 45.37,134.04 v1(45.37,134.24) v1(44.36,135.25) 44.36,136.91 43.85,137.41 43.85,141.16 42.96,142.05 42.96,143.76 42.2,144.53 42.2,147.68 43.29,148.77 43.29,150.68 43.92,151.31 45.82,151.31 v1(45.88,151.37) ; v1(55.25,180.42) 53.81,180.42 51.95,178.56 49.43,178.56 46.21,175.34 46.21,174.59 46.21,166.93 48.06,165.07 48.06,161.56 v1(48.01,161.51) 47.87,161.51 46.24,163.14 28.65,163.14 v1(25.46,159.96) ; v1(58.55,103.33) 57.64,103.33 v1(57.61,103.35) ; v1(134.08,60.6) 134.4,60.92 147.22,60.92 147.76,60.38 155.32,60.38 155.88,60.93 v1(160.31,60.93) 165.17,60.93 165.34,61.1 180.06,61.1 181.06,60.1 192.29,60.1 196.81,55.58 197.48,55.58 199.27,53.78 v1(199.61,53.78) 200.95,52.45 v1(200.95,50.55) ; v1(43.85,125.09) 44.65,125.9 46.02,125.9 46.95,126.82 v1(48.22,126.82) ; v1(41.23,105.69) 42.98,105.69 v1(44.17,106.87) ; v1(207.93,28.57) 216.44,28.57 217.33,29.46 v1(218.85,29.46) 226.09,29.46 v1(226.73,30.1) ; v1(60.54,108.13) 60.56,108.1 60.56,106.74 60.89,106.41 60.89,105.17 61.2,104.86 v1(61.2,103.24) v1(61.2,100.97) 61.2,100.15 v1(60.87,99.82) ; v1(49.69,210.82) 49.69,210.57 50.33,209.93 52.48,209.93 53.12,210.57 53.88,210.57 54.39,210.06 v1(54.39,209.93) ; v1(59.09,76.89) 60.28,76.89 60.53,76.63 61.89,76.63 v1(63.54,74.99) 63.62,74.91 65.96,74.91 66.55,74.32 68.29,74.32 69.97,76 73.57,76 74.64,74.93 82.58,74.93 88.22,69.29 88.22,68.38 93.68,62.92 96.91,62.92 98.08,61.74 101.12,61.74 v1(102.27,62.89) 103.42,61.74 109.27,61.74 v1(110.52,62.99) 111.03,62.99 111.75,62.28 113.14,62.28 115.73,59.69 126.02,59.69 v1(129.7,63.37) ; v1(232.32,46.61) 232.32,47.75 232.23,47.84 232.23,48.56 v1(232.32,48.64) 231.68,49.28 v1(231.68,60.83) ; v1(216.06,61.09) 218.47,61.09 v1(218.98,60.58) ; v1(64.68,213.49) 66.07,214.88 v1(66.07,215.52) 66.07,216.61 v1(68.87,219.41)
  BOTTOM w1.524: 47.14,90.47 47.14,92.56 46.9,92.8 46.9,98.17 46.39,98.68 46.39,100.97
  vias: v1(38.78,85.79) v1(39.3,86.16) v1(39.33,85.44) v1(39.86,85.82) v1(40.17,129.54) v1(40.8,129.54) v1(41.23,111.11) v1(41.87,135.03) v1(42.14,111.13) v1(42.5,134.9) v1(42.7,72.09) v1(42.78,111.12) v1(43.36,72.12) v1(43.99,111.14) v1(44.05,72.12) v1(44.76,72.12) v1(46.26,102.11) v1(46.9,102.11) v1(47,89.56) v1(47,88.87) v1(47.4,101.73) v1(47.51,116.64) v1(47.68,89.59) v1(47.68,88.87) v1(47.99,115.77)
+3P3V_LPS_LDO: length 11.5
  TOP w0.203: v1(47.02,50.29) 47.14,50.41 PU16.6 ; 45.63,49.89 PU16.3
  TOP w0.254: 45.63,49.89 45.63,48.82 45.37,48.56 PC338.1 44.86,47.68 v1(44.86,48.13) ; v1(43.98,49.4) 43.66,49.09 43.09,49.09 PR275.2
  BOTTOM w0.254: v1(47.02,50.29) 45.5,50.29 v2(44.99,49.78) 44.61,49.4 v1(43.98,49.4) 43.96,49.39 43.96,49.03 v1(44.86,48.13)
+3P3V_MAIN: length 1036.1
  TOP w0.102: M.2_SSD.2 113.14,131.93 RM6.1 112.64,131.98 M.2_SSD.4
  TOP w0.152: v1(57.04,129.96) 56.67,129.59 U4.AD13
  TOP w0.203: CO3.2 211.42,36 211.69,36.27 SIO_5553.4
  TOP w0.254: U136.B2 231.61,239.58 231.3,239.27 ; CG19.2 152.32,220.66 152.32,220.98 151.9,221.4 151.9,221.67 151.68,221.88 RTK_VGA.5 ; UF2.9 18.98,157.96 18.77,158.18 CF103.1 ; UF2.20 21.75,152.46 CF104.1 ; v1(61.12,141.6) 61.63,142.11 C1646.2 ; 151.68,228.87 RTK_VGA.20
  TOP w0.381: BRIDGE.H3 63.18,197.78 63.18,197.79 v1(63.19,197.79) ; v1(59.6,182.75) RK48.2 CK39.1 ; v1(57.56,181.86) 57.5,181.93 CK46.1 57.56,182.56 RK22.1 ; RK47.2 v1(59.6,185.17) ; v1(21.94,151.57) 21.12,150.75 19.59,150.75 19.4,150.56 CF107.1 RF77.1 20.7,149.58 20.7,148.05 20.43,147.78 UF3.6 ; BRIDGE.L8 v1(58.4,200.19) ; RK46.2 v1(58.58,182.75) 58.58,182.05 CK45.1 ; v1(62.39,198.59) 62.39,198.59 62.39,198.59 BRIDGE.J4 ; BRIDGE.D5 v1(61.59,193.8) ; BRIDGE.J12 v1(55.2,198.59) ; RK38.2 v1(56.55,185.17) ; BRIDGE.D9 v1(57.6,193.8) ; BRIDGE.E4 v1(62.39,194.6) ; BRIDGE.K9 v1(57.6,199.39) ; BRIDGE.C7 v1(59.99,193) ; CK42.1 63.22,205.74 v1(63.28,205.74)
  TOP w0.406: v1(32.27,159.38) 32.18,159.38 31.34,160.22 CS177.1 ; v1(34.2,89.15) 34.45,89.15 34.77,89.47 RF64.1 ; CK7.1 64.04,205.74 v1(63.28,205.74) ; DIMM2.284 101.48,78.1 101.88,78.1 102.36,78.58 102.36,79.45 102.15,79.66 DIMM2.140 100.69,83.31 100.81,83.43 C66.1 C67.1 100.81,86.21 DIMM1.284
  TOP w0.457: v1(29.88,129.16) 30.13,129.41 R6369.1
  TOP w0.508: PR202.1 v1(141.26,192.66) ; v1(32.8,140.72) 33.21,141.13 33.58,141.13 ; CK63.1 24.84,202.06 SLOT4.A33 ; CS120.1 69.82,167.83 v1(70.26,167.39) ; CS176.1 52.1,232.41 v1(52.23,232.41) ; v1(102.73,144.32) 103.22,144.82 RM3.1 ; v1(139.73,196.53) PR198.1 138.79,196.53 138.21,197.12 138.21,203.86 138.89,204.55 138.89,207.16 138.21,207.85 138.21,211.35 136.58,212.98 136.58,214.48 136.05,215.01 ; v1(234.27,62.99) 229.02,62.99 228.13,63.88 220.02,63.88 217.49,66.41 210.93,66.41 201.92,57.4 199.29,57.4 v1(199.01,57.13) 197.23,55.35 190.89,55.35 184.56,49.02 184.56,46.28 182.2,43.92 179.73,43.92 v1(178.36,42.54) ; v1(66.07,211.96) 65.5,212.53 CS131.1 ; CS192.1 46.38,83.81 46.38,84.55 v1(46.08,84.84) ; v1(41.31,140.84) R6427.2 R6431.2 ; CF103.1 17.75,158.18 v1(17.5,157.92) ; R6403.1 32.55,122.3 v1(32.42,122.17) ; 193.77,38.93 193.76,38.93 189.12,34.29 188.5,34.29 187.8,33.59 CA23.1 ; 204.67,53.85 206.79,55.97 CA89.1 ; 204.67,53.85 201.14,53.85 RO170.1 ; 204.67,53.85 204.67,52.32 204.95,52.04 RO51.1 RO43.1 205.11,49.87 205.11,46.84 v1(205.01,46.74) ; v1(124.24,56.51) 134.37,46.38 140.98,46.38 141.89,45.47 141.89,39.91 v1(142.15,39.66) ; RI1.2 216.82,241.62 RI2.2 218.23,239.46 218.57,239.12 221.01,239.12 ; CS111.2 59.78,90.87 v1(59.47,91.19) ; RH7.2 v1(62.39,108.33) RA69.1 ; v1(16.19,148.97) 16.26,148.97 16.45,149.16 CS187.1 ; LPC_DEBUG.4 10.76,154.94 CB4.1 13.05,154.74 13.67,154.11 v1(14.03,154.11) ; v1(40.55,100.84) 40.09,100.84 CF13.2 ; v1(28.12,77.22) 28.12,76.75 CS194.1 ; v1(18.1,81.7) 18.51,81.29 CS196.1 ; 40.17,148.84 40.04,148.97 v1(40.04,151.76) 40.48,152.21 CS175.1 ; 40.17,148.84 39.66,148.34 39.66,146.18 40.17,145.67 40.17,144.27 39.66,143.76 v1(39.66,141.53) 39.29,141.53 C1808.1 ; 40.17,148.84 40.93,149.61 RIO6.1 ; v1(52,182.09) 51.6,182.5 v1(51.6,182.6) FBK3.1 ; CS202.1 53.69,231.84 v1(53.5,231.65) ; v1(234.48,88.52) 230.8,92.19 230.53,92.19 226.98,95.74 226.98,101.85 231.43,106.3 v1(231.43,110.49) ; v1(31.56,117.22) R79.1 R20.2 RX185.1 ; CM5.1 103.86,134.73 103.6,134.99 PR215.1 v1(102.9,136.65) ; CK65.1 24.61,209.93 SLOT4.A27 ; CS171.1 89.06,138.11 v1(89.06,138.05) ; CK47.1 v1(67.47,200.28) ; UK2.1 70.31,187.08 CK44.1 v1(69.5,187.26) 68.41,186.17 UK2.3 66.64,185.8 CK40.1 66.39,187.01 CK58.1 ; 69.14,230.89 ECX11.1 ; ECX11.1 70.03,230 ; ECX11.1 70.03,231.78 ; ECX11.1 70.92,230.89 ; v1(40.29,91.82) 39.85,91.82 RF63.1 ; DIMM2.284 101,77.32 101.86,76.45 107.79,76.45 108.3,75.95 C24.1 C25.1 109.44,75.95 109.95,76.45 112.81,76.45 114.73,74.53 114.73,71.85 113.7,70.81 113.7,66.29 117.11,62.88 128.42,62.88 v1(130.84,60.45) ; RG7.2 142.03,225.23 v1(141.83,225.23) ; v1(226.16,239.46) RI3.2 224.4,239.46 224.06,239.12 221.01,239.12 ; CK68.1 24.61,217.53 SLOT4.A21 ; v1(21.83,133.61) 21.83,133.21 CS180.1 ; CS118.1 69.44,178.37 v1(69.88,178.82) ; CS181.1 18.21,134.11 v1(18.58,134.49) ; v1(67.72,233.83) 67.96,233.83 CS201.1 ; v1(27.34,145.03) 26.89,144.59 CS183.1 ; v1(67.8,232.99) 67.62,233.17 RX16.1 ; v1(37.63,101.98) 38.34,101.27 RF55.2 ; R495.1 R497.1 204.69,44.32 RO168.1 203.8,43.56 RO172.1 202.03,43.43 201.52,42.93 199.55,42.93 198.66,43.81 198.66,45.91 199.48,46.73 v1(199.48,46.74) 199.49,46.74 RO44.1 ; v1(234.77,119.27) 234.77,118.76 235.35,118.17 RF9.2 ; v1(39.55,58.99) 39.46,58.99 CS189.1 ; 221.01,239.12 221.01,236.92 RV86.2 RV87.2 ; CG19.2 152.59,220.04 152.1,220.04 151.84,219.77 RG6.1 152.12,219.21 v1(152.37,219.21) 152.93,219.21 153.32,218.82 155.6,218.82 156.44,219.66 FBG2.1 157.39,219.84 160.69,223.14 EEPROM_G.8 162.85,223.14 165.39,225.68 EEPROM_G.3 168.58,225.68 v3(169.21,226.31) CG17.2 RG25.2 ; 231.3,239.27 v1(230.74,239.27) RV77.1 230.05,238.9 229.47,238.33 226.65,238.33 224.32,235.99 224.32,233.35 v1(223.55,232.59) 224.59,231.55 224.59,225.15 224.07,224.62 220.6,224.62 219.24,223.25 v1(219.24,220.85) ; v1(21.94,151.57) CF104.1 ; CK28.1 35.73,212.6 39.7,212.6 SLOT3.B25 ; 94.11,220.95 94.52,220.95 100.13,226.57 RL1.1 ; CX55.1 65.02,230.12 SLOT2.A10 ; RO23.1 211.74,56.45 RO27.1 212.44,55.44 v1(212.5,55.5) ; v3(147.81,219.81) 147.85,219.77 RG5.1 ; CS198.1 52.12,225.5 v1(52.66,225.5) ; CK9.1 33,194.21 v1(33.99,194.21) ; CX56.1 58.12,231.84 SLOT2.B8 ; v1(18.85,123.34) 18.67,123.16 18.55,123.16 CS188.1 ; v1(16.31,70.63) 16.31,70.02 CS197.1 ; v1(37.32,159.66) 37.59,159.4 CS206.1 ; v1(31.45,142.49) 31.45,142.62 31.97,143.14 CS182.1 ; v1(35.74,171.64) 35.29,172.09 CS205.1 ; CS184.1 23.26,144.84 v1(23.68,144.42) ; v1(25.52,85.8) 25.52,85.57 CS193.1 ; v1(36.23,202.44) 35.97,202.69 CK29.1 ; CF19.1 v1(36.86,102.11) ; CS195.1 26.35,79.03 v1(26.96,79.03) ; v1(27.16,147.73) 27.38,147.51 CS185.1 ; CS203.1 48.24,226.56 v1(47.2,226.56) ; RL34.1 101.39,220.79 98.31,217.71 v1(98.31,216.31) ; v1(27.59,151.86) 28.31,152.58 CS204.1 ; v1(174.86,31.95) 174.4,32.4 R6540.1 ; CK26.1 45.61,216.85 SLOT3.A21 ; CS200.1 67.55,170.26 v1(68.16,169.65) ; CS207.1 31.19,154.62 v1(30.72,155.08) ; CS190.1 v1(53.56,85.79) ; v1(228.64,239.9) RI4.2 ; CS191.1 56.31,81.6 56.24,81.53 v1(55.91,81.53) ; RNO2.6 207.43,16.01 208.35,16.93 208.35,27.9 209.23,28.78 209.23,31.29 210.14,32.21 210.14,33.35 211.42,34.63 CO3.2 ; RO25.1 v3(217.33,56.26) ; R6586.1 v1(28.86,125.98) ; CK41.1 v1(67.47,196.6) ; CS129.1 v1(48.55,196.72) ; v1(56.01,247.17) RL41.1 ; CK43.1 v1(36.1,204.6) ; v1(13.24,78.23) 12.53,77.52 10.8,77.52 8.9,75.62 5.97,75.62 4.35,74 4.35,48.77 8.29,44.83 PR336.1 ; CS199.1 47.21,196.04 v1(46.73,196.52) ; CS186.1 v1(17.56,147.55) ; PR141.1 v3(220.76,198.5) ; v3(216.31,56.26) RO26.1
  TOP w0.889: PCE32.1 43.89,61.99 ; PCE32.1 43,61.1 ; PCE32.1 42.11,61.99
  TOP w1.016: v1(177.36,42.54) v1(178.36,42.54) 178.36,42.39 179.38,41.38 183.65,41.38 186.51,44.24 188.46,44.24 201.07,31.62 201.07,23.37 201.71,22.73
  TOP w1.27: SATA_PWR.5 100.16,47.77 ; SATA_PWR.5 98.96,46.57 ; SATA_PWR.5 101.37,46.57
  BOTTOM w0.254: v1(57.04,129.96) 57.04,130.91 57.29,131.16 57.29,134.73 58.22,135.66 58.22,136.37 59.34,137.49 59.34,139.83 v1(61.12,141.6) 62.24,142.73 62.24,142.98 63.65,144.39 63.94,144.39 64.61,145.06 64.61,145.34 65.72,146.45 65.72,151.13 62.85,154 62.85,161.98 66.27,165.4 66.27,166.7 v1(67.06,167.49)
  BOTTOM w0.508: v1(56.01,247.17) 54.11,245.28 54.11,237.06 53.65,236.6 v1(53.65,233.55) ; v1(137.45,225.26) 141.8,225.26 v1(141.83,225.23) 141.83,225.39 143.59,227.15 144.61,227.15 144.69,227.08 147.23,227.08 148.24,226.06 148.24,222.76 147.78,222.3 147.78,219.84 v3(147.81,219.81) 147.91,219.91 151.67,219.91 v1(152.37,219.21) ; v1(223.55,232.59) 213.52,232.59 212.17,231.24 191.32,231.24 189.14,233.43 184.82,233.43 183.33,231.94 183.33,228.13 180.09,224.89 178.04,224.89 177.38,225.55 173.52,225.55 173.39,225.43 170.1,225.43 v3(169.21,226.31) ; v1(39.66,141.53) 40.62,141.53 v1(41.31,140.84) ; v1(187.1,32.72) 184.52,32.72 184.2,33.04 183.13,33.04 182.81,32.72 175.63,32.72 v1(174.86,31.95) ; v1(141.26,192.66) 141.54,192.95 141.54,195.66 140.67,196.53 v1(139.73,196.53) ; v1(234.27,62.99) 234.27,85.14 234.6,85.47 234.6,88.39 v1(234.48,88.52) ; v1(48.52,187.5) 48.95,187.07 v1(48.95,186.99) 48.95,185.24 v1(51.6,182.6) 52,182.19 v1(52,182.09) ; v1(102.73,144.32) 102.73,142.68 104.3,141.1 104.3,137.19 103.77,136.65 v1(102.9,136.65) ; v3(217.33,56.26) v3(216.31,56.26) 215.55,55.5 v1(212.5,55.5) 208.06,55.5 207.93,55.37 v1(207.55,55.37) 205.48,55.37 204.87,55.98 200.16,55.98 v1(199.01,57.13) ; v1(231.43,110.49) 234.77,113.83 v1(234.77,119.27) 235.21,119.71 235.21,121.99 235.95,122.73 235.95,127.3 233.33,129.92 v1(233.33,131.32) ; v1(230.74,239.27) 229.27,239.27 v1(228.64,239.9) 227.76,239.01 226.6,239.01 v1(226.16,239.46) ; v1(62.39,108.33) 62.39,106.93 62.06,106.6 62.06,106.36 61.96,106.26 61.96,105.32 62.06,105.22 62.06,96.95 59.93,94.81 59.93,91.64 v1(59.47,91.19) ; v1(219.24,220.85) 221.06,219.03 222.22,219.03 232,209.26 232,203.8 230.91,202.71 225.07,202.71 223.55,201.19 223.55,199.69 223.02,199.16 221.42,199.16 v3(220.76,198.5) ; v1(199.48,46.74) v1(205.01,46.74) ; v1(124.24,56.51) 124.75,57.02 127.41,57.02 v1(130.84,60.45)
  BOTTOM w1.016: SATA_PWR.5 102.06,46.57 103.82,44.81 106.79,44.81 107.88,43.71 113.01,43.71 113.67,43.05 117.6,43.05 119.25,41.4 123.79,41.4 124.5,40.69 137.92,40.69 138.96,39.66 v1(142.15,39.66) 152.69,39.66 153.66,38.68 172.87,38.68 173.43,39.24 174.06,39.24 v1(177.36,42.54) v1(178.36,42.54)
  BOTTOM w1.778: 130.44,214.43 119.74,214.43 119.11,213.79 110.92,213.79 108.41,216.31 v1(98.31,216.31)
  vias: v1(26.59,154.27) v1(26.59,153.58) v1(42.32,62.87) v1(43.59,62.87) v1(44.1,62.48) v1(44.1,61.72) v1(45.88,221.87) v1(47.53,60.07) v1(49.44,59.69) v1(49.94,60.07) v1(50.45,59.69) v1(50.96,60.07) v1(51.47,59.69) v1(51.98,60.07) v1(52.48,59.69) v1(52.99,60.07) v1(53.5,59.69) v1(54.01,60.07) v1(54.52,59.69) v1(61.12,88.9) v1(61.12,88.14) v1(61.4,67.8) v1(61.88,88.9) v1(61.88,88.14) v1(62.16,67.8) v1(62.92,67.8) v1(63.69,67.8) v1(64.45,67.8) v1(65.08,67.8) v1(69.76,229.87) v1(70.39,231.9) v1(70.65,230) v1(71.15,230.89) v1(83.5,86.82) v1(83.52,87.5) v1(84.16,87.5) v1(84.16,86.84) v1(88.43,230.25) v1(88.43,229.49) v1(88.43,228.73) v1(92.39,220.85) v1(92.69,132.72) v1(92.69,132.08) v1(92.9,220.34) v1(92.92,221.39) v1(93.4,132.74) v1(93.43,220.88) v1(94.04,132.79) v1(104.3,133.83) v1(104.55,133.22) v1(105.19,133.22) v1(133.38,216.03) v1(133.38,215.39) v1(134.02,216.03) v1(134.02,215.39)
+3P3V_PCIAUX: length 3.6
  TOP w0.508: ECX12.1 70.92,224.03 ; ECX12.1 70.03,224.92 ; ECX12.1 69.14,224.03 ; ECX12.1 70.03,223.14
  vias: v1(14.13,214.12) v1(14.13,213.36) v1(14.13,212.6) v1(14.13,210.31) v1(14.89,214.12) v1(14.89,213.36) v1(14.89,212.6) v1(14.89,210.31) v1(15.53,231.52) v1(15.53,230.76) v1(15.53,230) v1(15.53,229.23) v1(15.53,228.47) v1(15.53,227.71) v1(15.53,226.95) v1(15.53,226.19) v1(56.04,228.47) v1(56.04,227.71) v1(56.93,228.47) v1(56.93,227.71) v1(57.69,228.47) v1(65.95,226.19) v1(65.95,225.43) v1(66.71,226.19) v1(66.71,225.43) v1(69.88,223.01) v1(70.39,225.04) v1(70.77,223.14) v1(71.15,224.03)
+3P3V_SB: length 694.6
  TOP w0.152: v3(58.52,128.42) U4.W15
  TOP w0.203: 207.78,47.81 208.07,48.09 SIO_5553.104 ; CO9.2 226.26,43.46 225.37,43.46 225.2,43.29 SIO_5553.45 ; v1(218.32,53.7) 218.32,53.43 218.09,53.2 SIO_5553.77 ; SIO_5553.60 225.13,49.29 225.46,49.62 225.46,50.1 ; CO8.2 225.37,47.62 225.04,47.29 SIO_5553.55 ; SIO_5553.120 208.17,41.69 207.63,42.24 207.41,42.77 v1(207.35,42.8) ; SIO_5553.22 218.89,36.05 CO1.2 ; 223.77,36.27 223.1,36.27 222.89,36.47 SIO_5553.32 ; CO6.2 226.54,51.12
  TOP w0.254: v1(23.78,129.67) 24.58,130.46 26.29,130.46 27.47,129.29 28.72,129.29 29.43,128.57 32.47,128.57 33.24,129.35 R6438.1 R6544.2 35.21,128.78 35.66,128.33 R6664.1 36.23,127.76 36.1,127.63 36.1,127.06 R6435.1 R6658.1 ; v1(24.12,119) 26.04,119 27.01,119.98 v1(30.17,119.98) ; v1(48.72,124.14) U4.BA24
  TOP w0.406: CO6.2 225.46,50.1
  TOP w0.508: 226.73,43.69 226.86,43.81 233.08,43.81 233.84,44.58 233.84,50.42 232.19,52.07 230.54,52.07 v1(230.41,52.2) 230.36,52.15 229.01,52.15 ; v1(77.55,235.33) 76.11,235.33 75.22,236.22 75.22,237.87 72.8,240.28 v1(72.8,243.33) ; v1(69.76,74.17) 69.76,73.28 68.99,72.52 65.95,72.52 65.71,72.28 61.13,72.28 60.78,72.64 59.52,72.64 v1(58.65,71.76) ; v1(207.3,27.94) 207.3,31.18 200.82,37.66 v1(200.82,38.48) 199.92,39.38 199.1,39.38 196.5,41.98 196.5,51.05 195.23,52.32 v1(195.23,52.58) 197.39,52.58 200.31,55.5 202.83,55.5 211.46,64.13 216.57,64.13 v1(217.46,63.25) ; v1(61.12,140.46) 61.69,141.03 C1807.2 ; v1(169.96,37.8) 169.96,31 R6541.1 170.66,29.78 169.71,28.83 169.71,23.77 RA2.2 CA106.2 ; v1(106.76,219.98) 106.97,220.19 RL3.1 ; v1(168.82,54.48) 168.82,49.78 168.28,49.25 168.28,46.37 164.37,42.46 v1(164.37,37.8) ; v1(31.4,81.65) 26.21,81.65 25.78,82.08 22.17,82.08 21.45,82.8 21.45,84.02 19.11,86.36 14.18,86.36 14.16,86.39 ; v1(41.56,122.3) 41.56,121.48 C1647.1 ; 229.01,52.15 229.01,48.77 228.51,48.26 227.05,48.26 226.54,47.75 CO8.2 ; 229.01,52.15 226.52,52.15 225.65,53.02 CO5.2 ; v1(230.41,55.75) 227.27,55.75 222.96,60.07 221.27,60.07 220.38,59.18 v3(220.38,58.8) RO31.1 220.25,57.98 219.74,57.47 219.74,55.05 219.24,54.55 CO7.2 219.36,54.17 v1(219.36,53.72) ; v3(206.92,46.45) CO4.2 207.16,47.18 207.78,47.81 ; v1(66.99,166.07) 66.86,166.19 50.63,166.19 48.9,164.47 46.67,164.47 v1(41.49,159.28) ; v1(207.35,42.8) 207.12,42.8 206.48,42.16 CO13.2 CO19.1 206.09,40.25 CO20.1 205.24,38.91 203.92,38.91 v1(203.74,38.73) ; v1(146.26,54.45) 145.48,54.45 144.18,55.75 134.53,55.75 128.04,62.24 104.35,62.24 PR387.1 102.98,62.24 PR61.1 v1(96.68,62.24) ; 55.84,57.89 55.84,57.87 52.18,54.21 52.18,51.1 50.99,49.91 PR269.1 ; CO1.2 217.71,34.86 v1(217.71,27.94) 217.71,26.92 213.84,23.05 RIO2.1 ; R6590.1 v1(170.59,55.5) ; 223.77,36.27 225.33,34.71 CO2.2 225.41,34.1 226.09,33.42 226.09,30.35 v1(224.57,28.83)
  TOP w0.889: 65.08,57.1 PCE37.1 ; PCE37.1 65.08,58.98 ; PCE37.1 64.14,58.04 ; PCE37.1 66.02,58.04
  BOTTOM w0.254: v1(30.17,119.98) 30.43,120.24 32.6,120.24 33.19,119.66 33.89,119.66 34.7,120.47 38.11,120.47 40.42,122.78 41.08,122.78 v1(41.56,122.3) 42.04,122.78 44.02,122.78 44.4,123.16 46.58,123.16 46.65,123.23 47.81,123.23 v1(48.72,124.14)
  BOTTOM w0.508: v1(207.3,27.94) v1(217.71,27.94) 220,27.94 220.89,28.83 v1(224.57,28.83) ; v1(195.23,52.58) 193.2,52.58 189.29,56.49 178.75,56.49 177.96,57.28 171.61,57.28 170.59,56.26 v1(170.59,55.5) 169.58,54.48 v1(168.82,54.48) 168.82,54.03 167.01,52.22 157.29,52.22 153.86,55.65 148.79,55.65 147.59,54.45 v1(146.26,54.45) ; v1(218.32,53.7) 218.34,53.72 v1(219.36,53.72) ; v1(203.74,38.73) 201.07,38.73 v1(200.82,38.48) ; v1(72.8,243.33) 72.8,247.52 70.14,250.19 v1(67.98,250.19) ; v1(31.4,81.65) 31.4,82.68 31.99,83.26 31.99,92.41 27.9,96.49 27.9,99.16 19.72,107.34 19.72,113.03 23,116.32 23,116.99 24.12,118.11 v1(24.12,119) 24.12,123.57 23.78,123.91 v1(23.78,129.67) 23.85,129.73 23.85,134.27 23.78,134.33 23.78,135.88 29.51,141.6 31.77,141.6 32.95,142.79 32.95,143.79 33.88,144.72 33.88,151.83 41.33,159.28 v1(41.49,159.28) ; v1(164.37,37.8) v1(169.96,37.8) ; v1(106.76,219.98) 104.83,219.98 103.93,220.88 98.64,220.88 91.21,228.32 91.21,231.51 87.92,234.8 84.65,234.8 83.7,233.85 80.4,233.85 79.73,233.18 ; v1(58.65,71.76) 56.97,71.76 v1(54.83,69.61) ; v1(96.68,62.24) 93.46,62.24 90.43,65.27 88.54,65.27 86.31,67.5 86.31,70.29 86.11,70.48 82.4,74.19 73.77,74.19 73.52,73.94 69.98,73.94 v1(69.76,74.17) ; v1(230.41,55.75) v1(230.41,52.2) ; v1(217.46,63.25) 220.38,60.32 v3(220.38,58.8) ; 58.83,134.49 58.83,135.97 59.85,136.98 59.85,139.19 v1(61.12,140.46) 62.75,142.09 62.75,142.77 63.86,143.88 64.15,143.88 65.11,144.85 65.11,145.13 66.23,146.24 66.23,146.66 66.23,151.34 63.36,154.21 63.36,161.6 66.99,165.23 v1(66.99,166.07) ; v1(207.35,42.8) 207.35,42.82 206.92,43.26 v3(206.92,46.45)
  vias: v1(3.97,181.23) v1(3.97,180.59) v1(3.97,179.96) v1(3.97,179.32) v1(4.61,181.23) v1(4.61,180.59) v1(4.61,179.96) v1(4.61,179.32) v1(10.45,207.52) v1(10.45,206.88) v1(10.45,206.25) v1(10.45,205.61) v1(11.08,207.52) v1(11.08,206.88) v1(11.08,206.25) v1(11.08,205.61) v1(11.49,84.96) v1(11.49,84.33) v1(12.12,84.96) v1(12.12,84.33) v1(12.76,84.96) v1(12.76,84.33) v1(13.39,84.96) v1(13.4,84.3) v1(26.58,67.56) v1(26.58,66.55) v1(26.96,67.06) v1(27.34,67.56) v1(27.34,66.55) v1(27.72,67.06) v1(28.1,67.56) v1(28.1,66.55) v1(46.26,253.49) v1(46.9,253.49) v1(50.45,253.11) v1(51.21,253.11) v1(60.74,53.97) v1(60.74,53.21) v1(61.5,53.97) v1(61.5,53.21) v1(61.5,52.32) v1(62.64,51.44) v1(63.03,60.71) v1(63.03,50.8) v1(63.15,57.66) v1(63.41,58.55) v1(63.41,51.44) v1(63.66,60.71) v1(63.79,57.66) v1(63.79,50.8) v1(64.04,58.55) v1(64.17,51.44) v1(64.3,60.71) v1(64.55,50.8) v1(64.93,60.71) v1(64.93,51.44) v1(65.31,50.8) v1(65.44,254.38) v1(65.44,253.75) v1(65.82,51.44) v1(66.07,254.38) v1(66.07,253.75)
+3P3V_SB_BOOT_20: length 0.9
  TOP w0.203: 48.04,52.32 47.93,52.22 PU16.9
  vias: v1(48.45,52.81)
+3P3V_SB_BOOTR_20: length 2.8
  TOP w0.508: v1(51.34,51.44) 51.09,51.69 50.88,51.69 PC329.1 50.96,52.53 PR262.2
