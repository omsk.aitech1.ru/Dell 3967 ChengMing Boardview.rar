# Allegro board Phoenix-A00-Layout-20161019.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SMBDATA: length 487.2
  TOP w0.089: U4.BB43 48.57,114.6 v1(48.6,114.63)
  TOP w0.102: RK19.2 34.24,192.3 34.13,192.3 v1(33.84,192.01) 33.55,192.3 30.29,192.3 29.94,192.66 27.69,192.66 RK52.2 ; RX176.1 74.76,234.07 70.43,234.07 69.68,234.82 68.31,234.82 v1(68.04,234.56) 67.77,234.82 67.67,234.82 67.43,234.58 67.13,234.58 67.03,234.48 RX20.1 ; SIO_5553.78 217.69,53.21 217.84,53.36 217.84,57.03 217.97,57.16 v1(217.97,57.41) 217.69,57.69 217.69,58.95 217.79,59.06 RO80.2 ; v1(45.03,84.35) 45.19,84.51 45.19,84.76 45.09,84.86 44.85,84.86 44,84.01 44,83.14 43.62,82.75 42.11,82.75 41.69,82.33 38.81,82.33 36.08,79.6 27.49,79.6 27.22,79.87 26.84,79.87 v1(26.65,79.68) ; v1(36.07,160.81) 35.81,160.55 35.21,160.55 33.54,162.23 33.54,171.22 34.07,171.75 34.27,171.75 v1(34.55,171.47) ; v1(47.29,225.86) 47.07,225.64 47.07,225.19 47.43,224.82 49.56,224.82 50.9,226.16 54.19,226.16 v1(54.36,225.98)
  BOTTOM w0.089: 48.93,111.96 48.93,112.57 49.37,113.02 49.37,113.42 48.83,113.97 48.83,114.4 v1(48.6,114.63)
  BOTTOM w0.102: 48.93,111.96 48.93,110.24 47.84,109.15 47.84,107.9 47.81,107.87 47.81,105.17 44.71,102.07 44.71,86.24 45.18,85.77 45.18,84.51 v1(45.03,84.35) 45.03,84.23 45.27,83.99 45.43,83.99 45.67,83.75 45.67,83.09 45.04,82.47 45.04,80.69 45.71,80.01 45.71,79.22 47.2,77.74 48,77.74 49.25,78.99 52.85,78.99 56.2,75.64 59.78,75.64 60.9,74.52 62.4,74.52 63.13,73.79 65.37,73.79 65.95,73.2 68.42,73.2 68.81,72.82 80.16,72.82 82.95,70.03 83.97,70.03 85.2,68.81 85.2,67.03 88.1,64.13 89.91,64.13 92.98,61.05 96.76,61.05 97.19,60.63 110.17,60.63 110.63,61.08 112.67,61.08 115.18,58.57 126.63,58.57 130.98,62.92 144.86,62.92 146.2,64.26 147.02,64.26 148.09,65.33 154.46,65.33 155.14,66.01 158.24,66.01 158.52,65.74 159.47,65.74 159.86,65.35 178.07,65.35 181.75,61.67 194.15,61.67 198.24,57.58 199.96,57.58 201.12,56.41 205.04,56.41 205.38,56.08 213.49,56.08 214.84,57.43 215.58,57.43 216.22,56.79 217.36,56.79 v1(217.97,57.41) ; v1(34.55,171.47) 34.83,171.75 35.03,171.75 35.95,172.67 35.95,174.19 33.1,177.03 33.1,192.16 33.24,192.29 33.56,192.29 v1(33.84,192.01) 34.12,192.29 34.49,192.29 35.04,192.84 35.04,215.5 36.93,217.39 37.87,217.39 39.12,218.65 40.06,218.65 41.42,220.01 42.68,220.01 43.52,220.85 43.52,222.66 44.52,223.65 45.55,223.65 47.07,225.17 47.07,225.64 v1(47.29,225.86) ; v1(68.04,234.56) 67.77,234.82 66.84,234.82 66.05,234.04 66.05,231.5 65.2,230.65 64.47,230.65 63.38,229.57 60.04,229.57 58.95,230.66 54.54,230.66 54.01,230.12 54.01,226.34 v1(54.36,225.98) ; v1(36.07,160.81) 35.72,160.47 35.31,160.47 34.76,159.92 34.76,158.07 30.51,153.82 30.51,149.62 28.14,147.24 26.34,147.24 24.11,145.01 24.11,143.91 23.63,143.43 23.63,141.83 19.48,137.68 19.48,126.38 17.97,124.87 17.97,118.14 18.35,117.76 18.35,116.54 16.95,115.14 16.95,106.16 25.03,98.08 25.03,93.4 26.91,91.52 27.48,91.52 28.28,90.71 28.28,89.08 27.98,88.77 27.4,88.77 24.19,85.57 24.19,82.96 25.79,81.36 25.79,80.29 26.19,79.88 26.44,79.88 v1(26.65,79.68)
SML1CLK_PCH: length 281.7
  TOP w0.089: U4.AW42 49.63,115.08 49.63,113.85 49.69,113.79 49.69,112.93 49.47,112.71 48.23,111.47 47.47,111.47 v1(47.26,111.25)
  TOP w0.102: RS90.2 219.53,32.03 219.53,32.17 v1(219.74,32.38) 219.53,32.6 219.53,32.87 RO8.1 ; v1(44.59,83.43) 44.46,83.43 44.23,83.19 44.23,83.03 43.72,82.52 42.21,82.52 41.78,82.1 38.92,82.1 35.41,78.59 25.2,78.59 24.8,78.99 24.8,79.9 v1(25.08,80.18)
  BOTTOM w0.102: v1(219.74,32.38) 219.74,32.51 218.98,33.27 216.57,33.27 215.22,31.92 212.68,31.92 211.99,32.61 211.03,32.61 210.76,32.35 209.8,32.35 v2(209.42,32.73) 209.04,32.35 208.7,32.35 208.13,31.78 200.52,31.78 190.41,41.88 186.45,41.88 183.07,45.27 176.17,45.27 173.01,42.11 155.91,42.11 152.33,45.69 135.7,45.69 134.84,44.83 121.02,44.83 119.41,46.44 116.14,46.44 110.38,52.21 90.52,52.21 86.52,56.21 84.63,56.21 78.4,62.44 71.34,62.44 69.66,64.11 54.53,64.11 54.22,64.43 45.22,64.43 44.4,65.25 38.26,65.25 30.44,73.07 30.44,74.24 25.84,78.84 25.59,78.84 24.8,79.63 24.8,79.9 v1(25.08,80.18) ; v1(47.26,111.25) 46.9,110.89 46.9,104.58 44.48,102.17 44.48,84.76 44.23,84.51 44.23,83.44 44.34,83.34 44.51,83.34 v1(44.59,83.43)
SML1DATA_PCH: length 280.8
  TOP w0.089: U4.AW45 49.47,113.59 49.47,113.02 49.39,112.93 49.38,112.93 48.14,111.68 47.5,111.68
  TOP w0.102: v1(24.29,80.18) 24.57,79.9 24.57,78.9 25.11,78.36 35.51,78.36 39.02,81.87 41.88,81.87 42.3,82.29 43.78,82.29 44.36,82.87 44.51,82.87 v1(44.59,82.79) ; RO4.1 219.3,32.76 219.3,32.58 v1(219.11,32.38) 219.25,32.25 219.25,32.08 RS89.2 ; 47.5,111.68 v1(47.28,111.91)
  BOTTOM w0.089: 46.9,111.53 v1(47.28,111.91)
  BOTTOM w0.102: v1(44.59,82.79) 44.27,83.11 44.24,83.11 44.01,83.35 44.01,84.61 44.25,84.86 44.25,102.26 46.67,104.67 46.67,110.99 46.85,111.17 46.85,111.48 46.9,111.53 ; v1(219.11,32.38) 219.11,32.61 219.14,32.64 219.14,32.79 218.89,33.05 216.66,33.05 215.31,31.69 212.59,31.69 211.89,32.38 211.65,32.38 211.28,32.01 v2(211.26,32.01) 211.15,32.12 208.79,32.12 208.22,31.55 200.43,31.55 190.32,41.66 186.36,41.66 182.97,45.04 176.27,45.04 173.11,41.88 155.82,41.88 152.24,45.47 135.8,45.47 134.93,44.6 120.93,44.6 119.32,46.22 116.05,46.22 110.29,51.98 90.42,51.98 86.42,55.98 84.53,55.98 78.3,62.21 71.25,62.21 69.57,63.89 54.44,63.89 54.12,64.2 45.13,64.2 44.31,65.02 38.16,65.02 30.21,72.97 30.21,74.15 25.74,78.61 25.49,78.61 24.57,79.53 24.57,79.9 v1(24.29,80.18)
SPI_CS#: length 41.3
  TOP w0.089: v1(44.55,115.16) 44.76,115.38 44.76,117.73 45.18,118.14 45.18,120.04 45.83,120.69 46.75,120.69 U4.BD31
  TOP w0.102: v1(34.58,106.93) SPI1.1 SPI_1.1
  BOTTOM w0.102: v1(34.58,106.93) 35.09,106.93 35.32,107.17 35.32,109.73 35.5,109.91 35.75,109.91 35.93,109.73 35.93,107.21 36.09,107.06 36.44,107.06 36.54,107.16 36.54,109.7 36.72,109.88 36.97,109.88 37.15,109.7 37.15,107.62 37.3,107.47 38.34,107.47 38.87,108 42.07,108 42.22,108.15 42.22,108.39 40.99,109.62 40.99,109.87 41.17,110.05 41.42,110.05 42.54,108.93 42.8,108.93 42.97,109.11 42.97,109.36 42.34,110 42.34,110.25 42.52,110.43 42.77,110.43 43.41,109.79 43.66,109.79 44.86,111 44.86,114.85 v1(44.55,115.16)
SPI_IO2: length 33.5
  TOP w0.089: U4.BC29 47.17,121.7 47.03,121.56 45.63,121.56 44.41,120.35 44.41,118.5 43.77,117.86 R6518.1 43.19,117.94
  TOP w0.102: RF24.1 38.82,109.66 38.97,109.82 38.97,112.21 39.28,112.52 39.28,112.9 39.1,113.08 36.81,113.08 36.63,113.26 36.63,113.52 36.81,113.69 38.45,113.69 38.55,113.79 38.55,113.97 37.96,114.56 37.96,114.81 38.14,114.99 38.4,114.99 38.89,114.5 39.05,114.5 39.6,115.05 39.6,115.24 39.36,115.48 38.29,115.48 38.11,115.66 38.11,115.91 v1(38.29,116.09) 39.36,116.09 39.54,116.27 39.54,116.52 39.36,116.7 38.29,116.7 38.11,116.88 38.11,117.13 38.29,117.31 39.36,117.31 39.54,117.49 39.54,117.72 39.41,117.86 R102.1 38.96,118.42 39.18,118.65 40.06,118.65 40.85,117.86 RA13.1 41.26,118.13 41.26,118.44 41.52,118.69 42.44,118.69 43.19,117.94
SPI_IO3: length 38.7
  TOP w0.089: 43.19,115.42 44.2,115.42 44.57,115.79 44.57,117.82 44.99,118.23 44.99,120.12 45.76,120.89 46.75,120.89 U4.BD30
  TOP w0.102: 43.19,115.42 42.87,115.42 R83.1 42.34,114.88 v1(41.69,114.88) 41.44,114.63 41.29,114.63 RA14.1 ; RF23.1 28.04,104.26 v1(28.04,107.57)
  BOTTOM w0.102: v1(28.04,107.57) 28.52,108.05 31.38,108.05 31.92,108.6 32.17,108.6 33.3,107.47 33.55,107.47 33.73,107.65 33.73,107.9 32.6,109.03 32.6,109.28 32.78,109.46 33.04,109.46 34.16,108.34 34.41,108.34 34.59,108.51 34.59,108.77 33.47,109.89 33.47,110.14 35.39,112.06 36.71,112.06 39.41,114.76 41.57,114.76 v1(41.69,114.88)
SPI_MISO: length 35.4
  TOP w0.089: U4.BE30 45.74,121.14 44.8,120.19 44.8,118.32 44.38,117.91 44.38,116.61 44.1,116.33 43.19,116.33
  TOP w0.102: 43.19,116.33 42.9,116.33 R78.1 v1(41.69,115.82) RA11.1 ; RF61.1 39.21,106.49 v1(39.4,106.3) 39.97,106.3 RF60.1
  BOTTOM w0.102: v1(41.69,115.82) 42.2,116.33 v2(42.97,116.33) 44.23,116.33 45.09,115.47 45.09,110.57 44.59,110.06 44.59,109.81 44.81,109.59 44.81,109.33 44.63,109.15 44.38,109.15 44.15,109.38 43.9,109.38 43.52,109 43.52,107.31 42.63,106.43 42.33,106.43 42.15,106.6 42.15,106.97 41.97,107.14 41.72,107.14 41.54,106.97 41.54,106.6 41.36,106.43 41.11,106.43 40.93,106.6 40.93,107.4 40.75,107.57 40.5,107.57 40.32,107.4 40.32,106.6 40.16,106.45 39.89,106.45 39.68,106.65 39.68,107.39 39.5,107.57 39.25,107.57 39.07,107.39 39.07,106.63 v1(39.4,106.3)
SPI_MOSI: length 380.9
  TOP w0.089: U4.BB29 47.68,121.47 47.2,121.47 47.11,121.37 45.7,121.37 44.6,120.27 44.6,118.41 43.54,117.35 43.19,117.35
  TOP w0.102: R93.1 134.26,195.14 134.45,195.33 134.45,196.63 133.93,197.15 v1(133.71,197.15) ; v1(30.01,142.88) 29.55,142.88 23.97,137.29 22.45,137.29 18.73,133.57 16.24,133.57 12.02,129.36 12.02,122.07 14.77,119.33 14.77,111.86 18.67,107.95 18.67,101.21 20.61,99.28 20.61,85.85 23.8,82.66 25.89,82.66 26.47,82.08 32.02,82.08 33.05,81.05 36.88,81.05 38.62,82.79 41.5,82.79 41.92,83.21 43.13,83.21 v1(43.34,83.42) ; RF21.1 RF18.1 27.84,113.22 28.75,114.13 30.1,114.13 30.64,113.59 v1(30.64,111.89) ; v1(93.63,215.77) 92.84,215.77 87.64,220.98 87.13,220.98 85.61,222.5 83.93,222.5 83.04,221.62 80.3,221.62 79.28,222.63 76.71,222.63 74.58,220.5 v1(74.58,219.71) ; v1(127.77,207.52) 127.77,208.03 125.71,210.08 116.7,210.08 v1(116.44,210.34) ; RA10.1 41.6,116.84 v1(41.69,116.74) 42.29,116.74 R82.1 42.9,117.35 43.19,117.35 ; v1(67.72,169.04) 65.82,169.04 62.87,171.98 59.08,171.98 55.7,168.61 52.25,168.61 51.26,167.61 50.15,167.61 48.37,165.84 46.14,165.84 44.15,163.86 41.84,163.86 38.38,160.4 v1(38.12,160.4)
  BOTTOM w0.102: v1(43.34,83.42) 43.34,89.55 43.8,90.01 43.8,101.97 43,102.78 40.38,105.39 28.7,105.39 24.87,109.22 24.87,109.98 25.51,110.62 27.61,110.62 28.29,111.3 30.06,111.3 v1(30.64,111.89) 31.91,111.89 32.17,112.15 32.42,112.15 33.11,111.46 33.36,111.46 33.54,111.64 33.54,111.89 32.85,112.58 32.85,112.83 33.05,113.03 33.81,113.03 33.98,113.21 33.98,113.76 34.16,113.94 34.41,113.94 34.59,113.76 34.59,113.21 34.77,113.03 35.02,113.03 35.2,113.21 35.2,113.76 35.38,113.94 35.63,113.94 35.81,113.76 35.81,113.21 35.99,113.03 36.27,113.03 39.57,116.32 40.1,116.32 40.28,116.15 40.28,115.98 40.46,115.8 40.71,115.8 40.89,115.98 40.89,116.15 41.07,116.32 41.27,116.32 v1(41.69,116.74) ; v1(67.72,169.04) 67.72,170.51 70.9,173.69 72.6,173.69 75.09,176.17 75.09,206.5 v2(74.86,206.74) 74.58,207.01 v1(74.58,219.71) ; v1(116.44,210.34) 116.31,210.46 110.01,210.46 107.17,213.31 95.03,213.31 93.63,214.71 v1(93.63,215.77) ; v1(38.12,160.4) 37.8,160.08 37.8,158.86 31.96,153.02 31.96,147.96 30.01,146 v1(30.01,142.88) ; v1(133.71,197.15) 133.59,197.28 132.75,197.28 132.44,197.59 125.91,197.59 125.4,198.09 124.61,198.09 122.09,200.61 122.09,204.84 123.66,206.42 124.45,206.42 124.94,206.91 127.16,206.91 v1(127.77,207.52)
SPI_SCK: length 35.6
  TOP w0.089: v1(43.99,114.12) 44.19,114.12 44.28,114.21 44.28,114.3 45.03,115.05 45.03,115.74 44.95,115.82 44.95,117.65 45.37,118.06 45.37,119.96 45.9,120.5 46.56,120.5 46.77,120.29 47.19,120.29 U4.BC31
  TOP w0.102: RF16.1 27.72,109.28 27.72,109.47 v1(27.97,109.73) 27.72,109.98 27.72,110.05 RF17.1
  BOTTOM w0.102: v1(27.97,109.73) 27.97,109.85 28.51,110.39 28.73,110.39 28.91,110.21 28.91,108.81 29.09,108.64 29.34,108.64 29.52,108.81 29.52,110.21 29.7,110.39 29.95,110.39 30.13,110.21 30.13,108.87 30.31,108.69 30.56,108.69 30.74,108.87 30.74,110.21 30.92,110.39 33,110.39 35.15,112.55 36.51,112.55 39.28,115.32 42.2,115.32 43.39,114.12 v1(43.99,114.12)
SPI_TPM_CS2#: length 53.7
  TOP w0.089: U4.AT31 51.16,119.99 v3(51.16,119.91)
  TOP w0.102: v1(25.56,109.47) 25.46,109.37 25.46,103.53 26.93,102.06 26.93,97.88 RF56.2 RF43.1
  BOTTOM w0.089: v3(51.16,119.91) 50.57,119.32 49.51,119.32 49.21,119.02 48.62,119.02 47.84,118.24 46.88,118.24 46.46,117.82 45.82,117.82 45.32,117.32 v2(45.32,116.81) 45.32,115.83 45.38,115.77 45.38,115.58
  BOTTOM w0.102: 45.38,115.58 45.38,109.49 43.75,107.85 43.75,107.2 42.72,106.17 40.8,106.17 40.48,105.85 28.9,105.85 25.56,109.19 v1(25.56,109.47)
SPI_VDD1:
  vias: v1(37.5,100.33)
SPI_VDD3: length 4.2
  TOP w0.102: UF1.22 31.48,93.61 CF23.1 30.31,92.44 RF62.1 31.07,91.44 v1(31.2,91.57)
SPKR: length 225.9
  TOP w0.102: v1(26.7,90.65) 26.47,90.88 26.47,101.87 24.82,103.52 24.82,109.76 26.45,111.39 v1(26.45,112.27) ; R20.1 34.2,117.54 v1(34.2,117.22) 34.26,117.28 RA9.2 34.89,117.28 35.34,117.73 35.34,119.2 35.71,119.57 36.35,119.57 37.17,120.4 R114.1 ; v1(175.68,36.2) CA20.2
  BOTTOM w0.102: v1(26.45,112.27) 27.85,113.66 30.64,113.66 v1(34.2,117.22) ; v1(175.68,36.2) 175.19,36.7 174.44,36.7 172.62,34.87 153.92,34.87 151.65,37.14 137.91,37.14 136.93,38.13 121.91,38.13 121.15,38.89 118.18,38.89 116.61,40.46 109.05,40.46 106.21,43.31 103.16,43.31 101.9,44.56 99.41,44.56 98.11,45.87 91.88,45.87 85.49,52.26 83.45,52.26 80.97,54.74 76.27,54.74 68.93,62.08 66.44,62.08 66.44,62.08 66.05,62.08 65.16,62.97 53.87,62.97 53.56,63.28 44.75,63.28 43.93,64.1 37.72,64.1 29.29,72.53 29.29,73.06 25.17,77.18 25.17,77.84 23.27,79.73 23.27,86.11 26.7,89.53 v1(26.7,90.65)
SRTCRST#_ICH: length 9.7
  TOP w0.089: U4.BB10 47.89,130.65 47.8,130.56 47.23,130.56 47.14,130.47 45.47,130.47 44.75,131.19 44.42,131.19 43.79,130.56 43.31,130.56
  TOP w0.102: 43.31,130.56 C1630.1 42.72,130.12 39.98,130.12 39.4,129.55 R6425.1
SSD_SATA_DEVSLP3: length 98
  TOP w0.089: U4.AB41 57.66,115.52 v1(57.35,115.21)
  TOP w0.102: RM5.1 101.38,133.79 v1(100.74,133.79) ; v1(87.31,132.08) 87.18,132.08 86.82,131.72 86.44,131.72 86.18,131.46 86.18,125 87.33,123.85 87.33,115.8 82.96,111.43 v1(82.96,108.46) ; v1(64.12,98.17) 62.91,98.17 60.5,95.76 58.71,95.76 58.22,96.24 v1(56.75,96.24)
  BOTTOM w0.089: 57.16,111.25 57.16,115.03 v1(57.35,115.21)
  BOTTOM w0.102: v1(100.74,133.79) 100.4,134.13 v2(98.46,134.13) 98.46,132.59 97.92,132.05 96.21,132.05 94.62,133.64 91.69,133.64 90.12,132.08 v1(87.31,132.08) ; v1(82.96,108.46) 81.36,108.46 79.46,106.55 69.32,106.55 68.33,105.56 68.33,103.73 65.95,101.35 65.95,100.33 64.12,98.5 v1(64.12,98.17) ; v1(56.75,96.24) 56.75,100.36 57.06,100.67 57.06,101.57 56.62,102 56.62,107.48 56.97,107.83 56.97,109.7 57.16,109.9 57.16,111.25
SUS_PWR_ACK#: length 305.7
  TOP w0.089: U4.BB19 47.68,126.01 46.44,126.01 46.15,125.72 44.28,125.72 44.19,125.81 43.19,125.81
  TOP w0.102: v1(223.51,60.48) 227.03,56.96 PR391.2 ; 43.19,125.81 41.78,125.81 40.84,124.88 40.84,124.18 PR12.2 40.23,123.23 38.62,121.62 36.27,121.62 35.54,120.88 32.93,120.88 32.47,120.42 22.12,120.42 20.92,119.22 20.92,117.63 24.48,114.07 24.48,103.4 26.25,101.64 26.25,90.21 27.6,88.85 28.19,88.85 30.4,86.64 31.73,86.64 32.21,86.16 33.92,86.16 v1(34.04,86.03)
  BOTTOM w0.102: v1(34.04,86.03) 34.04,85.39 35.34,84.09 35.34,80.08 36.62,78.8 36.62,75.83 40.67,71.78 41.31,71.78 42.61,70.48 46.78,70.48 47.63,69.63 53.72,69.63 56.58,72.49 59.05,72.49 60.55,70.99 61.34,70.99 62.68,69.66 70.27,69.66 70.54,69.93 75.38,69.93 76.67,68.63 80.93,68.63 87.23,62.33 89.1,62.33 93.09,58.34 112.88,58.34 115.4,55.83 131.26,55.83 132.05,56.62 143.86,56.62 144.78,57.54 144.78,59.14 145.44,59.8 146.86,59.8 147.33,59.33 155.75,59.33 156.26,59.84 165.55,59.84 165.77,60.06 179.62,60.06 180.63,59.06 191.85,59.06 194.88,56.03 194.88,54.9 196.09,53.69 196.7,53.69 199.11,51.28 199.11,48.54 200.02,47.62 204.76,47.62 206.5,49.37 207.33,49.37 207.51,49.2 209.06,49.2 212.26,52.4 217.07,52.4 217.9,53.23 219.59,53.23 220.23,53.87 v2(220.23,54.99) 220.78,55.55 221.35,55.55 221.95,56.15 221.95,56.68 223.51,58.24 v1(223.51,60.48)
SUS_STAT_N: length 11.9
  TOP w0.089: U4.BC18 47.35,126.59 46.75,126.59 46.55,126.4 46.28,126.4 45.99,126.11 44.48,126.11 44.32,126.27 43.19,126.27
  TOP w0.102: R19.1 37.66,123.8 37.86,123.8 38.29,124.23 v1(38.62,124.23) 38.62,124.56 39.08,125.02 40.29,125.02 41.54,126.27 43.19,126.27
SUS_WARN#: length 289
  TOP w0.102: PR12.1 39.28,123.51 RH6.1 ; PR12.1 R6663.1 ; PR12.1 39.34,123 38.34,122 36.33,122 35.44,121.11 32.84,121.11 32.38,120.65 22.03,120.65 20.7,119.32 20.7,117.54 24.25,113.98 24.25,103.31 26.02,101.55 26.02,90.11 27.56,88.57 28.15,88.57 30.35,86.37 31.57,86.37 32.12,85.83 33.28,85.83 v1(33.54,85.57) ; RO19.1 223.52,55.53 223.52,56.44 222.97,56.99 v1(222.92,56.99)
  BOTTOM w0.102: v1(222.92,56.99) 222.71,56.99 222.18,56.45 222.18,56.06 220.45,54.33 220.45,53.77 219.69,53.01 218.12,53.01 216.48,51.36 216.48,50.81 216.04,50.37 215.48,50.37 213.5,48.39 205.89,48.39 204.9,47.4 199.92,47.4 198.88,48.44 198.88,51.19 196.61,53.46 195.93,53.46 194.6,54.79 194.6,55.33 v2(192.4,57.53) 191.12,58.8 180.33,58.8 179.41,59.72 165.83,59.72 165.67,59.56 156.95,59.56 156.5,59.11 147.23,59.11 146.77,59.57 145.53,59.57 145.01,59.05 145.01,57.44 143.96,56.39 132.14,56.39 131.35,55.6 115.31,55.6 112.82,58.09 93.02,58.09 89,62.1 87.14,62.1 80.83,68.4 76.57,68.4 75.28,69.7 70.72,69.7 70.43,69.41 62.61,69.41 61.25,70.76 60.38,70.76 58.88,72.26 56.67,72.26 53.81,69.41 47.54,69.41 46.69,70.25 42.52,70.25 41.22,71.55 40.57,71.55 36.39,75.73 36.39,78.7 35.11,79.98 35.11,84 v1(33.54,85.57)
SUSCLK_PCH: length 29.7
  TOP w0.089: U4.AN15 51.77,128.12 v1(51.77,128.02)
  TOP w0.102: v1(28.71,128.57) 27.74,128.57 26.65,129.67 R6442.1 RF176.1
  BOTTOM w0.089: 43.23,126.67 43.61,126.67 44.38,127.43 48.57,127.43 48.72,127.28 51.34,127.28 51.77,127.71 v1(51.77,128.02)
  BOTTOM w0.102: v1(28.71,128.57) 29.62,127.66 v2(30.42,127.66) 34.14,127.66 35.38,126.42 37.91,126.42 38.17,126.67 43.23,126.67
SUSCLK_SIO: length 282.5
  TOP w0.102: R6442.2 24.73,129.16 23.5,129.16 23.12,129.54 17.58,129.54 17.05,129.01 15.63,129.01 14.82,128.2 14.82,123.23 17.56,120.49 17.56,112.65 20.98,109.23 20.98,102.17 22.92,100.24 22.92,87.22 v1(24.93,85.22) ; SIO_5553.19 217.69,36.37 217.43,36.1 216.44,36.1 215.55,35.21 R3.1 214.99,34.43 v1(214.99,33.32)
  BOTTOM w0.102: v1(24.93,85.22) 24.93,83.44 27.13,81.23 27.13,80.23 28.63,78.73 28.63,76.87 30.79,74.71 30.79,73.27 38.46,65.6 44.68,65.6 45.5,64.78 54.37,64.78 54.68,64.47 69.81,64.47 71.49,62.79 78.55,62.79 84.78,56.56 86.7,56.56 90.7,52.56 110.53,52.56 116.29,46.8 119.56,46.8 121.17,45.19 134.69,45.19 135.55,46.05 152.48,46.05 155.43,43.1 173.5,43.1 176.02,45.63 183.21,45.63 186.6,42.24 190.56,42.24 200.24,32.56 208.04,32.56 208.83,33.35 214.97,33.35 v1(214.99,33.32)
SW_TPM: length 11.1
  TOP w0.089: U4.BC33 47.08,119.13 46.13,119.13 45.59,118.58 45.59,117.98 45.22,117.61 45.22,114.92 44.48,114.18 44.48,113.98 44.1,113.6 43.19,113.6
  TOP w0.102: 43.19,113.6 42.84,113.6 RS236.1 42.31,114.12 v1(41.69,114.12) 41.61,114.05 RS235.2
SYS_FAN_+12V:
  vias: v1(215.28,225.53)
SYSTEM_FAN22: length 9.3
  TOP w0.508: v1(217.76,230.81) 218.32,230.25 RF14.2 219.06,229.37 CF7.1
  TOP w0.889: 208.59,231.52 CF110.1 ; CF110.1 209.48,232.41 ; CF110.1 207.7,232.41
  BOTTOM w0.508: v1(217.76,230.81) v1(214,230.81)
  vias: v1(207.55,232.79) v1(207.55,232.03) v1(209.71,232.79) v1(209.71,232.03) v1(213.01,225.63)
SYSTEM_FAN23:
  vias: v1(200.69,224.33)
TCM_SIO_24M_TCM_R: length 4.7
  TOP w0.102: UF3.3 23.83,147.78 23.53,148.08 v1(23.53,148.5) 24.61,149.58 CF109.1 RF179.2
TCM_SIO_CLOCKI_R: length 3.3
  TOP w0.102: v1(20.99,145.8) 20.54,145.35 RF178.1 CF108.1 19.39,145.17 UF3.8
TCM_UF3_PIN2: length 6.5
  TOP w0.102: UF3.2 24,147.12 23.43,146.55 22.02,146.55 21.43,147.13 v1(21.43,148.88) RF77.2
THERMTRIP#_PCH: length 7.7
  TOP w0.089: U4.AJ3 54.67,134.28 54.8,134.28 54.88,134.36 54.88,135.05 54.76,135.17 54.76,135.42 54.39,135.79 54.39,136.07 54.64,136.32 v1(54.64,136.68) 54.87,136.68 55.08,136.88 55.08,137.16 54.97,137.26 54.84,137.26 54.71,137.39 54.71,137.69 54.93,137.91 54.93,138.07
  TOP w0.102: 54.93,138.07 54.93,138.29 55.1,138.46 55.31,138.46 55.6,138.74 55.6,139.34 55.5,139.44 55.22,139.44 55.02,139.24 R6434.1
TMIN_SHIFT: length 13
  TOP w0.102: SIO_5553.33 225.06,38.49 225.23,38.33 225.23,37.72 v1(224.69,37.18) 224.69,36.02 225.79,34.92 225.79,34.34 226.73,33.4 RO36.2 RO179.2 226.73,31.68 227.36,31.05 227.36,29.84 Q3.D
TONSET_R: length 3.8
  TOP w0.203: PR119.1 219.62,197.17 219.62,198.44 PC89.1 219.64,199.43 PR118.2 219.62,200.48 v1(219.74,200.61)
TONSETA: length 2.7
  TOP w0.203: PR121.2 224.51,196.02 224.99,195.54 224.99,195.01 v1(225.23,194.77) 225.38,194.61 PU7.43
TONSETA_R: length 3.1
  TOP w0.203: PR121.1 224.63,197.1 PC90.1 224.12,199.01 v1(224.06,199.01) 224,199.01 PR120.2
TP_AJ24: length 2.8
  TOP w0.127: v1(170.59,139.27) 170.55,139.27 CPU.AJ24
  BOTTOM w0.102: TPS72.1 171.89,138.73 171.13,138.73 v1(170.59,139.27)
TP_AK21: length 5.5
  TOP w0.102: CPU.AK21 v1(166.8,138.26)
  BOTTOM w0.102: TPS8.1 170.47,141.04 168.65,139.21 168.34,139.21 167.83,138.71 167.53,138.71 167.08,138.26 v1(166.8,138.26)
TP_AK22: length 3
  TOP w0.102: CPU.AK22 v1(167.71,138.26)
  BOTTOM w0.102: v1(167.71,138.26) 168.44,138.99 168.78,138.99 169.13,139.34 TPS9.1
TP_APU_RSVD_AC37: length 1.8
  TOP w0.102: v1(182.34,144.6) 182.28,144.6 CPU.AC37
  BOTTOM w0.102: v1(182.34,144.6) 183.17,145.43 TPS29.1
TP_APU_RSVD_AU9: length 9.9
  TOP w0.102: CPU.AU9 154.57,132.81 155.12,132.81 155.88,133.57 155.88,137.75 v1(155.93,137.8)
  BOTTOM w0.102: v1(155.93,137.8) 155.93,138.4 155.62,138.71 155.44,138.71 155.14,139.01 155.14,139.17 154.22,140.08 TPS25.1
TP_APU_RSVD_AU10: length 8
  TOP w0.102: v1(156.35,137.16) 156.35,136.85 156.47,136.74 156.47,133.79 CPU.AU10
  BOTTOM w0.102: TPS28.1 156.43,138.57 156.43,137.24 v1(156.35,137.16)
TP_APU_RSVD_AU39: length 3.2
  TOP w0.102: CPU.AU39 183.71,131.16 184.76,130.11 184.76,128.67 TPS27.1
TP_APU_RSVD_AU40: length 0.7
  TOP w0.102: CPU.AU40 185.14,130.89 TPS26.1
TP_APU_RSVD_AV39: length 0.7
  TOP w0.102: CPU.AV39 184.11,130.09 TPS21.1
TP_APU_RSVD_AW38: length 0.7
  TOP w0.102: TPS22.1 182.89,128.95 182.89,129.48 CPU.AW38
TP_APU_RSVD_B39: length 2.3
  TOP w0.102: v1(183.76,164.67) 183.94,164.48 183.94,163.63 CPU.B39
  BOTTOM w0.102: v1(183.76,164.67) 183.73,164.69 TPS24.1
TP_APU_RSVD_C40: length 1.5
  TOP w0.102: CPU.C40 v1(185.09,162.96)
  BOTTOM w0.102: TPS101.1 185.07,162.98 v1(185.09,162.96)
TP_APU_RSVD_D15: length 2.8
  TOP w0.102: CPU.D15 v1(160.01,162.94)
  BOTTOM w0.102: TPS99.1 160.56,164.22 160.56,163.53 160.01,162.98 v1(160.01,162.94)
TP_APU_RSVD_J14: length 1.8
  TOP w0.102: v1(159.09,157.48) 158.65,157.92 CPU.J14
  BOTTOM w0.102: TPS96.1 159.09,156.97 v1(159.09,157.48)
TP_APU_RSVD_J15: length 0.7
  TOP w0.102: TPS95.1 159.57,157.93 CPU.J15
TP_APU_RSVD_J19: length 2.8
  TOP w0.102: CPU.J19 v1(162.75,158.39)
  BOTTOM w0.102: v1(162.75,158.39) CPU.J19 164.18,157.92 v2(164.52,158.27)
TP_APU_RSVD_K10: length 0.7
  TOP w0.102: CPU.K10 154.99,157.03 TPS94.1
TP_APU_RSVD_K12: length 2.7
  TOP w0.102: TPS103.1 156.4,156.29 156.82,156.71 CPU.K12
TP_APU_RSVD_L10: length 2.8
  TOP w0.102: v3(155.46,156.56) 155.46,156.53 155.02,156.09 CPU.L10
  BOTTOM w0.102: TPS30.1 154.44,155.42 155.46,156.45 v3(155.46,156.56)
TP_APU_RSVD_L12: length 2.2
  TOP w0.102: CPU.L12 v1(157.29,155.63)
  BOTTOM w0.102: TPS102.1 157.29,155.52 v1(157.29,155.63)
TP_APU_RSVD_TP_AV1: length 0.7
  TOP w0.102: CPU.AV1 146.31,130.95 TPS14.1
TP_APU_RSVD_TP_AW2: length 1.5
  TOP w0.457: TPS13.1 146.97,129.95 147.51,130.49 CPU.AW2
TP_APU_RSVD_TP_H11: length 6.7
  TOP w0.102: CPU.H11 v3(155.43,159.31)
  BOTTOM w0.102: v3(155.43,159.31) 155.91,159.78 155.91,160.44 155.73,160.62 155.73,161.46 155.96,161.69 155.96,162.2 155.73,162.43 155.73,164.13 155.86,164.27 TPS20.1
TP_APU_RSVD_TP_H12: length 1.9
  TOP w0.102: CPU.H12 156.82,158.82 v1(156.37,158.37)
  BOTTOM w0.102: v1(156.37,158.37) 156.37,157.23 TPS19.1
TP_APU_RSVD_TP_K8: length 1.6
  TOP w0.102: TPS105.1 152.71,157.46 CPU.K8
TP_APU_ZVM#: length 3.9
  TOP w0.102: CPU.AC38 v1(183.25,144.66)
  BOTTOM w0.102: v1(183.25,144.66) 183.27,144.66 185.3,146.69 TPS44.1
TP_BPM#2: length 2
  TOP w0.102: v3(159.1,159.3) CPU.G14
  BOTTOM w0.102: v3(159.1,159.3) 158.29,160.11 TPS42.1
TP_BPM#3: length 1.6
  TOP w0.102: CPU.H14 v3(159.11,158.38)
  BOTTOM w0.102: v3(159.11,158.38) 159.1,158.37 TPS43.1
TP_EDP_DISP: length 2.6
  TOP w0.102: CPU.D14 v3(158.21,162.94)
  BOTTOM w0.102: v3(158.21,162.94) 157.76,163.38 157.76,164.51 TPS45.1
TP_F36: length 1.7
  TOP w0.305: v3(181.43,160.21) CPU.F36
  BOTTOM w0.102: v3(181.43,160.21) 180.57,160.21 TPS110.1
TP_F37: length 0.6
  TOP w0.305: CPU.F37 TPS109.1
TP_GPP_D4_ISH_I2C2_SDA: length 2.3
  TOP w0.089: U4.AM44 52.67,113.93 52.48,113.74 v1(52.48,113.16)
  BOTTOM w0.089: v1(52.48,113.16) 53.25,113.92 TPS128.1
TP_GPP_D14_ISH_UART0_TXD: length 2.8
  TOP w0.089: v1(53.12,112.52) 53.55,112.95 53.55,113.89 U4.AK44
  BOTTOM w0.089: TPS129.1 53.37,112.27 v1(53.12,112.52)
TP_GPP_D18_DMIC_DATA1: length 2.2
  TOP w0.089: U4.AJ38 54.18,117.22 v1(53.75,117.22)
  BOTTOM w0.089: v1(53.75,117.22) 52.74,116.2 TPS130.1
TP_GPP_D19_DMIC_CLK0: length 1.6
  TOP w0.089: U4.AJ35 53.83,118.57 v1(53.75,118.49)
  BOTTOM w0.089: v1(53.75,118.49) 53.5,118.49 TPS131.1
TP_GPP_H15_SML3ALERT_N: length 1.9
  TOP w0.089: v1(48.72,117.63) 48.49,117.87 48.42,117.87 48.17,118.12 U4.BB36
  BOTTOM w0.089: v1(48.72,117.63) 49.09,117.27 TPS132.1
TP_GPP_H18_SML4ALERT_N: length 1.6
  TOP w0.089: U4.BC36 47.69,117.63 48.09,117.63 v1(48.09,117.63)
  BOTTOM w0.089: TPS133.1 47.8,117.35 v1(48.09,117.63)
TP_PCH_B19: length 5.3
  TOP w0.089: v1(69.38,127.1) 69.38,126.92 68.86,126.41 68.08,126.41 67.98,126.5 67.98,126.5 67.93,126.55 67.63,126.55 U4.B19
  BOTTOM w0.089: TPS127.1 67.52,126.42 68.87,126.42 69.38,126.92 v1(69.38,127.1)
TP_PCH_B20: length 3
  TOP w0.089: v1(69.6,126.26) 69.32,126.26 69.07,126.01 67.82,126.01 U4.B20
  BOTTOM w0.089: v1(69.6,126.26) 69.27,126.26 TPS123.1
TP_PCH_C19: length 4.9
  TOP w0.089: U4.C19 67.15,126.64 67.43,126.36 67.85,126.36 67.9,126.31 67.9,126.31 68.01,126.21 68.98,126.21 69.47,126.7 69.6,126.7 v1(70.01,127.1)
  BOTTOM w0.089: TPS126.1 69.35,127.76 69.88,127.24
  BOTTOM w0.102: 69.88,127.24 v1(70.01,127.1)
TP_PCH_C20: length 5.1
  TOP w0.089: v1(70.24,126.26) 69.79,125.82 67.5,125.82 U4.C20
  BOTTOM w0.102: TPS122.1 70.77,127.23 70.24,126.7 v1(70.24,126.26)
TP_PCH_E17: length 3.4
  TOP w0.089: U4.E17 65.89,127.67 v1(65.89,128.02)
  BOTTOM w0.089: v1(65.89,128.02) 66.46,128.02 TPS125.1
TP_PCH_G17: length 2.4
  TOP w0.089: U4.G17 65.38,127.86 v1(65.23,128.02)
  BOTTOM w0.089: v1(65.23,128.02) 65.23,128.57 TPS124.1
TP_PCH_K17: length 2.6
  TOP w0.089: v3(63.47,128.99) 63.47,127.8 U4.K17
  BOTTOM w0.089: v3(63.47,128.99) 63.5,129.03 TPS120.1
TP_PCH_L17: length 1.6
  TOP w0.089: v1(62.74,128.11) U4.L17
  BOTTOM w0.089: v1(62.74,128.11) 62.74,127.76 TPS121.1
TP_PCH_RSVD0: length 3.4
  TOP w0.089: U4.BE2 45.96,135.46 v1(45.96,136.04)
  BOTTOM w0.089: v1(45.96,136.04) 46.36,136.45 46.36,136.58 46.72,136.93 TPS73.1
TP_PCH_RSVD1: length 2.1
  TOP w0.089: U4.BD1 46.59,135.53 v1(46.59,136.04)
  BOTTOM w0.089: v1(46.59,136.04) 46.59,135.46 TPS74.1
TP_PCH_RSVD2: length 2.7
  TOP w0.089: U4.AR22 51.42,125.18 51.46,125.22 51.47,125.22 51.92,125.67 v1(51.95,125.67)
  BOTTOM w0.089: TPS75.1 52.23,125.39 v1(51.95,125.67)
TP_PCH_RSVD3: length 1.8
  TOP w0.089: v1(51.98,122.17) 51.98,122.01 52.28,121.71 U4.AN29
  BOTTOM w0.089: v1(51.98,122.17) 52.46,121.69 TPS76.1
TP_PCH_RSVD4: length 3.3
  TOP w0.089: U4.AG15 55.54,128.35 55.02,128.86 v1(55.02,129.03)
  BOTTOM w0.089: TPS77.1 54.34,129.72 v1(55.02,129.03)
TP_PCH_RSVD5: length 2.5
  TOP w0.089: U4.AG14 55.54,129.13 54.93,129.73 v1(54.93,129.94)
  BOTTOM w0.089: TPS78.1 v1(54.93,129.94)
TP_PCH_RSVD6: length 1.1
  TOP w0.089: TPS79.1 55.1,128.22 U4.AF17
TP_PCH_RSVD7: length 1
  TOP w0.089: TPS80.1 57.26,128.12 56.7,127.56 U4.AE17
TP_PCH_RSVD8: length 0.7
  TOP w0.089: TPS81.1 58.1,129.59 U4.AB13
TP_PCH_RSVD9: length 1.5
  TOP w0.089: v3(59.54,129.23) U4.W13
  BOTTOM w0.089: TPS82.1 59.44,129.14 v3(59.54,129.23)
TP_PCH_RSVD10: length 2
  TOP w0.089: U4.U13 60.72,130.05 v3(60.87,130.05)
  BOTTOM w0.089: TPS83.1 v3(60.87,130.05)
TP_PCH_RSVD11: length 2.2
  TOP w0.089: U4.R27 61.12,122.42 v1(61.49,122.05)
  BOTTOM w0.089: v1(61.49,122.05) 61.48,122.05 TPS84.1
TP_PCH_RSVD12: length 2.3
  TOP w0.089: v1(61.37,123.32) 61.37,123.54 U4.R24
  BOTTOM w0.089: v1(61.37,123.32) 61.37,124.31 TPS85.1
TP_PCH_RSVD13: length 3
  TOP w0.089: v1(61.09,120.2) 61.49,120.2 U4.P31
  BOTTOM w0.089: TPS86.1 60.39,120.2 v1(61.09,120.2)
TP_PCH_RSVD14: length 2.8
  TOP w0.089: v1(61.27,120.86) 61.27,121.1 U4.P29
  BOTTOM w0.089: v1(61.27,120.86) 61.6,120.53 61.6,119.18 TPS87.1
TP_PCH_RSVD15: length 1.8
  TOP w0.089: U4.P27 62.11,122.25 v1(62.11,121.91)
  BOTTOM w0.089: v1(62.11,121.91) 62.11,122.65 TPS88.1
TP_PCH_RSVD16: length 2.5
  TOP w0.089: v1(62.75,123.32) 62.62,123.44 62.02,123.44 U4.P24
  BOTTOM w0.089: v1(62.75,123.32) 62.82,123.39 TPS89.1
TP_PCH_RSVD17: length 3
  TOP w0.089: v1(62.14,119.76) 62.14,120.09 U4.N31
  BOTTOM w0.089: v1(62.14,119.76) 62.14,119.33 63,118.47 TPS90.1
TP_PCH_RSVD18: length 2.6
  TOP w0.089: U4.N29 62.06,121.13 v1(62.06,120.9)
  BOTTOM w0.089: v1(62.06,120.9) 62.06,120.68 62.95,119.79 TPS91.1
TP_PCH_TP4: length 1.7
  TOP w0.089: U4.AN17 52.18,127.6 52.6,128.02 v1(52.6,128.15)
  BOTTOM w0.089: TPS70.1 52.56,128.1 v1(52.6,128.15)
TP_PCH_TP5: length 2.8
  TOP w0.089: U4.AR19 51.45,126.23 v1(51.88,126.67)
  BOTTOM w0.089: v1(51.88,126.67) 52.31,126.24 52.99,126.24 TPS71.1
TP_SIO_GP054: length 2.4
  TOP w0.102: v1(210.42,47.29) SIO_5553.106
  BOTTOM w0.102: TPS5.1 211.41,47.29 v1(210.42,47.29)
TPM_BADD: length 4
  TOP w0.102: v1(38.13,96.01) 38.7,95.44 RF30.1 38.69,95.11 UF1.6
  BOTTOM w0.102: v2(37.88,97.16) 37.88,96.27 v1(38.13,96.01)
TPM_CLK: length 4.3
  TOP w0.102: RF37.2 31.02,95.63 v1(31.28,95.38) 31.54,95.11 UF1.19
  BOTTOM w0.102: v1(31.28,95.38) 30.13,95.38 v2(29.24,96.27)
TPM_CS2_LFRAM#_R: length 1.6
  TOP w0.102: RF28.2 v1(31.25,94.62) 32.09,94.62 UF1.20
TPM_PP: length 3.8
  TOP w0.102: RF25.2 RF26.1 38.26,94.11 38.26,94.11 38,94.11 v1(37.88,94.23) 37.76,94.11 UF1.4
  BOTTOM w0.102: v2(37.88,95.25) v1(37.88,94.23)
TPM_QF1_G: length 3
  TOP w0.102: v1(31.48,98.42) 30.96,98.42 QF1.G 30.2,99.06 30.07,98.93 RF33.2
TPM_RST_N: length 6.6
  TOP w0.102: UF1.17 32.09,98.11 32.23,98.25 QF1.S 32.23,99.19 32.42,99.38 RF34.1 RF32.2 34.18,100.52 34.3,100.41 v1(34.3,100.28)
TPM_SERIRQ: length 1.7
  TOP w0.102: RF29.2 33.56,90.93 v1(33.41,91.08) 33.83,91.5 UF1.27
TPM_SPIIRQ: length 2.3
  TOP w0.102: RF45.1 29.56,98.17 v1(29.48,98.25) RF27.2
TPM_TCM_CS: length 19.6
  TOP w0.089: v3(49.69,118.9) 49.23,118.9 48.83,119.3 U4.BA33
  TOP w0.102: RS233.2 v1(46.13,105.28) RS234.1
  BOTTOM w0.089: v3(49.69,118.9) 49.69,118.45 49.29,118.05 46.99,118.05 46.53,117.58 46.53,116.16 46.16,115.79 46.16,114.01 45.97,113.83 45.97,112.78 45.99,112.76 45.99,112.44
  BOTTOM w0.102: 45.99,112.44 45.99,108.7 45.63,108.33 v2(45.63,106.65) 45.63,105.79 v1(46.13,105.28)
TPM_VDD2: length 3.4
  TOP w0.102: RF53.2 CF24.2 34.58,97.79 v1(34.7,97.66) 34.32,97.66 33.83,97.17 UF1.14
TSEN: length 34.4
  TOP w0.203: v1(215.93,200.53) 215.55,200.15 215.55,198.63 215.79,198.39 217.44,198.39 218.16,197.68 218.16,196.72 PR163.1 219.31,195.57 PU7.1 ; PRT3.2 207.17,214.63 v1(207.68,214.12)
  BOTTOM w0.203: v1(207.68,214.12) 208.31,214.12 209.51,212.93 216.47,212.93 218.53,210.87 218.53,207.41 216.57,205.44 216.57,201.17 v1(215.93,200.53)
TSEN_R1: length 29.2
  TOP w0.203: PRT3.1 206.47,213.87 v1(206.92,213.87) ; PR159.1 215.01,198.79 215.22,199.01 215.22,201.73 v1(215.93,202.44)
  BOTTOM w0.203: v1(215.93,202.44) 215.15,203.23 215.15,205.97 215.51,206.33 216.99,206.33 218.2,207.54 218.2,210.73 216.34,212.6 209.08,212.6 208.57,213.11 207.68,213.11 v1(206.92,213.87)
TSEN_R2: length 2.8
  TOP w0.203: 217.2,198.87 217.5,198.87 218.68,197.69 v1(218.79,197.69) PR163.2
TSENA: length 41.2
  TOP w0.203: v1(228.89,171.22) 228.67,171 228.67,170.72 PRT4.2 ; PR164.2 226.47,195.26 v3(226.47,194.69) 226.47,194.18 225.97,193.68 225.97,193.55 225.76,193.34 PU7.42
  BOTTOM w0.203: v1(228.89,171.22) 228.66,171.45 228.66,172.34 227.62,173.37 227.11,173.37 v2(226.49,173.99) 226.02,174.46 226.02,176.33 230.61,180.93 230.61,182.87 231.68,183.94 231.68,185.22 231.27,185.62 231.27,186.66 232.9,188.29 232.9,190.17 231.83,191.24 231.83,192.48 232.16,192.81 232.16,194.64 232.57,195.05 232.57,195.45 232.19,195.83 229.27,195.83 228.13,194.69 v3(226.47,194.69)
TSENA_R1: length 32.4
  TOP w0.203: v1(232.06,195.22) 231.52,195.77 PR165.1 ; PRT4.1 228.33,170.7 228.33,171.02 v1(228.13,171.22)
  BOTTOM w0.203: v1(232.06,195.22) 231.81,194.97 231.81,193.07 231.45,192.71 231.45,191.13 232.54,190.04 232.54,188.42 230.94,186.82 230.94,185.42 231.3,185.06 231.3,184.02 230.28,183 230.28,181.11 225.69,176.51 225.69,176.02 v2(225.35,175.68) 225.68,175.35 225.68,173.85 226.5,173.03 227.5,173.03 228.33,172.2 228.33,171.42 v1(228.13,171.22)
TSENA_R2: length 1.5
  TOP w0.203: PR164.1 v1(225.59,197.87) PR166.2
U_USB1N_R: length 19.6
  TOP w0.102: v1(150.67,18.4) 150.78,18.51 150.78,19.6 UU9.4 151.38,19.87 152.29,20.78 152.29,21.47 151.42,22.34 151.42,23.4 LU36.2 151.68,23.67 RU54.2
  BOTTOM w0.102: v1(150.67,18.4) 150.5,18.56 150.5,18.87 150.25,19.13 149.71,19.13 149.11,18.52 149.11,17.3 148.42,16.61 148.42,15.5 147.55,14.63 145.4,14.63 144.69,13.92 144.69,13.51 144.03,12.85 143.7,12.85 143.42,12.57 143.42,12.34 143.24,12.17 F_USB3.2
U_USB1P_R: length 19.6
  TOP w0.102: v1(149.91,18.4) 150.05,18.4 150.58,18.92 150.58,19.4 150.2,19.78 150.2,20.9 UU9.6 151.22,21.92 151.22,22.94 150.72,23.43 LU36.1 150.41,23.67 RU55.2
  BOTTOM w0.102: v1(149.91,18.4) 150.08,18.4 150.3,18.62 150.3,18.79 150.16,18.92 149.79,18.92 149.31,18.44 149.31,17.21 148.62,16.53 148.62,15.42 147.63,14.43 145.48,14.43 144.89,13.83 144.89,13.43 144.11,12.65 143.78,12.65 143.62,12.49 143.62,12.32 143.77,12.17 F_USB3.3
U_USB2N_R: length 15
  TOP w0.102: RU58.2 148.11,23.45 LU37.1 148.37,23.17 148.37,22.86 147.77,22.26 147.77,21.06 147.29,20.58 147.29,20.12 147.55,19.87 UU9.3 148.76,19.61 148.76,19.47 148.76,19.47 148.76,19.25 148.66,19.14 148.13,19.14 147.9,18.91 147.9,18.68 v1(147.62,18.4)
  BOTTOM w0.102: F_USB3.11 143.55,15.37 143.65,15.47 143.65,15.7 144.57,16.62 144.57,16.99 145.37,17.79 147.7,17.79 147.9,17.99 147.9,18.12 v1(147.62,18.4)
U_USB2P_R: length 15
  TOP w0.102: RU59.2 148.91,23.45 LU37.2 148.57,23.09 148.57,22.78 147.97,22.18 147.97,22.01 148.23,21.75 UU9.1 149.07,21.75 149.32,21.5 149.32,19.74 148.97,19.39 148.97,19.16 148.75,18.94 148.22,18.94 148.1,18.83 148.1,18.5 148.21,18.4 v1(148.39,18.4)
  BOTTOM w0.102: v1(148.39,18.4) 148.1,18.11 148.1,17.91 147.78,17.58 145.46,17.58 144.78,16.9 144.78,16.54 143.85,15.61 143.85,15.47 143.95,15.37 F_USB3.12
U_USB3N_R: length 17.9
  TOP w0.102: SSUSB_R.2 134.82,247.94 134.58,248.18 134.58,248.48 134.21,248.84 132.94,248.84 132.5,248.41 132.5,247.46 133.27,246.69 133.27,246.14 132.43,245.3 132.43,244.34 133.21,243.56 133.21,241.86 UU3.1 130.94,239.6 130.94,238.18 131.21,237.92 131.21,237.2 130.9,236.9 LU4.4 130.67,236.41 RU13.2
U_USB3P_R: length 17.9
  TOP w0.102: RU15.2 131.94,236.41 LU4.3 131.71,236.9 131.41,237.19 131.41,238.18 UU3.3 132.38,239.15 132.59,239.15 132.97,239.54 132.97,240.01 132.54,240.44 132.54,240.91 133.41,241.77 133.41,243.64 132.63,244.42 132.63,245.21 133.48,246.06 133.48,246.78 132.7,247.55 132.7,248.32 133.02,248.64 134.12,248.64 134.37,248.39 134.37,247.97 134.13,247.73 133.62,247.73 SSUSB_R.3
U_USB4N_R: length 18.3
  TOP w0.102: NIC_USB.6 112.79,244.19 112.68,244.3 112.68,244.63 112.05,245.26 108.1,245.26 107.65,245.71 105.03,245.71 103.74,244.42 102.5,244.42 102.21,244.71 100.34,244.71 100.14,244.51 UU1.4 100.14,243.71 99.86,243.43 99.72,243.43 99.08,244.07 98.75,244.07 LU2.2 98.44,244.37 RU120.1
U_USB4P_R: length 18.3
  TOP w0.102: RU5.1 98.44,243.56 LU2.1 98.75,243.87 99,243.87 99.63,243.23 100.56,243.23 101.04,242.75 101.74,242.75 102.02,243.03 UU1.6 102.27,244.22 103.83,244.22 105.12,245.51 107.57,245.51 108.02,245.06 111.96,245.06 112.48,244.54 112.48,244.36 112.31,244.19 NIC_USB.7
U_USB5N_R: length 17.1
  TOP w0.102: NIC_USB.2 112.63,246.81 112.53,246.71 112.53,246.28 112,245.75 108.47,245.75 107.97,246.25 103.46,246.25 103.09,245.88 102.39,245.88 102.27,245.76 100.89,245.76 UU1.3 99.98,246.66 99.43,246.66 99.28,246.51 98.84,246.51 98.45,246.12 LU1.1 98.22,245.87 RU3.1
U_USB5P_R: length 17.1
  TOP w0.102: RU4.1 98.22,247.14 LU1.2 98.65,246.71 99.19,246.71 99.35,246.87 99.55,246.87 100.41,247.73 100.8,247.73 UU1.1 102.44,246.08 103.01,246.08 103.37,246.45 108.05,246.45 108.55,245.95 111.91,245.95 112.33,246.36 112.33,246.71 112.22,246.81 NIC_USB.3
U_USB6N_R: length 16.5
  TOP w0.102: LU23.4 44.08,74.95 44.38,74.65 44.66,74.65 44.91,74.4 44.91,74.07 45.09,73.89 45.35,73.89 45.45,73.99 45.45,75.26 45.93,75.74 47.95,75.74 49.41,74.27 52.81,74.27 53.3,74.75 53.3,76.54 53.08,76.76 52.75,76.76 52.24,76.24 WF_BT_USB.3
U_USB6P_R: length 16.5
  TOP w0.102: LU23.3 44.08,74.15 44.38,74.45 44.58,74.45 44.71,74.31 44.71,73.98 45.01,73.69 47.02,73.69 47.33,73.99 47.33,75.37 47.49,75.53 47.86,75.53 49.33,74.07 52.9,74.07 53.5,74.67 53.5,76.62 WF_BT_USB.5
U_USB7N_R: length 12.1
  TOP w0.102: RU10.2 134.25,236.63 LU35.3 134.25,236.74 133.94,237.05 133.94,237.26 134.12,237.44 134.45,237.44 134.96,237.95 134.96,238.86 135.44,239.35 135.44,240.06 135.16,240.33 UU3.6 133.97,240.59 133.97,240.73 135.42,242.18 135.42,243.64 134.63,244.43 134.63,244.57 134.79,244.74 SSUSB_R.11
U_USB7P_R: length 12.1
  TOP w0.102: SSUSB_R.12 134.29,244.74 134.42,244.6 134.42,244.35 135.21,243.56 135.21,242.27 133.48,240.53 133.48,238.66 133.68,238.46 UU3.4 134.48,238.46 134.76,238.18 134.76,238.04 134.36,237.64 134.04,237.64 133.74,237.35 133.74,237.05 133.44,236.74 LU35.4 133.44,236.63 RU12.2
U_USB8N_R: length 9.6
  TOP w0.102: WF_BT_USB.4 49.7,76.42 49.59,76.52 48.51,76.52 48.22,76.23 45.85,76.23 45.45,76.63 UU13.6 45.45,77.91 45.27,78.09 45.04,78.09 44.94,77.99 44.94,77.35 44.7,77.1 44.4,77.1 44.11,76.81 LU24.3
U_USB8P_R: length 9.6
  TOP w0.102: LU24.4 44.08,77.62 44.39,77.3 44.61,77.3 44.74,77.43 44.74,78.08 44.96,78.3 46.84,78.3 47.33,77.81 UU13.4 47.33,76.62 47.52,76.43 48.13,76.43 48.42,76.72 49.59,76.72 49.7,76.82 WF_BT_USB.6
UEFI_S: length 17
  TOP w0.089: U4.N43 62.59,114.28 62.59,113.54 62.9,113.23 62.9,112.65 64.17,111.38 64.17,111.25
  TOP w0.102: 64.17,111.25 64.17,110.81 64.55,110.43 64.55,106.93 65.31,106.17 66,106.17 66.33,105.84 R6668.2 66.93,104.74 66.93,103.73 68.8,101.85 UEFI.1
USB2_ID: length 4.7
  TOP w0.089: 55.42,137.83 55.27,137.68 55.27,135.13 55.18,135.04 55.18,134.74 U4.AG2
  TOP w0.102: 55.42,137.83 v1(55.79,138.2) 56.04,138.46 R6602.1
USB3_RXDN1: length 185
  TOP w0.089: 70.33,133.6 70.31,133.6 70.3,133.61 69.83,133.61 69.18,132.96 69.18,132.65 68.63,132.1 67.92,132.1 U4.B7
  TOP w0.102: F_USB3.5 147.05,13.67 146.54,13.16 146.54,12.68 146.44,12.57 146.44,11.84 146.92,11.35 147.56,11.35 148.47,12.26 148.47,17.17 148,17.63 146.93,17.63 146.29,18.27 146.29,18.79 146.22,18.87 UU26.9 UU26.2 146.22,28.51 120.52,54.2 92.06,54.2 81.31,64.95 81.31,82.21 77.27,86.25 77.27,92.12 75.6,93.79 75.6,96.94 74.48,98.06 74.48,104.99 77.68,108.19 77.68,114.96 79.28,116.56 79.28,119.62 78.67,120.23 78.67,121.35 77.86,122.17 77.86,123.99 75.98,125.87 75.98,129.69 72.07,133.6 70.33,133.6
USB3_RXDN2: length 178.9
  TOP w0.089: v1(66.4,132.28) 66.53,132.28 67,131.81 U4.C8
  TOP w0.102: F_USB3.14 147.34,16.87 147.24,16.76 147.24,16.53 146.69,15.97 145.24,15.97 145.16,16.05 144.39,16.05 144.21,15.88 143.36,15.88 142.7,16.53 142.7,17.11 141.81,18 141.81,18.5 141.52,18.8 UU10.9 UU10.2 141.52,20.48 141.76,20.72 141.76,30.91 119.84,52.83 91.49,52.83 79.94,64.38 79.94,81.5 75.83,85.62 75.83,91.51 74.05,93.29 74.05,96.25 73.08,97.21 73.08,105.77 76.23,108.92 76.23,115.54 77.91,117.22 77.91,119.05 77.2,119.77 77.2,120.79 76.49,121.5 76.49,123.26 74.51,125.24 74.51,129.2 72.75,130.96 72.47,130.96 72.07,131.36 v3(71.44,131.36)
  BOTTOM w0.089: v1(66.4,132.28) 66.63,132.05 66.63,131.68 66.98,131.32 68.19,131.32 68.2,131.32 68.22,131.32
  BOTTOM w0.102: 68.22,131.32 70.6,131.32 71.07,131.78 71.32,131.78 71.38,131.72 71.44,131.66 v3(71.44,131.36)
USB3_RXDN3: length 167.6
  TOP w0.089: v3(69.85,131.99) 69.85,132.14 69.69,132.3 69.5,132.3 68.93,131.72 68.93,131.56 68.68,131.31 68.52,131.31 68.27,131.05 68.04,131.05 U4.B10
  TOP w0.102: SSUSB_R.5 131.12,246.44 131.61,246.93 131.61,247.49 131.71,247.58 131.71,248.26 131.22,248.74 130.61,248.74 129.62,247.75 129.62,246.1 129.7,246.02 129.7,243.45 127.86,241.61 127.86,240.06 128.01,239.92 UU7.9 UU7.2 128.01,237.86 127.86,237.71 127.86,231.63 127.36,231.13 127.36,221.48 122.26,216.38 100.55,216.38 91.68,207.51 91.68,163.39 93.07,161.99 93.07,158.18 92.79,157.9 v3(92.79,157.54)
  BOTTOM w0.102: v3(92.79,157.54) 92.43,157.54 92.04,157.15 91.37,157.15 89.47,155.24 88.06,155.24 85.93,153.11 84.66,153.11 82.98,151.43 79.61,151.43 73.74,145.57 73.74,139.41 72.25,137.91 72.25,134 70.58,132.33 70.2,132.33 v3(69.85,131.99)
USB3_RXDN4: length 163.2
  TOP w0.089: U4.E11 65.86,130.98 v3(65.86,131.21)
  TOP w0.102: v3(93.76,159.05) 93.76,159.53 93.56,159.74 93.56,162.19 92.16,163.59 92.16,207.31 100.75,215.9 122.46,215.9 127.87,221.31 127.87,230.49 129.16,231.77 129.16,237.71 129.01,237.86 UU7.4 UU7.7 129.01,239.92 129.16,240.06 129.16,240.37 131.31,242.52 131.31,243.13 131.2,243.24 SSUSB_R.14
  BOTTOM w0.089: v3(65.86,131.21) 65.69,131.04 65.48,131.04 65.39,131.13 65.39,132.14 66.22,132.98 67.55,132.98 67.55,132.97 67.58,132.97
  BOTTOM w0.102: 67.58,132.97 69.28,132.97 70.02,133.71 70.73,133.71 71.56,134.54 71.56,138.22 73.06,139.72 73.06,145.9 79.31,152.15 82.72,152.15 84.37,153.8 85.65,153.8 87.78,155.93 89.18,155.93 92.94,159.69 93.61,159.69 93.76,159.53 v3(93.76,159.05)
USB3_RXDP1: length 185
  TOP w0.089: U4.A7 68.19,132.29 68.55,132.29 68.99,132.73 68.99,133.04 69.75,133.8 70.3,133.8 70.31,133.81 70.33,133.81
  TOP w0.102: F_USB3.6 146.34,13.08 146.34,12.76 146.24,12.66 146.24,11.75 146.84,11.15 147.64,11.15 148.67,12.18 148.67,17.25 148.09,17.83 147.01,17.83 146.49,18.35 146.49,18.65 146.72,18.87 UU26.10 UU26.1 146.72,20.5 146.42,20.8 146.42,28.59 120.61,54.41 92.14,54.41 81.52,65.03 81.52,82.3 77.48,86.33 77.48,92.2 75.8,93.88 75.8,97.03 74.68,98.15 74.68,104.9 77.89,108.1 77.89,114.88 79.48,116.48 79.48,119.71 78.87,120.32 78.87,121.44 78.06,122.25 78.06,124.08 76.18,125.96 76.18,129.78 72.15,133.81 70.33,133.81
USB3_RXDP2: length 178.8
  TOP w0.089: U4.B8 67.74,131.89 67.32,132.31 v1(67.11,132.31)
  TOP w0.102: F_USB3.15 146.94,16.87 147.04,16.76 147.04,16.61 146.6,16.18 145.32,16.18 145.24,16.26 144.31,16.26 144.13,16.08 143.44,16.08 142.91,16.61 142.91,17.2 142.02,18.09 UU10.10 UU10.1 142.02,20.59 141.97,20.64 141.97,30.99 119.92,53.04 91.57,53.04 80.14,64.46 80.14,81.58 76.03,85.7 76.03,91.59 74.25,93.37 74.25,96.33 73.29,97.3 73.29,105.68 76.44,108.83 76.44,115.46 78.11,117.13 78.11,119.14 77.4,119.85 77.4,120.87 76.69,121.58 76.69,123.34 74.71,125.32 74.71,129.28 72.83,131.16 72.55,131.16 72.07,131.65 v3(72.07,131.98)
  BOTTOM w0.089: v1(67.11,132.31) 66.82,132.02 66.82,131.76 67.06,131.51 68.19,131.51 68.2,131.52 68.22,131.52
  BOTTOM w0.102: v3(72.07,131.98) 70.98,131.98 70.52,131.52 68.22,131.52
USB3_RXDP3: length 167.6
  TOP w0.089: v3(69.85,132.88) 69.85,132.66 69.68,132.49 69.43,132.49 68.74,131.8 68.74,131.64 68.6,131.5 68.44,131.5 68.23,131.7 68.08,131.7 67.99,131.61 67.99,131.45 U4.A9
  TOP w0.102: v3(92.16,158.17) 92.31,158.01 92.62,158.01 92.87,158.27 92.87,161.91 91.47,163.3 91.47,207.59 100.47,216.59 122.18,216.59 127.16,221.57 127.16,231.22 127.66,231.71 127.66,237.71 127.51,237.86 UU7.1 UU7.10 127.51,239.92 127.66,240.06 127.66,241.7 129.5,243.54 129.5,245.94 129.42,246.02 129.42,247.84 130.53,248.95 131.31,248.95 131.91,248.34 131.91,247.5 131.82,247.4 131.82,247.03 SSUSB_R.6
  BOTTOM w0.102: v3(92.16,158.17) 92.29,158.04 92.29,157.68 91.96,157.35 91.29,157.35 89.39,155.45 87.98,155.45 85.85,153.31 84.57,153.31 82.89,151.64 79.53,151.64 73.54,145.65 73.54,139.5 72.04,138 72.04,134.09 70.49,132.54 70.2,132.54 v3(69.85,132.88)
USB3_RXDP4: length 163.1
  TOP w0.089: U4.G11 65.31,130.66 64.98,130.99 v3(64.91,130.99)
  TOP w0.102: v3(94.39,159.68) 93.91,159.68 93.76,159.82 93.76,162.28 92.36,163.67 92.36,207.22 100.84,215.7 122.55,215.7 128.07,221.22 128.07,230.4 129.36,231.69 129.36,237.71 129.51,237.86 UU7.5 UU7.6 129.51,239.92 129.36,240.06 129.36,240.28 131.51,242.43 131.51,243.13 131.61,243.24 SSUSB_R.15
  BOTTOM w0.089: 67.58,133.17 67.55,133.17 67.55,133.17 66.14,133.17 65.2,132.22 65.2,131.28 v3(64.91,130.99)
  BOTTOM w0.102: v3(94.39,159.68) 93.91,159.68 93.69,159.89 92.86,159.89 89.1,156.13 87.7,156.13 85.56,154 84.29,154 82.64,152.35 79.22,152.35 72.85,145.98 72.85,139.8 71.36,138.3 71.36,134.62 70.65,133.91 69.93,133.91 69.2,133.17 67.58,133.17
USB3_TX1_PCH_DN_C: length 13.6
  TOP w0.102: CO44.1 145.01,21.46 145.01,21.23 144.86,21.09 144.86,20.62 144.72,20.48 UU26.5 UU26.6 144.72,18.92 144.86,18.77 144.86,18.57 144.78,18.49 144.43,18.49 144.18,18.24 144.18,17.94 144.04,17.79 v3(143.84,17.79)
  BOTTOM w0.102: v3(143.84,17.79) 144.16,17.79 144.26,17.89 144.26,18.22 144.12,18.36 143.67,18.36 142.78,17.48 142.78,16.46 141.89,15.57 141.89,15.39 140.65,14.15 140.65,13.84 140.83,13.67 F_USB3.8
USB3_TX1_PCH_DP_C: length 13.6
  TOP w0.102: CO43.1 145.21,21.51 145.21,21.15 145.07,21.01 145.07,20.65 145.22,20.5 UU26.4 UU26.7 145.22,18.97 145.07,18.82 145.07,18.49 144.87,18.29 144.52,18.29 144.39,18.16 144.39,17.95 144.55,17.79 v3(144.73,17.79)
  BOTTOM w0.102: F_USB3.9 140.29,13.67 140.45,13.82 140.45,14.23 141.69,15.48 141.69,15.65 142.58,16.54 142.58,17.56 143.59,18.57 144.2,18.57 144.46,18.31 144.46,18.06 v3(144.73,17.79)
USB3_TX2_PCH_DN_C: length 6.7
  TOP w0.102: CO45.1 140.29,21.89 140.03,21.62 140.03,21.41 140.37,21.06 140.37,20.84 140.52,20.7 UU10.4 UU10.7 140.52,18.64 140.37,18.49 140.37,17.7 140.85,17.22 140.85,16.97 140.95,16.87 F_USB3.17
USB3_TX2_PCH_DP_C: length 6.6
  TOP w0.102: F_USB3.18 140.55,16.87 140.65,16.97 140.65,17.14 140.17,17.62 140.17,18.49 140.02,18.64 UU10.6 UU10.5 140.02,20.7 140.17,20.84 140.17,20.98 139.82,21.32 139.82,21.66 139.59,21.89 CO46.1
USB3_TX3_PCH_DN_C: length 13.3
  TOP w0.102: SSUSB_R.8 137.2,246.44 137.31,246.33 137.31,246.11 137.95,245.47 138.43,245.47 139.1,244.8 139.1,241.04 138.43,240.37 138.43,240.06 138.28,239.92 UU6.7 UU6.4 138.28,237.86 138.43,237.71 138.43,236.8 138.06,236.43 138.06,236.18 CO26.2
USB3_TX3_PCH_DP_C: length 13.3
  TOP w0.102: SSUSB_R.9 137.61,246.44 137.51,246.33 137.51,246.19 138.03,245.67 138.52,245.67 139.3,244.88 139.3,240.96 138.63,240.28 138.63,240.06 138.78,239.92 UU6.6 UU6.5 138.78,237.86 138.63,237.71 138.63,236.72 138.26,236.35 138.26,236.18 CO25.2
USB3_TX4_PCH_DN_C: length 9.1
  TOP w0.102: CO28.2 136.03,236.18 136.03,236.46 136.93,237.36 136.93,237.71 136.78,237.86 UU6.1 UU6.10 136.78,239.92 136.93,240.06 136.93,240.67 137.31,241.05 137.31,243.13 137.2,243.24 SSUSB_R.17
USB3_TX4_PCH_DP_C: length 9.1
  TOP w0.102: SSUSB_R.18 137.61,243.24 137.51,243.13 137.51,240.96 137.13,240.58 137.13,240.06 137.28,239.92 UU6.9 UU6.2 137.28,237.86 137.13,237.71 137.13,237.27 136.23,236.37 136.23,236.18 CO27.2
USB3_TXDN1: length 167.7
  TOP w0.089: U4.C11 67.28,130.67 67.52,130.43 67.85,130.43 67.9,130.48 68.08,130.66 68.94,130.66 69.57,131.29 70.3,131.29 70.31,131.29 70.33,131.29
  TOP w0.102: 70.33,131.29 70.61,131.29 70.9,131.57 70.9,132.59 71.2,132.89 71.81,132.89 75.22,129.48 75.22,125.57 77.17,123.61 77.17,121.79 77.93,121.03 77.93,120 78.6,119.34 78.6,116.93 77,115.33 77,108.66 73.79,105.46 73.79,97.47 74.73,96.53 74.73,93.62 76.52,91.83 76.52,85.94 80.63,81.83 80.63,64.66 91.77,53.52 120.22,53.52 144.82,28.92 144.82,25.55 v1(144.69,25.43) 144.99,25.12 144.99,23.2 CO44.2
USB3_TXDN2: length 161.9
  TOP w0.089: 71.15,130.86 71.13,130.86 71.12,130.85 69.43,130.85 69.04,130.46 68.15,130.46 67.75,130.05 U4.B12
  TOP w0.102: CO45.2 140.24,23.04 140.24,23.39 v1(140.37,23.52) 140.37,24.65 140.14,24.88 140.14,31.75 119.54,52.35 91.29,52.35 79.46,64.18 79.46,81.3 75.34,85.42 75.34,91.3 73.57,93.07 73.57,96.05 72.6,97.01 72.6,105.97 75.73,109.09 75.73,115.71 77.43,117.42 77.43,118.85 76.72,119.57 76.72,120.58 75.98,121.32 75.98,123.06 74.01,125.04 74.01,129.01 73.03,129.98 72.46,129.98 71.58,130.86 71.15,130.86
USB3_TXDN3: length 163.9
  TOP w0.089: v3(70.67,130.18) 70.31,130.18 70.12,129.98 70.12,129.73 69.89,129.49 68.85,129.49 68.71,129.63 67.38,129.63 U4.C13
  TOP w0.102: CO26.1 137.83,234.89 138.06,234.66 138.06,233.88 136.53,232.36 131.83,232.36 129.27,229.79 129.27,220.76 122.98,214.48 101.27,214.48 93.53,206.74 93.53,164.16 96.73,160.96 96.73,159.18 95.11,157.55 95.11,157.17 95.72,156.56 v3(95.99,156.56)
  BOTTOM w0.102: v3(70.67,130.18) 70.47,130.18 70.29,130.35 70.29,130.53 70.39,130.63 71.86,130.63 72.93,131.7 72.93,137.62 74.43,139.12 74.43,144.72 77.43,147.72 77.97,147.72 78.31,148.06 78.31,149.14 78.86,149.69 v2(79.4,149.69) 80.43,150.72 83.24,150.72 84.94,152.43 86.22,152.43 88.35,154.56 89.75,154.56 91.58,156.39 93.3,156.39 93.99,157.07 94.97,157.07 95.12,156.92 95.62,156.92 v3(95.99,156.56)
USB3_TXDN4: length 161.7
  TOP w0.089: U4.A14 68.19,129.08 68.33,129.08 68.42,128.99 68.42,128.64 68.72,128.33 70.13,128.33 70.38,128.58 70.38,128.94 70.47,129.03 v3(70.75,129.03)
  TOP w0.102: v3(94.47,155.7) 94.47,156.15 94.32,156.31 94.32,157.73 95.99,159.41 95.99,160.72 92.84,163.87 92.84,207.02 101.04,215.21 122.75,215.21 128.56,221.02 128.56,230.16 131.52,233.12 135.69,233.12 136.03,233.46 136.03,234.48 CO28.1
  BOTTOM w0.102: v3(94.47,155.7) 94.67,155.9 94.67,156.13 94.55,156.26 94.17,156.26 93.62,155.7 91.87,155.7 90.04,153.87 88.63,153.87 86.5,151.74 85.22,151.74 83.52,150.04 81.3,150.04 v2(77.64,146.39) 77.1,146.39 76.44,145.72 76.44,144.64 76.1,144.3 75.56,144.3 75.12,143.86 75.12,138.81 73.62,137.31 73.62,131.41 71.69,129.49 70.54,129.49 70.44,129.39 70.44,129.24 70.64,129.03 v3(70.75,129.03)
USB3_TXDP1: length 167.6
  TOP w0.089: U4.B11 67.82,130.67 68,130.85 68.87,130.85 69.49,131.48 70.3,131.48 70.31,131.49 70.33,131.49
  TOP w0.102: 70.33,131.49 70.53,131.49 70.7,131.66 70.7,132.67 71.12,133.1 71.89,133.1 75.42,129.56 75.42,125.65 77.38,123.7 77.38,121.87 78.14,121.11 78.14,120.08 78.8,119.42 78.8,116.85 77.2,115.25 77.2,108.58 74,105.38 74,97.56 74.94,96.62 74.94,93.7 76.72,91.92 76.72,86.02 80.83,81.91 80.83,64.75 91.86,53.72 120.3,53.72 145.02,29 145.02,25.73 145.2,25.55 145.2,23.77 v1(145.45,23.52) 145.2,23.27 145.2,22.89 145.31,22.78 CO43.2
