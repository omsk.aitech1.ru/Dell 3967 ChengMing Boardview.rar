# Allegro board Phoenix-A00-Layout-20161019.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_CS_N0: length 66
  TOP w0.089: v1(163.11,134.6) CPU.AP17
  L3_GND w0.089: 161.68,127.41 161.83,127.56 161.83,128.11 162.28,128.56 162.28,130.59 162.67,130.98 162.67,134.17 v1(163.11,134.6)
  L3_GND w0.14: 161.68,127.41 161.08,126.81 161.08,124.92 159.58,123.43 159.58,104.43 153.09,97.94 151.95,97.94 151.71,97.7 151.3,97.7 151.13,97.53 151.13,97.12 150.97,96.96 150.56,96.96 150.39,96.79 150.39,96.38 150.16,96.15 149.17,96.15 148.46,95.44 148.46,91.23 147.63,90.4 147.63,89.85 148.48,89 148.48,87.15 148.99,86.64 148.99,85.96 148.48,85.45 148.48,84.9 148.99,84.4 148.99,83.5 148.29,82.81 148.29,82.25 147.61,81.56 147.61,80.49 147.84,80.26 148.09,80.26 148.29,80.47 148.29,81.12 DIMM2.84
M_B_CS_N1: length 67
  TOP w0.089: v1(161.31,135.52) CPU.AN15
  L3_GND w0.089: v1(161.31,135.52) 160.88,135.09 160.88,134.3 160.64,134.06 160.64,131.83 159.96,131.16 159.96,130.33 158.08,128.45
  L3_GND w0.14: DIMM2.89 144.04,81.85 144.18,81.71 144.56,81.71 144.71,81.86 144.71,83.64 144.23,84.12 144.23,86.05 144.23,86.05 144.23,86.6 145.08,87.45 145.08,89 144.23,89.85 144.23,90.4 145.08,91.25 145.08,92.58 145.74,93.24 145.74,96.07 146.21,96.55 146.21,96.76 146.05,96.93 146.05,97.14 146.2,97.3 146.42,97.3 146.58,97.13 146.8,97.13 157.18,107.52 157.18,124.56 157.93,125.3 157.93,125.52 158.08,125.67 158.48,125.67 158.63,125.82 158.63,126.04 158.48,126.19 158.08,126.19 157.93,126.35 157.93,126.56 158.08,126.72 158.6,126.72 158.76,126.87 158.76,127.09 158.6,127.24 158.08,127.24 157.93,127.39 157.93,128.29 158.08,128.45
M_B_MA0: length 69.8
  TOP w0.089: v1(164.97,137.35) CPU.AL19
  L3_GND w0.089: v1(164.97,137.35) 165.1,137.12 165.39,136.61 165.39,136.25 165.09,135.94 164.82,135.94 164.57,135.69 164.57,135.2 164.4,135.04 164.4,134.26 164.72,133.94 164.72,128.69 164.18,128.15 164.18,126.7
  L3_GND w0.152: DIMM2.79 153.41,83.59 153.41,85.11 154.19,85.89 154.19,87.02 153.75,87.46 153.75,88.82 152.72,89.84 152.72,90.4 154.02,91.7 154.02,92.98 154.15,93.11
  L3_GND w0.178: 154.15,93.11 163.28,102.24 163.28,115.81 163.11,115.98 162.5,115.98 162.34,116.14 162.34,116.37 162.5,116.54 163.11,116.54 163.28,116.7 163.28,116.93 163.11,117.1 162.5,117.1 162.34,117.26 162.34,117.5 162.5,117.66 163.11,117.66 163.28,117.82 163.28,118.06 163.11,118.22 162.5,118.22 162.34,118.39 162.34,118.62 162.5,118.78 163.11,118.78 163.28,118.95 163.28,119.18 163.11,119.34 162.5,119.34 162.34,119.51 162.34,119.74 162.5,119.91 163.11,119.91 163.28,120.07 163.28,120.3 163.11,120.47 162.5,120.47 162.34,120.63 162.34,120.86 162.5,121.03 163.11,121.03 163.28,121.19 163.28,121.96 164.18,122.87 164.18,126.7
M_B_MA1: length 71
  TOP w0.089: CPU.AL22 v1(168.62,137.35)
  L3_GND w0.089: v1(168.62,137.35) 169.11,136.87 169.11,135.08 168.77,134.75 168.77,128.25 168.35,127.83 168.35,127.41
  L3_GND w0.152: DIMM2.72 163.59,80.63 163.81,80.42 164.07,80.42 164.27,80.62 164.27,81.76 163.76,82.27 163.76,83.21 163.23,83.74 162.26,83.74 162.03,83.97 162.03,85.23 161.22,86.04 161.22,86.6 161.74,87.12 161.74,88.8 160.89,89.64 160.89,90.43 161.72,91.26 161.72,92.13 161.98,92.39 161.98,93.11
  L3_GND w0.178: 168.35,127.41 168.35,121.26 167.13,120.04 167.13,113.94 168.63,112.44 168.63,101.64 168.4,101.42 168.4,101.18 168.6,100.98 168.6,100.75 168.44,100.59 168.2,100.59 168,100.79 167.77,100.79 167.6,100.62 167.6,100.39 167.81,100.19 167.81,99.96 167.64,99.79 167.41,99.79 167.21,99.99 166.98,99.99 166.81,99.83 166.81,99.6 167.01,99.39 167.01,99.16 166.85,99 166.62,99 166.41,99.2 166.18,99.2 166.02,99.04 166.02,98.8 166.22,98.6 166.22,98.37 166.05,98.2 165.82,98.2 165.62,98.41 165.39,98.41 165.22,98.24 165.22,98.01 165.42,97.81 165.42,97.57 165.26,97.41 165.03,97.41 164.83,97.61 164.59,97.61 164.43,97.45 164.43,97.21 164.63,97.01 164.63,96.78 164.47,96.62 164.23,96.62 164.03,96.82 163.8,96.82 163.51,96.53 163.51,95.59 161.98,94.07 161.98,93.11
M_B_MA2: length 68.4
  TOP w0.089: v1(168.62,136.43) CPU.AM22
  L3_GND w0.089: v1(168.62,136.43) 168.12,135.93 168.12,135.35 168.56,134.91 168.56,128.41 167.84,127.69 167.84,127.41
  L3_GND w0.152: DIMM2.216 163.59,79.21 162.59,80.21 162.59,81.53 163.46,82.4 163.46,83.08 163.1,83.44 162.13,83.44 161.73,83.85 161.73,85.11 160.92,85.92 160.92,87.1 160.37,87.64 160.37,88.2 159.44,89.14 159.44,90.69 160.29,91.55 160.29,91.93 160.85,92.49 161.19,92.49 161.52,92.82 161.52,93.11
  L3_GND w0.178: 161.52,93.11 161.52,95.16 168.18,101.83 168.18,112.26 166.68,113.76 166.68,120.39 167.87,121.58 167.87,127.32 167.84,127.36 167.84,127.41
M_B_MA3: length 68.2
  TOP w0.089: v1(169.54,135.52) CPU.AM23
  L3_GND w0.089: v1(169.54,135.52) 169.54,135.21 168.99,134.66 168.99,128.94 169.61,128.31 169.61,127.54 169.43,127.36
  L3_GND w0.152: DIMM2.71 164.44,83.37 164.22,83.59 164.22,84.14 162.62,85.75 162.62,87.1 162.07,87.64 162.07,88.2 162.59,88.72 162.59,90.93 162.06,91.45 162.06,92.03 162.43,92.4 162.43,93.11
  L3_GND w0.178: 169.43,127.36 168.81,126.74 168.81,121.09 167.57,119.85 167.57,114.12 169.07,112.63 169.07,112 169.23,111.84 169.95,111.84 170.11,111.67 170.11,111.44 169.95,111.28 169.23,111.28 169.07,111.11 169.07,110.88 169.23,110.72 169.95,110.72 170.11,110.55 170.11,110.32 169.95,110.15 169.23,110.15 169.07,109.99 169.07,109.76 169.23,109.59 169.95,109.59 170.11,109.43 170.11,109.2 169.95,109.03 169.23,109.03 169.07,108.87 169.07,108.64 169.23,108.47 169.95,108.47 170.11,108.31 170.11,108.07 169.95,107.91 169.23,107.91 169.07,107.75 169.07,107.51 169.23,107.35 169.95,107.35 170.11,107.18 170.11,106.95 169.95,106.79 169.23,106.79 169.07,106.62 169.07,100.46 162.43,93.82 162.43,93.11
M_B_MA4: length 66.6
  TOP w0.089: v1(169.56,133.69) CPU.AP23
  L3_GND w0.089: v1(169.56,133.69) 169.56,132.55 169.99,132.12 169.99,131.63 169.6,131.24 169.6,128.78 169.91,128.47 169.91,127.28
  L3_GND w0.152: 163.68,93.11 163.68,92.81 163.44,92.56 163.44,91.22 162.91,90.69 162.91,89.66 163.44,89.13 163.44,87.49 162.92,86.97 162.92,85.88 164.7,84.1 164.7,83.59 165.17,83.12 165.17,81.94 164.62,81.4 164.62,80.84 165.29,80.17 DIMM2.214
  L3_GND w0.178: 169.91,127.28 169.91,127.18 169.27,126.54 169.27,120.92 168.02,119.67 168.02,114.64 170.62,112.03 170.62,106.42 170.46,106.26 169.72,106.26 169.55,106.09 169.55,105.86 169.72,105.7 170.46,105.7 170.62,105.53 170.62,105.3 170.46,105.14 169.72,105.14 169.55,104.97 169.55,100.31 163.68,94.44 163.68,93.11
M_B_MA5: length 69
  TOP w0.089: CPU.AL23 v1(169.54,136.43)
  L3_GND w0.089: v1(169.54,136.43) 170.02,135.95 170.02,132.59 170.21,132.4 170.21,131.36 169.91,131.06 169.91,128.95 170.35,128.5 170.35,127.1
  L3_GND w0.152: 164.47,93.11 164.47,92.99 163.75,92.27 163.75,91.46 164.28,90.94 164.28,89.12 163.76,88.6 163.76,87.29 164.32,86.73 164.32,85.92 165.13,85.11 165.13,83.59 165.47,83.24 165.47,82.27 165.97,81.77 165.97,79.71 166.14,79.53 DIMM2.213
  L3_GND w0.178: 164.47,93.11 164.47,94.6 170.01,100.14 170.01,102.19 170.17,102.35 170.91,102.35 171.08,102.52 171.08,102.75 170.91,102.91 170.17,102.91 170.01,103.08 170.01,103.31 170.17,103.48 170.91,103.48 171.08,103.64 171.08,103.87 170.91,104.04 170.17,104.04 170.01,104.2 170.01,104.43 170.17,104.6 170.91,104.6 171.08,104.76 171.08,112.2 168.46,114.82 168.46,119.48 169.75,120.77 169.75,126.33 170.35,126.93 170.35,127.1
M_B_MA6: length 60.3
  TOP w0.089: v1(171.36,127.27) 171.25,127.41 171.25,129.01 171.81,129.57 CPU.AW26
  L3_GND w0.152: 165.17,93.11 165.17,91.23 164.61,90.68 164.61,89.68 165.17,89.12 165.17,87.15 164.62,86.6 164.62,86.04 165.43,85.23 165.43,84.14 166.14,83.43 DIMM2.69
  L3_GND w0.178: v1(171.36,127.27) 170.21,126.13 170.21,120.61 168.9,119.3 168.9,115 171.52,112.39 171.52,101.87 171.36,101.71 170.96,101.71 170.8,101.54 170.8,101.31 170.96,101.14 171.36,101.14 171.52,100.98 171.52,100.29 170.72,99.49 170.49,99.49 170.38,99.6 170.15,99.6 169.98,99.44 169.98,99.21 170.22,98.97 170.22,98.74 170.05,98.57 169.82,98.57 169.58,98.81 169.35,98.81 169.19,98.64 169.19,98.41 169.41,98.19 169.41,97.95 169.25,97.79 169.01,97.79 168.79,98.01 168.56,98.01 168.39,97.85 168.39,97.62 168.6,97.4 168.6,97.17 168.44,97.01 168.21,97.01 168,97.22 167.76,97.22 167.6,97.06 167.6,96.82 167.77,96.65 167.77,96.42 167.61,96.25 167.38,96.25 167.2,96.43 166.97,96.43 166.8,96.26 166.8,96.03 167.04,95.79 167.04,95.56 166.88,95.39 166.65,95.39 166.41,95.63 166.18,95.63 166.01,95.47 166.01,95.24 166.26,94.98 166.26,94.75 166.1,94.59 165.86,94.59 165.61,94.84 165.38,94.84 165.22,94.67 165.22,94.44 165.33,94.33 165.33,94.1 165.17,93.94 165.17,93.11
M_B_MA7: length 60.2
  TOP w0.089: CPU.AY26 171.82,127.74 172.1,127.47 172.1,126.22 171.84,125.96 171.84,125.42 v1(171.62,125.19)
  L3_GND w0.152: DIMM2.211 167.84,80.59 167.72,80.71 167.72,81.89 167.17,82.44 167.17,85.19 166.32,86.04 166.32,86.6 166.87,87.15 166.87,89.3 166.32,89.84 166.32,90.4 166.87,90.95 166.87,92.58 167.4,93.11
  L3_GND w0.178: v1(171.62,125.19) 171.13,124.69 171.13,120.27 169.79,118.93 169.79,115.37 172.41,112.76 172.41,98.77 171.27,97.63 171.27,97.4 171.56,97.11 171.56,96.88 171.4,96.71 171.17,96.71 170.88,97 170.65,97 170.48,96.84 170.48,96.61 170.77,96.32 170.77,96.09 170.6,95.92 170.37,95.92 170.08,96.21 169.85,96.21 169.69,96.04 169.69,95.81 169.98,95.52 169.98,95.29 169.81,95.13 169.58,95.13 169.29,95.42 169.06,95.42 168.89,95.25 168.89,95.02 169.18,94.73 169.18,94.5 168.91,94.22 168.62,94.22 168.4,94.45 168.12,94.45 167.91,94.25 167.91,93.96 168.14,93.74 168.14,93.45 167.83,93.14 167.43,93.14 167.4,93.11
M_B_MA8: length 63.8
  TOP w0.089: v1(171.36,125.85) 171.79,126.31 171.79,127.44 171.49,127.74 171.49,128.89 171.7,129.11 171.96,129.11 172.16,129.3 172.16,130.68 171.82,131.02 CPU.AU26
  L3_GND w0.152: 166.12,93.11 165.47,92.46 165.47,91.44 166.02,90.9 166.02,88.75 165.47,88.2 165.47,87.64 166.02,87.1 166.02,85.92 166.87,85.07 166.87,82.33 166.3,81.76 166.3,80.47 166.48,80.29 166.81,80.29 166.99,80.47 DIMM2.68
  L3_GND w0.178: 166.12,93.11 166.36,93.35 166.36,93.58 166.17,93.77 166.17,94.01 166.34,94.17 166.57,94.17 166.72,94.02 166.95,94.02 167.12,94.19 167.12,94.42 166.93,94.6 166.93,94.84 167.1,95 167.33,95 167.56,94.77 167.79,94.77 168.93,95.92 168.93,96.15 168.75,96.32 168.75,96.56 168.92,96.72 169.15,96.72 169.33,96.54 169.56,96.54 169.72,96.71 169.72,96.94 169.55,97.12 169.55,97.35 169.71,97.52 169.94,97.52 170.12,97.34 170.35,97.34 170.52,97.5 170.52,97.74 170.34,97.91 170.34,98.15 170.5,98.31 170.74,98.31 170.91,98.13 171.15,98.13 171.31,98.3 171.31,98.53 171.13,98.71 171.13,98.94 171.3,99.1 171.53,99.1 171.71,98.93 171.84,98.93 171.97,99.05 171.97,112.57 169.35,115.19 169.35,119.12 170.67,120.44 170.67,125.17 v1(171.36,125.85)
M_B_MA9: length 59.5
  TOP w0.089: CPU.AW27 172.74,129.19 172.4,128.85 172.4,128.27 172.31,128.18 172.31,127.86 172.7,127.48 172.7,125.93 172.48,125.72 172.48,123.43 171.86,122.81 171.86,121.23 v1(172.14,120.95)
  L3_GND w0.152: DIMM2.66 169.01,81.12 169.32,81.43 169.32,81.81 168.87,82.27 168.87,85.19 168.02,86.04 168.02,86.6 168.57,87.15 168.57,89.3 168.02,89.84 168.02,90.4 168.57,90.95 168.57,92.33 169.35,93.11
  L3_GND w0.178: 169.35,93.11 172.73,96.49 172.73,97.5 173.64,98.42 173.64,98.94 173.34,99.24 173.34,99.5 173.64,99.81 173.64,100.06 173.34,100.37 173.34,100.62 173.64,100.93 173.64,101.19 173.34,101.49 173.34,101.75 173.64,102.05 173.64,102.31 173.34,102.61 173.34,102.87 173.64,103.17 173.64,103.43 173.34,103.74 173.34,103.99 173.64,104.3 173.64,104.55 173.34,104.86 173.34,105.11 173.64,105.42 173.64,105.68 173.34,105.98 173.34,106.24 173.64,106.54 173.64,109.17 173.81,109.33 174.16,109.33 174.33,109.49 174.33,109.73 174.16,109.89 173.81,109.89 173.64,110.06 173.64,110.29 173.81,110.45 174.16,110.45 174.33,110.62 174.33,110.85 174.16,111.01 173.81,111.01 173.64,111.18 173.64,111.41 173.81,111.58 174.16,111.58 174.33,111.74 174.33,111.97 174.16,112.14 173.81,112.14 173.64,112.3 173.64,112.78 170.8,115.63 170.8,118.64 172.14,119.99 v1(172.14,120.95)
M_B_MA10: length 68.1
  TOP w0.089: CPU.AP18 v1(164.04,133.69)
  L3_GND w0.089: 163.2,126.11 163.2,126.79 163.64,127.24 163.64,128.44 164.11,128.9 164.11,131.22 163.65,131.67 163.65,132.91 164.04,133.3 v1(164.04,133.69)
  L3_GND w0.152: 152.5,93.11 151.87,92.48 151.87,91.25 151.02,90.4 151.02,89.84 151.87,88.99 151.87,87.64 152.37,87.15 152.37,83.92 151.52,83.07 151.52,81.89 150.84,81.22 DIMM2.225
  L3_GND w0.178: 163.2,126.11 163.2,123.4 161.44,121.64 161.44,114.61 161.6,114.44 162.23,114.44 162.39,114.28 162.39,114.05 162.23,113.88 161.6,113.88 161.44,113.72 161.44,113.49 161.6,113.32 162.23,113.32 162.39,113.16 162.39,112.92 162.23,112.76 161.6,112.76 161.44,112.6 161.44,112.36 161.6,112.2 162.23,112.2 162.39,112.03 162.39,111.8 162.23,111.64 161.6,111.64 161.44,111.47 161.44,111.24 161.6,111.08 162.23,111.08 162.39,110.91 162.39,103 152.5,93.11
M_B_MA11: length 62.7
  TOP w0.089: v1(172.06,123.62) 172.06,124.27 172.25,124.46 172.25,125.98 172.42,126.14 172.42,127.45 172.07,127.8 172.07,128.31 172.16,128.4 172.16,128.97 172.4,129.21 172.4,130.68 172.74,131.02 CPU.AU27
  L3_GND w0.152: 168.47,93.11 167.96,92.61 167.48,92.61 167.17,92.3 167.17,91.44 167.72,90.9 167.72,88.75 167.17,88.2 167.17,87.28 167.72,86.73 167.72,83.83 168.09,83.46 168.29,83.46 168.52,83.23 168.52,82.44 168.02,81.94 168.02,80.84 168.69,80.17 168.69,78.77 168,78.08 168,77.67 168.36,77.32 DIMM2.210
  L3_GND w0.178: v1(172.06,123.62) 171.6,123.16 171.6,120.11 170.24,118.75 170.24,115.56 172.85,112.94 172.85,112.41 173.13,112.13 173.13,111.84 172.85,111.57 172.85,111.28 173.13,111 173.13,110.72 172.85,110.44 172.85,110.16 173.13,109.88 173.13,109.6 172.85,109.32 172.85,109.04 173.13,108.76 173.13,108.48 172.85,108.2 172.85,107.81 173.16,107.51 173.16,107.25 172.85,106.95 172.85,98.26 172.19,97.6 172.19,96.84 168.47,93.11
M_B_MA12: length 64.2
  TOP w0.089: CPU.AV27 173.08,130.15 173.08,128.3 173.18,128.2 173.18,127.82 173.04,127.68 173.04,125.81 172.74,125.51 172.74,123.35 172.27,122.88 v1(172.27,121.84)
  L3_GND w0.152: 169.98,93.11 168.87,92 168.87,91.44 169.37,90.95 169.37,88.7 168.87,88.2 168.87,87.64 169.54,86.97 DIMM2.65
  L3_GND w0.178: 169.98,93.11 173.17,96.3 173.17,97.32 174.79,98.93 174.79,99.93 174.62,100.09 174.24,100.09 174.07,100.26 174.07,100.49 174.24,100.66 174.62,100.66 174.79,100.82 174.79,101.05 174.62,101.22 174.24,101.22 174.07,101.38 174.07,101.61 174.24,101.78 174.62,101.78 174.79,101.94 174.79,102.18 174.62,102.34 174.24,102.34 174.07,102.5 174.07,102.74 174.24,102.9 174.62,102.9 174.79,103.07 174.79,103.3 174.62,103.46 174.24,103.46 174.07,103.63 174.07,103.86 174.24,104.02 174.62,104.02 174.79,104.19 174.79,104.42 174.62,104.59 174.24,104.59 174.07,104.75 174.07,104.98 174.24,105.15 174.62,105.15 174.79,105.31 174.79,105.54 174.62,105.71 174.24,105.71 174.07,105.87 174.07,106.1 174.24,106.27 174.62,106.27 174.79,106.43 174.79,106.67 174.62,106.83 174.26,106.83 174.1,106.99 174.1,107.23 174.26,107.39 174.62,107.39 174.79,107.56 174.79,107.79 174.62,107.95 174.26,107.95 174.1,108.12 174.1,108.35 174.26,108.51 174.62,108.51 174.79,108.68 174.79,112.27 173.09,113.96 173.09,114.19 173.43,114.53 173.43,114.77 173.27,114.93 173.03,114.93 172.69,114.59 172.46,114.59 172.16,114.89 172.16,115.13 172.45,115.42 172.45,115.65 172.28,115.81 172.05,115.81 171.76,115.52 171.53,115.52 171.25,115.8 171.25,118.39 172.69,119.82 172.69,121.09 172.27,121.51 v1(172.27,121.84)
M_B_MA13: length 65.3
  TOP w0.089: v1(161.31,133.69) CPU.AR15
  L3_GND w0.089: 160.48,128.45 160.73,128.69 160.73,128.8 161.06,129.13 161.06,130.44 161.7,131.09 161.7,132.92 161.6,133.11 161.47,133.36 v1(161.31,133.69)
  L3_GND w0.152: DIMM2.232 144.89,80.17 145.57,80.84 145.57,81.94 145.07,82.44 145.07,83 145.64,83.56 145.64,86.77 146.42,87.55 146.42,88.88 145.59,89.71 145.59,90.54 146.44,91.39 146.44,92.23 146.26,92.42 146.26,93.11
  L3_GND w0.178: 146.26,93.11 146.26,95.86 157.7,107.3 157.7,124.12 159.28,125.69 159.28,127.24 160.48,128.45
M_B_MA14: length 69.7
  TOP w0.089: CPU.AL17 v1(163.14,137.35)
  L3_GND w0.089: v1(163.14,137.35) 163.57,136.92 163.57,136.24 163.54,136.21 163.54,134.42 163.13,134.02 163.13,133.37 162.93,133.17 162.93,130.87 162.54,130.48 162.54,128.36 162.2,128.01 162.2,127.19 162.05,127.04
  L3_GND w0.152: DIMM2.228 148.78,77.32 149.82,78.36 149.82,80.34 149.32,80.84 149.32,81.4 149.84,81.92 149.84,84.44 149.67,84.62 149.67,85.52 149.32,85.87 149.32,86.6 149.87,87.15 149.87,88.87 149.02,89.72 149.02,90.55 149.84,91.37 149.84,93.11
  L3_GND w0.178: 162.05,127.04 161.61,126.6 161.61,124.48 160.1,122.97 160.1,104.22 153.31,97.42 152.16,97.42 149.84,95.1 149.84,93.11
M_B_MA15: length 66.2
  TOP w0.089: CPU.AP16 v1(162.22,133.69)
  L3_GND w0.089: 161.3,127.79 161.51,128 161.51,128.22 161.71,128.42 161.71,130.37 162.22,130.89 v1(162.22,133.69)
  L3_GND w0.152: 147.92,93.11 147.92,93.01 148.12,92.81 148.12,91.42 147.29,90.59 147.29,89.71 148.14,88.86 148.14,87.12 147.6,86.58 147.6,83.83 146.59,82.82 146.59,82.42 147.27,81.75 147.27,80.47 147.12,80.31 146.75,80.31 146.59,80.47 DIMM2.86
  L3_GND w0.178: 147.92,93.11 147.92,95.66 149.2,96.94 149.6,96.94 149.8,97.13 149.8,97.54 149.99,97.73 150.4,97.73 150.59,97.93 150.59,98.33 150.78,98.53 152.94,98.53 159.06,104.65 159.06,116.76 158.76,117.06 158.76,117.32 159.06,117.63 159.06,117.88 158.76,118.19 158.76,118.44 159.06,118.75 159.06,119.01 158.76,119.31 158.76,119.57 159.06,119.87 159.06,120.13 158.76,120.43 158.76,120.69 159.06,120.99 159.06,121.25 158.76,121.56 158.76,121.81 159.06,122.12 159.06,122.37 158.76,122.68 158.76,122.93 159.06,123.24 159.06,123.78 160.41,125.13 160.41,126.9 161.3,127.79
M_B_MA16: length 67.8
  TOP w0.089: v1(164.05,136.43) 164.05,135.52 CPU.AN18
  L3_GND w0.089: 162.4,126.68 162.56,126.84 162.56,127.15 163.11,127.69 163.11,128.51 163.68,129.08 163.68,131 163.17,131.51 163.17,133.1 163.37,133.31 163.37,133.94 163.75,134.32 163.75,135.85 163.76,135.86 v1(164.05,136.43)
  L3_GND w0.152: 150.52,93.11 150.52,92.5 150.17,92.15 150.17,91.25 149.32,90.4 149.32,89.84 150.17,88.99 150.17,87.64 150.29,87.53 150.67,87.15 150.67,85.69 150.9,85.46 150.9,84.62 150.17,83.89 150.17,82.19 150.48,81.89 150.48,81.6 DIMM2.82
  L3_GND w0.178: 162.4,126.68 162.12,126.4 162.12,124.13 160.55,122.56 160.55,105.25 160.71,105.08 161.11,105.08 161.27,104.92 161.27,104.69 161.18,104.59 161.11,104.52 160.71,104.52 160.55,104.36 160.55,102.41 155.63,97.5 155.4,97.5 155.14,97.75 154.91,97.75 154.74,97.59 154.74,97.36 155,97.1 155,96.87 154.07,95.94 152.16,95.94 150.52,94.29 150.52,93.11
M_B_ODT0: length 68.5
  TOP w0.089: CPU.AM16 v1(162.22,136.43)
  L3_GND w0.089: v1(162.22,136.43) 162.22,136.12 161.79,135.69 161.79,133.49 161.96,133.32 161.96,130.98 161.37,130.39 161.37,129.06 161.19,128.88 161.19,128.41 160.93,128.16
  L3_GND w0.14: 160.93,128.16 159.85,127.08 159.85,125.49 158.22,123.86 158.22,105.41 156.38,103.57 156.38,103.35 156.6,103.14 156.6,102.92 156.44,102.77 156.23,102.77 156.01,102.98 155.8,102.98 155.64,102.83 155.64,102.61 155.86,102.4 155.86,102.18 155.7,102.03 155.49,102.03 155.27,102.24 155.06,102.24 154.9,102.09 154.9,101.87 155.12,101.66 155.12,101.44 154.96,101.29 154.75,101.29 154.53,101.5 154.32,101.5 154.16,101.35 154.16,101.13 154.38,100.92 154.38,100.7 154.22,100.55 154.01,100.55 153.79,100.76 153.58,100.76 153.42,100.61 153.42,100.39 153.64,100.18 153.64,99.96 153.48,99.81 153.27,99.81 153.05,100.02 152.84,100.02 152.68,99.87 152.68,99.65 152.9,99.44 152.9,99.22 152.74,99.07 152.53,99.07 152.31,99.28 152.09,99.28 151.86,99.05 150.49,99.05 147.58,96.14 147.38,96.14 146.78,95.54 146.78,91.25 145.93,90.4 145.93,89.85 146.78,89 146.78,87.5 146.77,87.49 146.77,87.09 147.26,86.6 147.26,84.23 DIMM2.87
M_B_ODT1: length 69.1
  TOP w0.089: CPU.AL16 v1(162.22,137.35)
  L3_GND w0.089: 157.36,128.45 157.36,128.48 159.56,130.68 159.56,131.11 160.39,131.94 160.39,134.21 160.54,134.37 160.54,135.49 161.02,135.97 161.44,135.97 161.77,136.29 161.77,136.89 v1(162.22,137.35)
  L3_GND w0.14: DIMM2.91 142.34,82.09 142.55,81.89 143.01,81.89 143.22,82.1 143.22,83.59 143.86,84.23 143.86,86.75 144.71,87.6 144.71,88.85 143.86,89.7 143.86,90.55 144.71,91.4 144.71,93.64 144.86,93.79 145.07,93.79 145.22,93.94 145.22,94.16 145.07,94.31 144.86,94.31 144.71,94.47 144.71,94.68 144.86,94.84 145.07,94.84 145.22,94.99 145.22,95.21 145.07,95.36 144.86,95.36 144.71,95.51 144.71,95.73 144.86,95.88 145.07,95.88 145.22,96.04 145.22,96.25 145.07,96.41 144.86,96.41 144.71,96.56 144.71,97.08 145.45,97.82 146.78,97.82 156.69,107.72 156.69,124.82 157.36,125.49 157.36,128.45
M_B_PAR: length 67.6
  TOP w0.089: CPU.AL20 v1(165.88,137.35)
  L3_GND w0.089: 164.98,127.18 164.98,127.21 165.3,127.52 165.3,130.95 164.98,131.27 164.98,134.01 164.62,134.38 164.62,134.83 164.88,135.09 165.17,135.09 165.42,135.34 165.42,135.66 165.69,135.93 166.23,135.93 166.36,136.07 166.36,136.87 v1(165.88,137.35)
  L3_GND w0.152: DIMM2.222 153.39,79.57 154.17,80.35 154.17,81.31 154.49,81.63 154.49,87.33 154.17,87.65 154.17,90.26 155.29,91.38 155.29,93.11
  L3_GND w0.178: 155.29,93.11 155.29,93.63 163.72,102.06 163.72,121.62 164.98,122.88 164.98,127.18
M_B_VREF: length 6.4
  TOP w0.254: R62.2 220.49,75.88 C72.1 220.77,75.88 C68.1 C69.1 R63.1 223.81,76.6 DIMM2.146
M_CA_VREF: length 101.5
  TOP w0.254: RD9.2 226.92,83.95 227.88,83.95 CD6.1 228.02,83.52 228.48,83.06 v1(229.65,83.06) 229.78,83.06 230.28,83.56 230.28,85.22 229.79,85.71 228.72,85.71 225.74,88.7 225.74,92.16 223.52,94.38 223.52,103.64 226.73,106.85 226.73,116.43 220.91,122.25 220.91,124.7 211.27,134.33 211.27,136.7 199.9,148.07 187.58,148.07 CPU.AB40
M_CA_VREF_RC: length 1.6
  TOP w0.254: v1(229.65,84.98) RD10.1 CD6.2
M_DA0: length 92.9
  TOP w0.089: CPU.AE38 183.19,142.38 183.52,142.04 183.9,142.04 184.22,142.36 184.22,142.5 184.44,142.71 184.86,142.71 184.95,142.62 185.79,142.62 188.96,145.78 189.29,145.78
  TOP w0.165: DIMM1.148 222,86.32 223.17,87.5 223.17,88.33 222.16,89.35 222.16,90.58 221.24,91.49 221.24,92.38 219.97,93.65 219.97,96.06 220.17,96.26 220.84,96.26 221.04,96.46 221.04,96.74 220.84,96.94 220.32,96.94 220.13,97.13 220.13,97.41 220.32,97.61 221.04,97.61 221.24,97.81 221.24,98.09 221.04,98.29 220.5,98.29 220.3,98.48 220.3,98.76 220.5,98.96 221.04,98.96 221.24,99.16 221.24,112.19 208.33,125.11 208.33,136.38 198.92,145.79 195.96,145.79 195.96,145.78 189.29,145.78
M_DA1: length 93.9
  TOP w0.089: 189.29,144.51 188.66,144.51 186.28,142.13 184.94,142.13 184.84,142.04 184.2,142.04 183.98,141.82 183.4,141.82 183.22,142 182.26,142 CPU.AE37
  TOP w0.165: DIMM1.150 220.34,86.32 221.33,87.31 221.33,88.45 220.56,89.22 220.56,90.35 219.69,91.22 219.69,91.87 218.7,92.86 218.7,109.5 218.9,109.7 219.65,109.7 219.84,109.9 219.84,110.18 219.65,110.37 218.9,110.37 218.7,110.57 218.7,110.85 218.9,111.05 219.65,111.05 219.84,111.25 219.84,111.53 219.65,111.72 218.9,111.72 218.7,111.92 218.7,112.19 218.06,112.84 218.06,113.4 217.86,113.59 217.3,113.59 217.1,113.79 217.1,114.35 216.9,114.55 216.34,114.55 216.15,114.75 216.15,115.31 215.95,115.51 215.39,115.51 215.19,115.7 215.19,116.26 214.99,116.46 214.43,116.46 214.23,116.66 214.23,117.22 214.04,117.42 213.48,117.42 213.28,117.61 213.28,118.17 213.08,118.37 212.52,118.37 212.32,118.57 212.32,119.13 212.12,119.33 211.57,119.33 211.37,119.53 211.37,120.08 211.17,120.28 210.61,120.28 210.41,120.48 210.41,121.04 210.21,121.24 209.65,121.24 209.46,121.44 209.46,122 209.26,122.19 208.7,122.19 208.5,122.39 208.5,122.95 208.3,123.15 207.74,123.15 207.06,123.84 207.06,135.86 198.4,144.51 189.29,144.51
M_DA2: length 92
  TOP w0.089: CPU.AG38 183.54,140.21 184.78,140.21 184.86,140.23 184.87,140.23 185.15,140.31 187.04,140.31 188.57,141.84 189.29,141.84
  TOP w0.165: 189.29,141.84 197.07,141.84 203.98,134.92 203.98,122.11 213.98,112.11 213.98,111.41 214.18,111.21 214.77,111.21 214.97,111.01 214.97,110.73 214.77,110.54 214.18,110.54 213.98,110.34 213.98,110.06 214.18,109.86 214.77,109.86 214.97,109.66 214.97,109.38 214.77,109.18 214.18,109.18 213.98,108.99 213.98,108.71 214.18,108.51 214.77,108.51 214.97,108.31 214.97,108.03 214.77,107.83 214.18,107.83 213.98,107.64 213.98,107.36 214.18,107.16 214.77,107.16 214.97,106.96 214.97,106.68 214.77,106.48 214.18,106.48 213.98,106.28 213.98,106 214.18,105.81 214.77,105.81 214.97,105.61 214.97,105.33 214.77,105.13 214.18,105.13 213.98,104.93 213.98,104.65 214.18,104.46 214.77,104.46 214.97,104.26 214.97,103.98 214.77,103.78 214.18,103.78 213.98,103.58 213.98,103.3 214.18,103.1 214.77,103.1 214.97,102.91 214.97,102.63 214.77,102.43 214.18,102.43 213.98,102.23 213.98,101.95 214.18,101.75 214.77,101.75 214.97,101.56 214.97,101.28 214.77,101.08 214.18,101.08 213.98,100.88 213.98,100.6 214.18,100.4 214.77,100.4 214.97,100.2 214.97,99.92 214.77,99.73 214.18,99.73 213.98,99.53 213.98,99.25 214.18,99.05 214.77,99.05 214.97,98.85 214.97,98.57 214.77,98.37 214.18,98.37 213.98,98.18 213.98,97.9 214.18,97.7 214.77,97.7 214.97,97.5 214.97,97.22 214.77,97.02 214.18,97.02 213.98,96.83 213.98,96.55 214.18,96.35 214.69,96.35 214.89,96.15 214.89,95.87 214.69,95.67 214.18,95.67 213.98,95.47 213.98,92.56 214.59,91.94 DIMM1.12
M_DA3: length 93
  TOP w0.089: 189.29,141.2 188.43,141.2 187.19,139.96 185.58,139.96 185.48,140.06 185.2,140.06 184.99,139.97 183.09,139.97 CPU.AG37
  TOP w0.165: DIMM1.157 213.74,90.74 213.05,91.44 213.05,91.93 212.5,92.48 212.5,93.5 212.7,93.7 213.07,93.7 213.27,93.89 213.27,94.17 213.07,94.37 212.07,94.37 211.87,94.57 211.87,94.85 212.07,95.05 213.07,95.05 213.27,95.24 213.27,95.52 213.07,95.72 212.7,95.72 212.5,95.92 212.5,96.49 212.7,96.68 213.12,96.68 213.32,96.88 213.32,97.16 213.12,97.36 212.7,97.36 212.5,97.56 212.5,97.84 212.7,98.04 213.12,98.04 213.32,98.23 213.32,98.51 213.12,98.71 212.7,98.71 212.5,98.91 212.5,99.19 212.7,99.39 213.12,99.39 213.32,99.58 213.32,99.86 213.12,100.06 212.7,100.06 212.5,100.26 212.5,100.54 212.7,100.74 213.12,100.74 213.32,100.94 213.32,101.22 213.12,101.41 212.7,101.41 212.5,101.61 212.5,101.89 212.7,102.09 213.12,102.09 213.32,102.29 213.32,102.57 213.12,102.76 212.7,102.76 212.5,102.96 212.5,103.24 212.7,103.44 213.12,103.44 213.32,103.64 213.32,103.92 213.12,104.12 212.7,104.12 212.5,104.31 212.5,104.59 212.7,104.79 213.12,104.79 213.32,104.99 213.32,105.27 213.12,105.47 212.7,105.47 212.5,105.67 212.5,105.94 212.7,106.14 213.12,106.14 213.32,106.34 213.32,106.62 213.12,106.82 212.7,106.82 212.5,107.02 212.5,107.3 212.7,107.49 213.14,107.49 213.34,107.69 213.34,107.97 213.14,108.17 212.7,108.17 212.5,108.37 212.5,108.65 212.7,108.85 213.14,108.85 213.34,109.04 213.34,109.32 213.14,109.52 212.7,109.52 212.5,109.72 212.5,110 212.7,110.2 213.14,110.2 213.34,110.39 213.34,110.67 213.14,110.87 212.7,110.87 212.5,111.07 212.5,111.35 212.7,111.55 212.94,111.55 213.14,111.75 213.14,112.03 212.94,112.22 212.7,112.22 212.5,112.42 212.5,112.69 203.35,121.84 203.35,134.64 196.79,141.2 189.29,141.2
M_DA4: length 91.6
  TOP w0.089: 189.29,146.42 189.04,146.42 185.48,142.87 185.12,142.87 185.04,142.94 184.12,142.94 183.71,142.53 CPU.AE39
  TOP w0.165: 189.29,146.42 195.7,146.42 199.19,146.42 208.96,136.65 208.96,125.37 223.28,111.05 223.28,110.57 223.08,110.38 222.1,110.38 221.9,110.18 221.9,109.9 222.1,109.7 223.08,109.7 223.28,109.5 223.28,109.22 223.08,109.03 222.1,109.03 221.9,108.83 221.9,108.55 222.1,108.35 223.08,108.35 223.28,108.15 223.28,107.87 223.08,107.67 222.1,107.67 221.9,107.48 221.9,107.2 222.1,107 222.82,107 223.02,106.8 223.02,106.42 221.88,105.28 221.88,96.02 221.5,95.64 221.21,95.64 221.01,95.44 221.01,95.16 221.21,94.96 221.55,94.96 221.75,94.76 221.75,94.48 221.55,94.29 221.21,94.29 221.01,94.09 221.01,93.81 221.21,93.61 221.95,93.61 222.24,93.32 DIMM1.3
M_DA5: length 90.3
  TOP w0.089: 189.29,145.15 188.81,145.15 186.03,142.38 CPU.AE40
  TOP w0.165: DIMM1.5 220.54,92.06 219.34,93.27 219.34,99.37 219.53,99.56 220.28,99.56 220.48,99.76 220.48,100.04 220.28,100.24 219.53,100.24 219.34,100.44 219.34,100.72 219.53,100.91 220.28,100.91 220.48,101.11 220.48,101.39 220.28,101.59 219.53,101.59 219.34,101.79 219.34,102.07 219.53,102.27 220.28,102.27 220.48,102.46 220.48,102.74 220.28,102.94 219.53,102.94 219.34,103.14 219.34,103.42 219.53,103.62 220.28,103.62 220.48,103.82 220.48,104.1 220.28,104.29 219.53,104.29 219.34,104.49 219.34,104.77 219.53,104.97 220.28,104.97 220.48,105.17 220.48,105.45 220.28,105.64 219.53,105.64 219.34,105.84 219.34,106.12 219.53,106.32 220.28,106.32 220.48,106.52 220.48,106.8 220.28,107 219.53,107 219.34,107.19 219.34,107.47 219.53,107.67 220.28,107.67 220.48,107.87 220.48,111.99 219.81,112.66 219.27,112.66 219.07,112.87 219.07,113.13 219.07,113.41 207.69,124.78 207.69,136.12 198.66,145.15 189.29,145.15
M_DA6: length 90.7
  TOP w0.089: CPU.AG39 184.1,140.55 184.44,140.88 184.9,140.88 185,140.79 186.54,140.79 188.85,143.11 189.29,143.11
  TOP w0.165: DIMM1.10 216.29,90.89 216.45,91.04 216.45,92.24 217.05,92.84 217.05,107.74 216.83,107.96 216.44,107.96 216.24,108.16 216.24,108.44 216.44,108.64 216.83,108.64 217.03,108.84 217.03,109.12 216.83,109.32 216.44,109.32 216.24,109.51 216.24,109.79 216.44,109.99 216.83,109.99 217.03,110.19 217.03,110.86 215.23,112.65 215.23,112.93 215.44,113.14 215.44,113.42 215.24,113.62 214.96,113.62 214.75,113.41 214.47,113.41 214.28,113.61 214.28,113.89 214.48,114.1 214.48,114.38 214.29,114.58 214.01,114.58 213.8,114.37 213.52,114.37 213.32,114.56 213.32,114.84 213.53,115.05 213.53,115.33 213.33,115.53 213.05,115.53 212.84,115.32 212.56,115.32 212.36,115.52 212.36,115.8 212.57,116.01 212.57,116.29 212.38,116.49 212.1,116.49 211.89,116.28 211.61,116.28 211.41,116.48 211.41,116.76 211.62,116.96 211.62,117.24 211.42,117.44 211.14,117.44 210.93,117.23 210.65,117.23 210.45,117.43 210.45,117.71 210.66,117.92 210.66,118.2 210.46,118.4 210.18,118.4 209.98,118.19 209.7,118.19 209.5,118.39 209.5,118.67 209.71,118.88 209.71,119.15 209.51,119.35 209.23,119.35 209.02,119.14 208.74,119.14 208.54,119.34 208.54,119.62 208.75,119.83 208.75,120.11 208.55,120.31 208.27,120.31 208.06,120.1 207.78,120.1 207.59,120.3 207.59,120.58 207.8,120.79 207.8,121.07 207.6,121.26 207.32,121.26 207.11,121.06 206.83,121.06 206.63,121.25 206.63,121.53 206.84,121.74 206.84,122.02 206.64,122.22 206.36,122.22 206.15,122.01 205.87,122.01 205.25,122.63 205.25,123.26 205.65,123.66 205.65,123.94 205.25,124.33 205.25,124.61 205.65,125.01 205.65,125.29 205.25,125.68 205.25,125.96 205.65,126.36 205.65,126.64 205.25,127.03 205.25,127.32 205.65,127.71 205.65,127.99 205.25,128.39 205.25,128.67 205.65,129.06 205.65,129.34 205.25,129.74 205.25,130.02 205.65,130.41 205.65,130.69 205.25,131.09 205.25,131.37 205.65,131.76 205.65,132.05 205.25,132.44 205.25,132.72 205.65,133.12 205.65,133.4 205.25,133.79 205.25,134.07 205.65,134.47 205.65,134.75 205.25,135.14 205.25,135.45 197.6,143.11 189.29,143.11
M_DA7: length 89.6
  TOP w0.089: 189.29,142.47 188.7,142.47 186.78,140.55 CPU.AG40
  TOP w0.165: DIMM1.155 215.44,90.74 216.14,91.44 216.14,93.36 215.99,93.51 215.19,93.51 214.99,93.7 214.99,93.98 215.19,94.18 216.19,94.18 216.39,94.38 216.39,94.66 216.19,94.86 215.47,94.86 215.27,95.06 215.27,95.34 215.47,95.53 216.19,95.53 216.39,95.73 216.39,96.01 216.19,96.21 215.78,96.21 215.58,96.41 215.58,96.69 215.78,96.88 216.19,96.88 216.39,97.08 216.39,97.36 216.19,97.56 215.78,97.56 215.58,97.76 215.58,98.04 215.78,98.24 216.19,98.24 216.39,98.43 216.39,98.71 216.19,98.91 215.78,98.91 215.58,99.11 215.58,99.39 215.78,99.59 216.19,99.59 216.39,99.79 216.39,100.07 216.19,100.26 215.78,100.26 215.58,100.46 215.58,100.74 215.78,100.94 216.19,100.94 216.39,101.14 216.39,101.42 216.19,101.61 215.78,101.61 215.58,101.81 215.58,102.09 215.78,102.29 216.19,102.29 216.39,102.49 216.39,102.77 216.19,102.97 215.78,102.97 215.58,103.16 215.58,103.44 215.78,103.64 216.19,103.64 216.39,103.84 216.39,104.12 216.19,104.32 215.78,104.32 215.58,104.51 215.58,104.79 215.78,104.99 216.19,104.99 216.39,105.19 216.39,105.47 216.19,105.67 215.78,105.67 215.58,105.87 215.58,106.15 215.78,106.34 216.19,106.34 216.39,106.54 216.39,106.82 216.19,107.02 215.78,107.02 215.6,107.19 215.6,111.38 204.62,122.37 204.62,135.19 197.33,142.47 189.29,142.47
M_DA8: length 81.7
  TOP w0.089: 189.29,140.57 188.62,140.57 187.46,139.4 186.39,139.4 186.19,139.21 185.12,139.21 185.04,139.28 184.12,139.28 183.71,138.88 CPU.AJ39
  TOP w0.165: 189.29,140.57 196.53,140.57 202.71,134.38 202.71,121.58 211.84,112.45 211.84,112.14 211.65,111.94 211.41,111.94 211.21,111.74 211.21,111.46 211.41,111.27 211.65,111.27 211.84,111.07 211.84,110.79 211.65,110.59 211.41,110.59 211.21,110.39 211.21,110.11 211.41,109.91 211.65,109.91 211.84,109.72 211.84,109.44 211.65,109.24 211.41,109.24 211.21,109.04 211.21,108.76 211.41,108.56 211.65,108.56 211.84,108.36 211.84,108.08 211.65,107.89 211.41,107.89 211.21,107.69 211.21,107.41 211.41,107.21 211.65,107.21 211.84,107.01 211.84,106.73 211.65,106.54 211.41,106.54 211.21,106.34 211.21,106.06 211.41,105.86 211.65,105.86 211.84,105.66 211.84,105.38 211.65,105.18 211.41,105.18 211.21,104.99 211.21,104.71 211.41,104.51 211.65,104.51 211.84,104.31 211.84,104.03 211.65,103.83 211.41,103.83 211.21,103.64 211.21,103.36 211.41,103.16 211.65,103.16 211.84,102.96 211.84,102.68 211.65,102.48 211.41,102.48 211.21,102.28 211.21,102 211.41,101.81 211.65,101.81 211.84,101.61 211.84,101.33 211.65,101.13 211.41,101.13 211.21,100.93 211.21,100.65 211.41,100.45 211.65,100.45 211.84,100.26 211.84,99.98 211.65,99.78 211.41,99.78 211.21,99.58 211.21,99.3 211.41,99.1 211.65,99.1 211.84,98.91 211.84,98.63 211.65,98.43 211.41,98.43 211.21,98.23 211.21,97.95 211.41,97.75 211.65,97.75 211.84,97.55 211.84,97.27 211.65,97.08 211.41,97.08 211.21,96.88 211.21,96.6 211.41,96.4 211.65,96.4 211.84,96.2 211.84,95.92 211.65,95.73 211.41,95.73 211.21,95.53 211.21,92.41 211.36,92.25 211.36,91.44 211.89,90.92 212.52,90.92 212.89,90.54 DIMM1.14
M_DA9: length 84.2
  TOP w0.089: CPU.AJ37 182.3,138.3 182.83,138.3 182.97,138.16 184.05,138.16 184.27,138.38 184.84,138.38 184.93,138.47 188.09,138.47 188.28,138.66 189.29,138.66
  TOP w0.165: 189.29,138.66 195.59,138.66 200.81,133.44 200.81,120.79 201.16,120.43 201.16,119.27 201.45,118.99 201.45,118.71 201.19,118.45 201.19,118.17 201.39,117.97 201.67,117.97 201.93,118.23 202.21,118.23 202.41,118.03 202.41,117.75 201.17,116.52 201.17,116.24 201.37,116.04 201.65,116.04 202.88,117.27 203.16,117.27 203.36,117.08 203.36,116.8 202.51,115.94 202.51,115.66 202.7,115.46 202.98,115.46 203.84,116.32 204.12,116.32 208.55,111.88 208.55,106.43 208.36,106.23 207.98,106.23 207.78,106.03 207.78,105.75 207.98,105.55 208.36,105.55 208.55,105.35 208.55,105.07 208.36,104.88 207.85,104.88 207.65,104.68 207.65,104.4 207.85,104.2 208.36,104.2 208.55,104 208.55,103.72 208.36,103.52 207.85,103.52 207.65,103.33 207.65,103.05 207.85,102.85 208.36,102.85 208.55,102.65 208.55,102.37 208.36,102.17 207.85,102.17 207.65,101.98 207.65,101.74 208.01,101.38 208.01,101.06 207.65,100.71 207.65,98 208.55,97.1 208.55,92.79 209.34,92.01 209.34,91.44 209.28,91.38 208.8,90.9 208.8,89.84 209.63,89.01 209.63,88.63 DIMM1.161
M_DA10: length 82.2
  TOP w0.089: 189.29,135.98 188.11,135.98 187.44,136.65 185.11,136.65 184.86,136.57 184.78,136.55 183.54,136.55 CPU.AL38
  TOP w0.165: DIMM1.23 205.24,96.59 194.39,107.44 194.39,108.13 194.2,108.33 193.65,108.33 193.45,108.53 193.45,108.8 193.65,109 194.2,109 194.39,109.2 194.39,109.48 194.2,109.68 193.65,109.68 193.45,109.88 193.45,110.16 193.65,110.35 194.2,110.35 194.39,110.55 194.39,110.83 194.2,111.03 193.65,111.03 193.45,111.23 193.45,111.51 193.65,111.71 194.53,111.71 194.72,111.9 194.72,112.18 194.53,112.38 193.65,112.38 193.45,112.58 193.45,112.86 193.65,113.06 194.2,113.06 194.39,113.25 194.39,113.26 194.59,113.46 194.88,113.46 195.08,113.66 195.08,113.94 194.88,114.13 194.59,114.13 194.39,114.33 194.39,114.61 194.59,114.81 194.88,114.81 195.08,115.01 195.08,115.29 194.88,115.48 194.59,115.48 194.39,115.68 194.39,115.96 194.59,116.16 194.88,116.16 195.08,116.36 195.08,116.64 194.88,116.84 194.59,116.84 194.39,117.03 194.39,117.86 194.65,118.11 194.92,118.11 196,117.03 196.28,117.03 196.48,117.23 196.48,117.51 195.4,118.59 195.4,118.87 195.6,119.06 195.88,119.06 196.96,117.98 197.24,117.98 197.44,118.18 197.44,118.46 196.36,119.54 196.36,119.82 196.56,120.02 196.84,120.02 197.66,119.19 197.94,119.19 198.14,119.39 198.14,119.67 197.31,120.5 197.31,120.78 198.08,121.54 198.08,132.21 194.31,135.98 189.29,135.98
M_DA11: length 83.3
  TOP w0.089: CPU.AL37 181.72,136.89 181.63,136.8 181.63,136.51 181.79,136.35 182.95,136.35 182.99,136.31 184.96,136.31 185.16,136.4 187.08,136.4 188.13,135.35 189.29,135.35
  TOP w0.165: 189.29,135.35 193.31,135.35 197.31,131.34 197.31,123.44 196.82,122.95 196.82,122.67 197.4,122.09 197.4,121.81 197.21,121.61 196.93,121.61 196.34,122.19 196.06,122.19 195.87,121.99 195.87,121.71 196.45,121.13 196.45,120.85 196.25,120.65 195.97,120.65 195.39,121.24 195.11,121.24 194.91,121.04 194.91,120.76 195.49,120.18 195.49,119.9 195.3,119.7 195.02,119.7 194.43,120.28 194.15,120.28 193.95,120.08 193.95,119.8 194.54,119.22 194.54,118.94 194.34,118.74 194.06,118.74 193.48,119.33 193.2,119.33 192.81,118.94 192.81,118.65 193.2,118.26 193.2,117.97 192.81,117.58 192.81,117.29 193,117.09 193.56,117.09 193.76,116.89 193.76,116.61 193.56,116.41 193,116.41 192.81,116.22 192.81,115.94 193,115.74 193.56,115.74 193.76,115.54 193.76,115.26 193.56,115.06 193,115.06 192.81,114.86 192.81,114.58 193,114.39 193.56,114.39 193.76,114.19 193.76,113.91 193.56,113.71 193,113.71 192.81,113.51 192.81,108.13 204.24,96.7 204.24,91.44 203.83,91.03 203.81,91.03 203.59,90.81 203.59,89.61 204.39,88.81 DIMM1.168
M_DA12: length 80.9
  TOP w0.089: 189.29,139.29 188.48,139.29 187.9,138.72 CPU.AJ40
  TOP w0.165: DIMM1.16 210.53,90.12 209.65,91 209.65,92.69 209.19,93.15 209.19,93.81 209.39,94.01 209.69,94.01 209.89,94.21 209.89,94.49 209.69,94.69 209.39,94.69 209.19,94.88 209.19,95.16 209.39,95.36 209.69,95.36 209.89,95.56 209.89,95.84 209.69,96.04 209.39,96.04 209.19,96.24 209.19,96.52 209.39,96.71 209.69,96.71 209.89,96.91 209.89,97.19 209.69,97.39 209.39,97.39 209.19,97.59 209.19,98.08 208.99,98.27 208.49,98.27 208.29,98.47 208.29,98.75 208.49,98.95 208.99,98.95 209.19,99.15 209.19,99.43 208.99,99.63 208.49,99.63 208.29,99.82 208.29,100.1 208.49,100.3 208.99,100.3 209.19,100.5 209.19,100.78 208.99,100.98 208.84,100.98 208.64,101.17 208.64,101.45 208.84,101.65 208.99,101.65 209.19,101.85 209.19,112.15 208.57,112.78 208.57,113.06 208.82,113.31 208.82,113.59 208.62,113.79 208.34,113.79 208.09,113.53 207.81,113.53 207.61,113.73 207.61,114.01 207.86,114.27 207.86,114.55 207.67,114.74 207.39,114.74 207.13,114.49 206.85,114.49 206.66,114.69 206.66,114.97 206.91,115.22 206.91,115.5 206.71,115.7 206.43,115.7 206.18,115.45 205.9,115.45 205.7,115.64 205.7,115.92 205.95,116.18 205.95,116.46 205.76,116.65 205.48,116.65 205.22,116.4 204.94,116.4 204.74,116.6 204.74,116.88 205,117.13 205,117.41 204.8,117.61 204.52,117.61 204.27,117.36 203.99,117.36 203.79,117.55 203.79,117.83 204.04,118.09 204.04,118.37 203.84,118.57 203.56,118.57 203.31,118.31 203.03,118.31 202.83,118.51 202.83,118.79 203.09,119.04 203.09,119.32 202.89,119.52 202.61,119.52 202.36,119.27 202.08,119.27 201.8,119.54 201.8,120.7 201.44,121.05 201.44,133.81 195.96,139.29 189.29,139.29
M_DA13: length 83.2
  TOP w0.089: CPU.AJ38 183.19,138.72 183.52,138.38 183.9,138.38 184.22,138.7 184.22,138.84 184.44,139.06 184.86,139.06 184.95,138.96 186.38,138.96 186.48,139.06 187.61,139.06 188.48,139.93 189.29,139.93
  TOP w0.165: 189.29,139.93 196.23,139.93 202.08,134.08 202.08,121.32 210.55,112.85 210.55,112.33 210.35,112.13 210.03,112.13 209.84,111.94 209.84,111.66 210.03,111.46 210.35,111.46 210.55,111.26 210.55,110.98 210.35,110.78 210.03,110.78 209.84,110.59 209.84,110.31 210.03,110.11 210.35,110.11 210.55,109.91 210.55,109.63 210.35,109.43 210.03,109.43 209.84,109.23 209.84,108.95 210.03,108.76 210.35,108.76 210.55,108.56 210.55,108.28 210.35,108.08 210.03,108.08 209.84,107.88 209.84,107.6 210.03,107.4 210.35,107.4 210.55,107.21 210.55,106.93 210.35,106.73 210.03,106.73 209.84,106.53 209.84,106.25 210.03,106.05 210.35,106.05 210.55,105.86 210.55,105.58 210.35,105.38 210.03,105.38 209.84,105.18 209.84,104.9 210.03,104.7 210.35,104.7 210.55,104.5 210.55,104.22 210.35,104.03 210.03,104.03 209.84,103.83 209.84,103.55 210.03,103.35 210.35,103.35 210.55,103.15 210.55,102.87 210.35,102.68 210.03,102.68 209.84,102.48 209.84,102.2 210.03,102 210.35,102 210.55,101.8 210.55,101.52 210.35,101.32 210.03,101.32 209.84,101.13 209.84,100.85 210.03,100.65 210.35,100.65 210.55,100.45 210.55,100.17 210.35,99.97 210.09,99.97 209.89,99.78 209.89,99.5 210.09,99.3 210.35,99.3 210.55,99.1 210.55,98.82 210.35,98.62 210.11,98.62 209.91,98.42 209.91,98.14 210.11,97.95 210.35,97.95 210.55,97.75 210.55,92.53 211.02,92.06 211.02,91.27 212.04,90.25 DIMM1.159
M_DA14: length 80.7
  TOP w0.089: CPU.AL39 184.1,136.89 184.44,137.23 184.9,137.23 185,137.13 188.84,137.13 188.96,137.25 189.29,137.25
  TOP w0.165: DIMM1.21 206.94,96.69 205.13,98.5 205.13,98.78 205.98,99.64 205.98,99.92 205.78,100.11 205.51,100.11 204.65,99.26 204.37,99.26 204.17,99.46 204.17,99.74 205.03,100.59 205.03,100.87 204.83,101.07 204.55,101.07 203.69,100.21 203.41,100.21 203.22,100.41 203.22,100.69 204.07,101.55 204.07,101.83 203.87,102.03 203.59,102.03 202.74,101.17 202.46,101.17 202.26,101.37 202.26,101.65 203.12,102.5 203.12,102.78 202.92,102.98 202.64,102.98 202.15,102.49 201.78,102.13 201.5,102.13 201.31,102.32 201.31,102.6 202.06,103.36 202.06,103.64 201.86,103.84 201.58,103.84 200.83,103.08 200.55,103.08 196.46,107.17 196.46,111.91 197.68,113.13 197.68,113.41 197.33,113.76 197.33,114.04 197.53,114.24 197.81,114.24 198.16,113.89 198.44,113.89 198.64,114.09 198.64,114.37 198.29,114.72 198.29,115 198.49,115.19 198.77,115.19 199.12,114.84 199.4,114.84 199.75,115.2 199.75,119.81 199.35,120.21 199.35,132.74 194.84,137.25 189.29,137.25
M_DA15: length 79.5
  TOP w0.089: CPU.AL40 188.86,136.89 189.13,136.62 189.29,136.62
  TOP w0.165: DIMM1.166 206.09,88.68 205.24,89.53 205.24,90.75 205.51,91.03 205.53,91.03 205.94,91.44 205.94,91.45 205.95,91.47 205.95,96.78 195.83,106.9 195.83,107.89 195.63,108.09 195.23,108.09 195.03,108.28 195.03,108.56 195.23,108.76 195.63,108.76 195.83,108.96 195.83,109.24 195.63,109.44 195.23,109.44 195.03,109.64 195.03,109.92 195.23,110.11 195.63,110.11 195.83,110.31 195.83,110.59 195.63,110.79 195.23,110.79 195.03,110.99 195.03,111.27 195.23,111.46 195.63,111.46 195.83,111.66 195.83,112.17 196.4,112.75 196.4,113.03 196.2,113.22 195.91,113.22 195.71,113.42 195.71,113.7 195.91,113.9 196.48,113.9 196.68,114.1 196.68,114.38 196.48,114.57 195.91,114.57 195.71,114.77 195.71,115.49 195.98,115.76 196.26,115.76 196.86,115.16 197.14,115.16 197.33,115.36 197.33,115.64 196.74,116.24 196.74,116.52 196.94,116.72 197.22,116.72 197.77,116.16 198.05,116.16 198.25,116.36 198.25,116.64 197.69,117.19 197.69,117.47 197.89,117.67 198.17,117.67 198.59,117.25 198.87,117.25 199.07,117.45 199.07,117.73 198.65,118.15 198.65,118.43 199.12,118.9 199.12,119.54 198.71,119.95 198.71,132.48 194.57,136.62 189.29,136.62
M_DA16: length 67.8
  TOP w0.089: CPU.AN38 183.19,135.06 183.52,134.72 183.9,134.72 184.22,135.04 184.22,135.18 184.44,135.4 184.86,135.4 184.95,135.3 186.78,135.3 188,134.08 189.29,134.08
  TOP w0.165: DIMM1.170 203.3,86.93 203.3,87.21 202.86,87.64 202.86,88.35 202.01,89.2 202.01,89.83 202.01,90.76 202.78,91.52 202.78,96.36 191.51,107.63 191.51,120.77 196.02,125.28 196.02,130.84 192.78,134.08 189.29,134.08
M_DA17: length 65.6
  TOP w0.089: CPU.AN40 186.52,135.06 188.14,133.44 189.29,133.44
  TOP w0.165: DIMM1.27 201.84,92.58 202.14,92.88 202.14,93.3 201.94,93.5 201.68,93.5 201.48,93.69 201.48,93.97 201.68,94.17 201.94,94.17 202.14,94.37 202.14,94.65 201.94,94.85 201.68,94.85 201.48,95.04 201.48,95.32 201.68,95.52 201.94,95.52 202.14,95.72 202.14,96.1 190.88,107.36 190.88,122.86 191.09,123.08 191.37,123.08 191.77,122.68 192.05,122.68 192.25,122.87 192.25,123.15 191.85,123.56 191.85,123.83 192.05,124.03 192.32,124.03 192.73,123.63 193.01,123.63 193.2,123.83 193.2,124.11 192.8,124.51 192.8,124.79 193,124.99 193.28,124.99 193.68,124.59 193.96,124.59 194.16,124.79 194.16,125.06 193.76,125.47 193.76,125.75 193.96,125.94 194.24,125.94 194.64,125.54 194.92,125.54 195.12,125.74 195.12,126.02 194.71,126.42 194.71,126.7 195.36,127.35 195.36,130.54 192.46,133.44 189.29,133.44
M_DA18: length 66.2
  TOP w0.089: 186.09,130.78 186.09,132.39 185.58,132.9 183.54,132.9 CPU.AR38
  TOP w0.165: 186.09,130.78 186.09,106.53 186.28,106.34 186.56,106.34 186.69,106.48 186.97,106.48 187.17,106.28 187.17,106 187.04,105.87 187.04,105.59 187.23,105.39 187.51,105.39 187.65,105.53 187.93,105.53 188.13,105.33 188.13,105.05 187.99,104.91 187.99,104.63 188.19,104.43 188.47,104.43 188.6,104.57 188.88,104.57 189.08,104.37 189.08,104.09 188.95,103.96 188.95,103.68 189.14,103.48 189.42,103.48 189.56,103.61 189.84,103.61 190.04,103.42 190.04,103.14 189.9,103 189.9,102.72 190.1,102.52 190.38,102.52 190.52,102.66 190.8,102.66 190.99,102.46 190.99,102.18 190.86,102.05 190.86,101.77 191.06,101.57 191.34,101.57 191.47,101.7 191.75,101.7 191.95,101.51 191.95,101.23 191.81,101.09 191.81,100.81 192.01,100.61 192.29,100.61 192.43,100.75 192.71,100.75 192.9,100.55 192.9,100.27 192.77,100.13 192.77,99.85 192.97,99.66 193.25,99.66 193.38,99.79 193.66,99.79 193.86,99.59 193.86,99.31 193.72,99.18 193.72,98.9 193.92,98.7 194.2,98.7 194.34,98.84 194.62,98.84 194.82,98.64 194.82,98.36 194.68,98.22 194.68,97.94 194.88,97.75 195.16,97.75 195.29,97.88 195.57,97.88 195.77,97.68 195.77,96.6 195.53,96.35 194.13,96.35 193.94,96.16 193.94,95.88 194.13,95.68 195.53,95.68 195.72,95.48 195.72,95.2 195.53,95 194.13,95 193.94,94.8 193.94,94.53 194.13,94.33 195.53,94.33 195.72,94.13 195.72,93.85 195.53,93.65 194.14,93.65 193.97,93.49 193.97,93.14 194.14,92.98 195.53,92.98 195.72,92.78 195.72,91.3 195.89,91.13 DIMM1.34
M_DA19: length 67.2
  TOP w0.089: CPU.AR37 182.28,132.84 182.79,132.84 182.97,132.65 183.99,132.65 184.13,132.51 184.13,132.22 184.46,131.89 185.16,131.89 185.77,131.28 185.77,130.66 185.44,130.33 185.44,129.36
  TOP w0.165: DIMM1.179 195.04,90.76 194.11,91.69 194.11,92.04 193.3,92.85 193.3,96.91 193.5,97.11 193.81,97.11 194.01,97.31 194.01,97.59 193.81,97.79 193.5,97.79 193.3,97.98 193.3,98.42 185.44,106.28 185.44,107.77 185.24,107.97 184.79,107.97 184.59,108.17 184.59,108.45 184.79,108.65 185.24,108.65 185.44,108.84 185.44,109.12 185.24,109.32 184.79,109.32 184.59,109.52 184.59,109.8 184.79,110 185.24,110 185.44,110.19 185.44,110.47 185.24,110.67 184.79,110.67 184.59,110.87 184.59,111.15 184.79,111.35 185.24,111.35 185.44,111.55 185.44,111.83 185.24,112.02 184.79,112.02 184.59,112.22 184.59,112.5 184.79,112.7 185.24,112.7 185.44,112.9 185.44,113.18 185.24,113.38 184.79,113.38 184.59,113.57 184.59,113.85 184.79,114.05 185.24,114.05 185.44,114.25 185.44,114.53 185.24,114.73 184.79,114.73 184.59,114.92 184.59,115.2 184.79,115.4 185.24,115.4 185.44,115.6 185.44,115.88 185.24,116.08 184.79,116.08 184.59,116.28 184.59,116.56 184.79,116.75 185.24,116.75 185.44,116.95 185.44,117.23 185.24,117.43 184.79,117.43 184.59,117.63 184.59,117.91 184.79,118.1 185.24,118.1 185.44,118.3 185.44,118.58 185.24,118.78 184.79,118.78 184.59,118.98 184.59,119.26 184.79,119.46 185.24,119.46 185.44,119.65 185.44,119.93 185.24,120.13 184.79,120.13 184.59,120.33 184.59,120.61 184.79,120.81 185.24,120.81 185.44,121.01 185.44,122.07 185.07,122.44 185.07,122.75 185.44,123.11 185.44,123.42 185.07,123.79 185.07,124.1 185.44,124.47 185.44,124.77 185.07,125.14 185.07,125.45 185.44,125.82 185.44,126.12 185.07,126.49 185.07,126.8 185.44,127.17 185.44,127.48 185.07,127.84 185.07,128.15 185.44,128.52 185.44,129.36
M_DA20: length 66.3
  TOP w0.089: 189.29,134.71 187.86,134.71 187.02,135.55 185.12,135.55 185.04,135.63 183.93,135.63 183.71,135.41 CPU.AN39
  TOP w0.165: 189.29,134.71 193.04,134.71 196.65,131.1 196.65,125.02 195.77,124.13 195.77,123.85 196.13,123.5 196.13,123.22 195.93,123.02 195.65,123.02 195.29,123.38 195.01,123.38 194.81,123.18 194.81,122.9 195.18,122.53 195.18,122.25 194.98,122.05 194.7,122.05 194.34,122.42 194.06,122.42 193.86,122.22 193.86,121.94 194.2,121.6 194.2,121.32 194,121.12 193.72,121.12 193.38,121.47 193.1,121.47 192.9,121.27 192.9,120.99 193.25,120.65 193.25,120.37 193.05,120.17 192.77,120.17 192.51,120.42 192.32,120.42 192.15,120.24 192.15,107.89 203.54,96.49 DIMM1.25
M_DA21: length 68.3
  TOP w0.089: CPU.AN37 182.26,134.68 183.22,134.68 183.4,134.5 184.05,134.5 184.27,134.72 184.84,134.72 184.94,134.82 186.27,134.82 188.29,132.81 189.29,132.81
  TOP w0.165: 189.29,132.81 192.2,132.81 194.72,130.28 194.72,127.61 191.44,124.33 191.16,124.33 190.81,124.68 190.53,124.68 190.33,124.48 190.33,124.2 190.68,123.85 190.68,123.57 190.24,123.13 190.24,107.1 200.84,96.51 200.84,91.53 201.67,90.69 201.67,89.06 202.52,88.21 202.52,87.28 201.57,86.32 DIMM1.172
M_DA22: length 64.9
  TOP w0.089: CPU.AR39 184.1,133.23 184.44,133.57 184.9,133.57 185,133.47 185.69,133.47 187.42,131.74 187.42,130.78
  TOP w0.165: DIMM1.32 197.59,92.37 198.78,93.55 198.78,94.2 198.58,94.39 198.29,94.39 198.09,94.59 198.09,94.87 198.29,95.07 198.58,95.07 198.78,95.27 198.78,96.55 188.38,106.95 188.38,107.23 188.58,107.43 188.58,107.71 188.39,107.91 188.11,107.91 187.9,107.7 187.62,107.7 187.36,107.97 187.36,108.91 187.56,109.11 188.53,109.11 188.73,109.31 188.73,109.59 188.53,109.78 188.32,109.78 188.12,109.98 188.12,110.26 188.32,110.46 188.61,110.46 188.81,110.66 188.81,110.94 188.61,111.14 188.32,111.14 188.12,111.33 188.12,111.61 188.32,111.81 188.61,111.81 188.81,112.01 188.81,112.29 188.61,112.49 188.32,112.49 188.12,112.68 188.12,112.96 188.32,113.16 188.61,113.16 188.81,113.36 188.81,113.64 188.61,113.84 188.32,113.84 188.12,114.04 188.12,114.32 188.32,114.51 188.61,114.51 188.81,114.71 188.81,114.99 188.61,115.19 188.32,115.19 188.12,115.39 188.12,115.67 188.32,115.86 188.61,115.86 188.81,116.06 188.81,116.34 188.61,116.54 188.32,116.54 188.12,116.74 188.12,117.02 188.32,117.22 188.61,117.22 188.81,117.41 188.81,117.69 188.61,117.89 188.32,117.89 188.12,118.09 188.12,118.37 188.32,118.57 188.61,118.57 188.81,118.77 188.81,119.04 188.61,119.24 188.32,119.24 188.12,119.44 188.12,119.72 188.32,119.92 188.61,119.92 188.81,120.12 188.81,120.4 188.61,120.59 188.32,120.59 188.12,120.79 188.12,121.07 188.32,121.27 188.61,121.27 188.81,121.47 188.81,121.75 188.61,121.95 188.32,121.95 188.12,122.14 188.12,122.42 188.32,122.62 188.61,122.62 188.81,122.82 188.81,123.1 188.61,123.3 188.32,123.3 188.12,123.49 188.12,123.77 188.32,123.97 188.61,123.97 188.81,124.17 188.81,125.85 187.42,127.23 187.42,130.78
