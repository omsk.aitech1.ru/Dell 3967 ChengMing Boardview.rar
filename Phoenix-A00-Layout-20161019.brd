# Allegro board Phoenix-A00-Layout-20161019.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_DB47: length 75.8
  TOP w0.089: v1(150.88,134.6) CPU.AP6
  L3_GND w0.089: v1(150.88,134.6) 150.87,134.61 147.17,134.61 146.26,133.7 145.62,133.7 145.11,133.2 144.21,133.2 144.15,133.14
  L3_GND w0.14: 144.15,133.14 142.03,131.02 138.95,127.93 138.95,122.18 138.16,121.4 138.16,114 138.54,113.62 138.54,113.35 138.16,112.97 138.16,112.3 138.35,112.1 138.7,112.1 138.89,111.91 138.89,111.64 138.7,111.45 138.35,111.45 138.16,111.26 138.16,110.52 130.98,103.34 130.98,101.34 122.61,92.97 122.61,91.45 121.76,90.6 121.76,89.3 122.61,88.45 122.61,87.6 121.76,86.75 121.76,84.11 121.28,83.63 121.28,82.44 121.52,82.2 121.76,81.96 121.76,79.68 121.09,79.01 DIMM2.260
M_DB48: length 86
  TOP w0.089: CPU.AM10 v1(155.45,136.43)
  L3_GND w0.089: v1(155.45,136.43) 154.97,135.95 154.38,135.95 154.06,135.62 154.06,135.32 153.8,135.07 146.96,135.07 146.46,134.57 145.93,134.57 145.04,133.68 143.78,133.68 143.51,133.41
  L3_GND w0.14: 143.51,133.41 142.44,132.34 138.3,128.2 138.3,124.88 134.53,121.11 134.53,120.84 134.9,120.48 134.9,120.21 134.7,120.02 134.44,120.02 134.07,120.38 133.8,120.38 133.61,120.19 133.61,119.92 133.98,119.56 133.98,119.29 133.78,119.1 133.52,119.1 133.15,119.46 132.88,119.46 132.69,119.27 132.69,119 133.06,118.64 133.06,118.37 132.86,118.18 132.6,118.18 132.23,118.54 131.96,118.54 131.77,118.35 131.77,118.08 132.14,117.72 132.14,117.45 131.94,117.26 131.68,117.26 131.31,117.62 131.04,117.62 130.85,117.43 130.85,117.16 131.22,116.8 131.22,116.53 131.02,116.34 130.76,116.34 130.39,116.7 130.12,116.7 129.93,116.51 129.93,116.24 130.3,115.88 130.3,115.61 130.1,115.42 129.84,115.42 129.47,115.78 129.2,115.78 128.33,114.91 125.01,114.91 121.28,111.18 121.28,107.39 122.08,106.59 122.08,93.56 121.28,92.76 121.28,91.38 121.28,91.3 120.43,90.45 120.43,89.32 121.28,88.47 121.28,87.45 120.43,86.6 120.43,86.05 120.72,85.76 120.72,83.19 DIMM2.117
M_DB49: length 87
  TOP w0.089: CPU.AL10 v1(155.45,137.35)
  L3_GND w0.089: 142.97,133.79 143.27,134.09 144.87,134.09 145.84,135.05 146.36,135.05 146.79,135.49 148.44,135.49 148.87,135.92 153.48,135.92 154.43,136.86 154.97,136.86 v1(155.45,137.35)
  L3_GND w0.14: DIMM2.262 119.39,77.83 119.58,78.02 119.58,79.19 120.06,79.68 120.06,81.96 119.58,82.44 119.58,82.99 120.06,83.48 120.06,86.75 120.91,87.6 120.91,88.32 120.06,89.16 120.06,90.6 120.91,91.45 120.91,92 120.63,92.28 120.63,93.03 121.43,93.83 121.43,95.24 121.06,95.61 121.06,95.89 121.43,96.26 121.43,96.54 121.06,96.91 121.06,97.19 121.43,97.56 121.43,97.84 121.06,98.21 121.06,98.49 121.43,98.86 121.43,106.32 120.63,107.12 120.63,111.45 124.74,115.56 127.66,115.56 128.05,115.95 128.43,115.95 128.7,116.22 128.7,116.6 128.97,116.87 129.35,116.87 129.62,117.14 129.62,117.52 129.89,117.79 130.27,117.79 130.54,118.06 130.54,118.44 130.81,118.71 131.19,118.71 131.46,118.98 131.46,119.36 131.73,119.63 132.11,119.63 132.38,119.9 132.38,120.28 132.65,120.55 133.03,120.55 133.3,120.82 133.3,121.2 133.57,121.47 133.95,121.47 134.22,121.74 134.22,122.12 137.65,125.55 137.65,128.47 142.97,133.79
M_DB50: length 85.2
  TOP w0.089: CPU.AL6 151.15,138 151.03,138.13 v1(150.88,138.29)
  L3_GND w0.089: v1(150.88,138.29) 150.62,138.29 150.49,138.42 149.21,138.42 148.73,138.9 145.7,138.9 144.89,138.08 144.23,138.08
  L3_GND w0.14: 144.23,138.08 141.37,138.08 133.4,130.11 133.4,129.18 132.43,128.21 131.9,128.21 131.7,128.01 131.7,127.48 131.34,127.11 130.83,127.11 130.62,126.91 130.62,126.4 130.42,126.19 129.91,126.19 129.7,125.99 129.7,125.48 129.5,125.27 128.99,125.27 128.78,125.07 128.78,124.56 127.86,123.64 127.86,123.37 128.05,123.18 128.05,122.91 127.86,122.72 127.59,122.72 127.4,122.91 127.13,122.91 126.94,122.72 126.94,122.45 127.13,122.26 127.13,121.99 126.94,121.8 126.67,121.8 126.48,121.99 126.21,121.99 126.02,121.8 126.02,121.53 126.21,121.34 126.21,121.07 126.02,120.88 125.75,120.88 125.56,121.07 125.29,121.07 125.1,120.88 125.1,120.61 125.29,120.42 125.29,120.15 125.1,119.96 124.83,119.96 124.64,120.15 124.37,120.15 123.93,119.71 123.02,119.71 116.47,113.15 116.47,94.56 114.94,93.03 114.94,92.59 114.48,92.13 114.48,91.25 113.63,90.4 113.63,89.85 114.11,89.36 114.11,87.08 113.63,86.6 113.63,83.84 112.78,82.99 112.78,82.12 112.59,81.94 DIMM2.126
M_DB51: length 86
  TOP w0.089: CPU.AL7 v1(152.71,138.26)
  L3_GND w0.089: 144.23,138.73 144.91,138.73 145.39,139.21 148.15,139.21 148.55,139.6 149.23,139.6 149.48,139.35 149.48,139.06 149.79,138.75 151.89,138.75 v1(152.71,138.26)
  L3_GND w0.14: 144.23,138.73 141.1,138.73 115.82,113.44 115.82,94.83 114.11,93.13 114.11,91.4 113.26,90.55 113.26,88.68 112.78,88.2 112.78,87.65 113.26,87.16 113.26,84 112.41,83.15 112.41,82.44 111.74,81.77 111.74,80.58 112.12,80.2 112.12,79.93 111.74,79.55 DIMM2.271
M_DB52: length 85.7
  TOP w0.089: CPU.AM9 v1(154.54,137.35)
  L3_GND w0.089: 143.3,134.54 144.77,134.54 145.78,135.55 146.28,135.55 146.64,135.91 148.4,135.91 148.7,136.21 152.5,136.21 153.41,136.21 v1(154.54,137.35)
  L3_GND w0.14: DIMM2.119 119.26,83.44 119.26,85.51 118.73,86.05 118.73,86.6 119.33,87.21 119.48,87.21 119.58,87.3 119.58,88.73 119.54,88.77 119.54,89.04 118.73,89.85 118.73,90.4 119.58,91.25 119.58,91.51 119.58,92.68 119.98,93.08 119.98,98.93 120.35,99.3 120.35,99.58 119.98,99.95 119.98,100.23 120.35,100.6 120.35,100.88 119.98,101.25 119.98,101.53 120.35,101.9 120.35,102.18 119.98,102.55 119.98,102.83 120.35,103.2 120.35,103.48 119.98,103.85 119.98,104.13 120.35,104.5 120.35,104.78 119.98,105.15 119.98,105.43 120.35,105.8 120.35,106.08 119.98,106.45 119.98,111.73 124.46,116.2 127.21,116.2 129.27,118.26 129.27,118.53 129.13,118.67 129.13,118.94 129.32,119.13 129.59,119.13 129.73,118.99 130,118.99 130.19,119.18 130.19,119.45 130.05,119.59 130.05,119.86 130.24,120.05 130.51,120.05 130.65,119.91 130.92,119.91 131.11,120.1 131.11,120.37 130.97,120.51 130.97,120.78 131.16,120.97 131.43,120.97 131.57,120.83 131.84,120.83 132.03,121.02 132.03,121.29 131.89,121.43 131.89,121.7 132.08,121.89 132.35,121.89 132.49,121.75 132.76,121.75 132.95,121.94 132.95,122.21 132.81,122.35 132.81,122.62 133,122.81 133.27,122.81 133.41,122.67 133.68,122.67 133.87,122.86 133.87,123.13 133.73,123.27 133.73,123.54 133.92,123.73 134.19,123.73 134.33,123.59 134.6,123.59 134.79,123.78 134.79,124.05 134.65,124.19 134.65,124.46 134.84,124.65 135.11,124.65 135.25,124.51 135.52,124.51 135.71,124.7 135.71,124.97 135.57,125.11 135.57,125.38 135.76,125.57 136.03,125.57 136.17,125.43 136.44,125.43 137,126 137,128.74 142.81,134.54 143.3,134.54
M_DB53: length 86.9
  TOP w0.089: CPU.AL9 v1(154.54,138.26)
  L3_GND w0.089: 143.95,135.19 144.72,135.19 145.99,136.46 152.18,136.46 152.5,136.78 153.66,136.78 154.01,137.13 154.06,137.3 154.06,137.78 v1(154.54,138.26)
  L3_GND w0.14: DIMM2.264 118.19,77.32 119.21,78.33 119.21,79.19 118.59,79.82 118.59,81.73 117.88,82.44 117.88,84.94 118.36,85.42 118.36,86.75 119.21,87.6 119.21,88.2 118.89,88.52 118.89,89.17 118.36,89.7 118.36,90.6 119.21,91.45 119.21,92.33 118.98,92.56 118.98,93 119.33,93.35 119.33,112 124.19,116.85 126.09,116.85 126.68,117.44 126.94,117.44 127.09,117.29 127.36,117.29 127.55,117.48 127.55,117.75 127.4,117.9 127.4,118.17 127.7,118.46 128.22,118.46 128.42,118.66 128.42,119.18 136.35,127.12 136.35,129.02 142.53,135.19 143.95,135.19
M_DB54: length 83.7
  TOP w0.089: CPU.AM6 151.15,137.09 v1(150.88,137.37)
  L3_GND w0.089: v1(150.88,137.37) 150.57,137.37 150.14,137.8 146.66,137.8 146.23,137.38 145.44,137.38 144.84,136.79 144.23,136.79
  L3_GND w0.14: 144.23,136.79 141.91,136.79 134.7,129.57 134.7,127.65 134.44,127.39 134.17,127.39 133.96,127.59 133.7,127.59 133.5,127.4 133.5,127.13 133.71,126.93 133.71,126.66 133.52,126.47 133.25,126.47 133.04,126.67 132.78,126.67 132.58,126.48 132.58,126.21 132.79,126.01 132.79,125.74 132.37,125.32 131.86,125.32 131.65,125.12 131.65,124.61 125.46,118.41 123.56,118.41 117.76,112.62 117.76,94 116.54,92.78 116.54,92.37 116.18,92 116.18,91.25 115.33,90.4 115.33,89.85 116.16,89.01 116.16,87.43 115.33,86.6 115.33,83.84 114.48,82.99 114.48,82.13 115.15,81.46 115.15,80.47 114.94,80.26 114.51,80.26 114.29,80.48 DIMM2.124
M_DB55: length 84.5
  TOP w0.089: CPU.AM7 v1(151.79,137.37)
  L3_GND w0.089: v1(151.79,137.37) 150.91,137.85 150.67,137.85 150.41,138.12 148.82,138.12 148.59,138.35 145.78,138.35 144.87,137.43 144.23,137.43
  L3_GND w0.14: 144.23,137.43 141.64,137.43 134.05,129.84 134.05,128.91 130.15,125.01 130.15,124.74 130.33,124.57 130.33,124.3 130.14,124.11 129.87,124.11 129.74,124.23 129.47,124.23 129.28,124.04 129.28,123.77 129.43,123.62 129.43,123.35 125.14,119.06 123.29,119.06 117.11,112.88 117.11,94.27 115.81,92.97 115.81,91.4 114.96,90.55 114.96,88.68 114.48,88.2 114.48,87.65 114.96,87.16 114.96,84 114.11,83.15 114.11,82.25 113.44,81.59 113.44,80.75 112.89,80.19 112.89,79.45 113.42,78.92 DIMM2.269
M_DB56: length 96.9
  TOP w0.089: v1(150.88,140.09) CPU.AJ6
  L3_GND w0.089: 144.23,140.02 145.38,140.02 145.67,140.31 149.5,140.31 149.7,140.52 150.15,140.52 150.5,140.16 150.81,140.16 v1(150.88,140.09)
  L3_GND w0.14: DIMM2.273 110.07,78.92 110.6,79.45 110.6,79.96 109.89,80.67 109.89,81.93 109.38,82.44 109.38,82.99 110.23,83.85 110.55,83.85 111.01,84.31 111.01,84.63 111.56,85.18 111.56,86.65 110.71,87.5 110.71,88.38 111.56,89.23 111.56,90.6 112.41,91.45 112.41,92.13 112.41,92.13 112.41,92.3 112.78,92.67 112.78,93.63 113.32,94.16 113.32,94.46 113.51,94.65 113.79,94.65 113.98,94.84 113.98,95.11 113.79,95.3 113.51,95.3 113.32,95.49 113.32,95.76 113.51,95.95 113.81,95.95 114,96.14 114,96.41 113.81,96.6 113.51,96.6 113.32,96.79 113.32,97.06 113.51,97.25 113.69,97.25 113.88,97.44 113.88,97.71 113.69,97.9 113.51,97.9 113.32,98.09 113.32,98.36 113.51,98.55 113.69,98.55 113.88,98.74 113.88,99.01 113.69,99.2 113.51,99.2 113.32,99.39 113.32,99.66 113.51,99.85 113.69,99.85 113.88,100.04 113.88,100.31 113.69,100.5 113.51,100.5 113.32,100.69 113.32,100.96 113.51,101.15 113.69,101.15 113.88,101.34 113.88,101.61 113.69,101.8 113.51,101.8 113.32,101.99 113.32,102.26 113.51,102.45 113.69,102.45 113.88,102.64 113.88,102.91 113.69,103.1 113.51,103.1 113.32,103.29 113.32,103.56 113.51,103.75 113.69,103.75 113.88,103.94 113.88,104.21 113.69,104.4 113.51,104.4 113.32,104.59 113.32,104.86 113.51,105.05 113.69,105.05 113.88,105.24 113.88,105.51 113.69,105.7 113.51,105.7 113.32,105.89 113.32,106.16 113.51,106.35 113.69,106.35 113.88,106.54 113.88,106.81 113.69,107 113.51,107 113.32,107.19 113.32,107.46 113.51,107.65 113.69,107.65 113.88,107.84 113.88,108.11 113.69,108.3 113.51,108.3 113.32,108.49 113.32,108.76 113.51,108.95 113.69,108.95 113.88,109.14 113.88,109.41 113.69,109.6 113.51,109.6 113.32,109.79 113.32,110.06 113.51,110.25 113.69,110.25 113.88,110.44 113.88,110.71 113.69,110.9 113.51,110.9 113.32,111.09 113.32,111.36 113.51,111.55 113.69,111.55 113.88,111.74 113.88,112.01 113.69,112.2 113.51,112.2 113.32,112.39 113.32,112.77 140.57,140.02 144.23,140.02
M_DB57: length 98.3
  TOP w0.089: CPU.AH7 v1(152.71,140.09)
  L3_GND w0.089: v1(152.71,140.09) 152.28,139.66 149.79,139.66 149.4,140.06 145.93,140.06 145.56,139.69 145.12,139.69 144.8,139.38 144.23,139.38
  L3_GND w0.14: 144.23,139.38 140.83,139.38 115.17,113.71 115.17,113.13 114.98,112.94 114.57,112.94 114.38,112.75 114.38,112.48 114.57,112.29 114.98,112.29 115.17,112.1 115.17,111.83 114.98,111.64 114.65,111.64 114.46,111.45 114.46,111.18 114.65,110.99 114.98,110.99 115.17,110.8 115.17,110.53 114.98,110.34 114.65,110.34 114.46,110.15 114.46,109.88 114.65,109.69 114.98,109.69 115.17,109.5 115.17,109.23 114.98,109.04 114.65,109.04 114.46,108.85 114.46,108.58 114.65,108.39 114.98,108.39 115.17,108.2 115.17,107.93 114.98,107.74 114.65,107.74 114.46,107.55 114.46,107.28 114.65,107.09 114.98,107.09 115.17,106.9 115.17,106.63 114.98,106.44 114.65,106.44 114.46,106.25 114.46,105.98 114.65,105.79 114.98,105.79 115.17,105.6 115.17,105.33 114.98,105.14 114.65,105.14 114.46,104.95 114.46,104.68 114.65,104.49 114.98,104.49 115.17,104.3 115.17,104.03 114.98,103.84 114.65,103.84 114.46,103.65 114.46,103.38 114.65,103.19 114.98,103.19 115.17,102.99 115.17,102.73 114.98,102.54 114.65,102.54 114.46,102.34 114.46,102.08 114.65,101.88 114.98,101.88 115.17,101.69 115.17,101.43 114.98,101.23 114.65,101.23 114.46,101.04 114.46,100.78 114.65,100.58 114.98,100.58 115.17,100.39 115.17,100.12 114.98,99.93 114.65,99.93 114.46,99.74 114.46,99.47 114.65,99.28 114.98,99.28 115.17,99.09 115.17,98.82 114.98,98.63 114.65,98.63 114.46,98.44 114.46,98.17 114.65,97.98 114.98,97.98 115.17,97.79 115.17,97.52 114.98,97.33 114.7,97.33 114.51,97.14 114.51,96.87 114.7,96.68 114.98,96.68 115.17,96.49 115.17,95.1 113.44,93.37 113.44,92.81 112.78,92.15 112.78,91.25 111.93,90.4 111.93,89.08 111.08,88.23 111.08,87.65 111.93,86.8 111.93,85.38 112.12,85.19 112.31,85.19 112.5,85 112.5,84.73 112.31,84.54 112.12,84.54 111.93,84.35 111.93,83.84 110.75,82.67 110.75,82.33 110.45,82.03 110.45,81.57 DIMM2.128
M_DB58: length 98.5
  TOP w0.089: CPU.AE6 v1(151.79,142.83)
  L3_GND w0.089: v1(151.79,142.83) 151.41,143 151.21,143.11 150.78,143.54 149.01,143.54 148.77,143.3 145.88,143.3 145.49,143.69 145.37,143.69
  L3_GND w0.14: 145.37,143.69 139.3,143.69 108.19,112.58 108.19,111.32 108.38,111.13 108.76,111.13 108.95,110.94 108.95,110.67 108.76,110.48 108.38,110.48 108.19,110.29 108.19,110.02 108.38,109.83 108.88,109.83 109.08,109.64 109.08,109.37 108.88,109.18 108.38,109.18 108.19,108.99 108.19,96.34 105.7,93.85 105.61,93.77 105.61,91.3 104.99,90.67 104.99,89.48 104.28,88.78 104.28,87.45 104.1,87.27 103.43,86.6 103.43,86.05 104.09,85.38 104.09,82.06 103.43,81.39 103.43,80.84 104.09,80.17 104.09,78.74 104.55,78.28 104.55,77.78 DIMM2.280
M_DB59: length 99.3
  TOP w0.089: CPU.AF7 v1(152.71,142.83)
  L3_GND w0.089: 145.37,144.34 145.39,144.34 145.95,143.78 146.31,143.78 146.7,144.18 148.49,144.18 148.86,143.8 150.94,143.8 151.45,143.29 152.25,143.29 v1(152.71,142.83)
  L3_GND w0.14: 145.37,144.34 139.03,144.34 107.48,112.79 107.48,108.47 107.12,108.12 107.12,107.82 107.48,107.47 107.48,106.98 107.28,106.79 107.03,106.79 106.84,106.6 106.84,106.33 107.03,106.14 107.28,106.14 107.48,105.95 107.48,105.68 107.28,105.49 107.03,105.49 106.84,105.3 106.84,105.03 107.03,104.84 107.28,104.84 107.48,104.65 107.48,104.38 107.28,104.19 107.03,104.19 106.84,104 106.84,103.73 107.03,103.54 107.28,103.54 107.48,103.35 107.48,103.08 107.28,102.89 107.03,102.89 106.84,102.7 106.84,102.43 107.03,102.24 107.28,102.24 107.48,102.05 107.48,101.78 107.28,101.59 107.03,101.59 106.84,101.4 106.84,101.13 107.03,100.94 107.28,100.94 107.48,100.75 107.48,100.48 107.28,100.29 107.03,100.29 106.84,100.1 106.84,99.83 107.03,99.64 107.28,99.64 107.48,99.45 107.48,99.18 107.28,98.99 107.03,98.99 106.84,98.8 106.84,98.53 107.03,98.34 107.28,98.34 107.48,98.15 107.48,97.88 107.28,97.69 107.03,97.69 106.84,97.5 106.84,97.23 107.03,97.04 107.28,97.04 107.48,96.85 107.48,96.57 103.91,93.01 103.91,91.45 103.24,90.78 103.24,88.87 103.91,88.2 103.91,87.65 103.82,87.55 103.06,86.8 103.06,85.9 103.24,85.71 DIMM2.137
M_DB60: length 97.3
  TOP w0.089: CPU.AH6 v1(151.79,141)
  L3_GND w0.089: v1(151.79,141) 151.38,141.42 150.71,141.42 150.55,141.26 150.55,141.26 150.49,141.2 149.47,141.2 149.23,141.44 145.78,141.44 145.46,141.11 144.9,141.11 144.7,141.32 144.23,141.32
  L3_GND w0.14: 144.23,141.32 140.03,141.32 111.34,112.63 111.34,98.18 111.53,97.99 111.83,97.99 112.02,97.8 112.02,97.53 111.83,97.34 111.53,97.34 111.34,97.15 111.34,96.6 112.02,95.92 112.02,95.07 110.76,93.81 110.76,93.54 111.03,93.26 111.03,92.99 110.84,92.8 110.57,92.8 110.3,93.08 110.03,93.08 109.38,92.43 109.38,91.45 109.86,90.96 109.86,89.2 109.01,88.35 109.01,87.5 109.86,86.65 109.86,84.51 109.62,84.27 109.35,84.27 109.01,84.61 108.74,84.61 108.55,84.42 108.55,84.15 108.89,83.81 108.89,83.54 108.73,83.38 108.07,83.38 108.03,83.34 107.68,82.99 107.68,82.04 108.16,81.56 108.16,80.06 109.18,79.04 109.18,78.18 108.95,77.95 108.57,77.95 108.34,78.18 DIMM2.275
M_DB61: length 97.7
  TOP w0.089: CPU.AJ7 v1(151.79,140.09)
  L3_GND w0.089: v1(151.79,140.09) 151.34,140.54 150.62,140.54 150.38,140.78 149.6,140.78 149.39,140.57 147.73,140.57 147.62,140.67 144.23,140.67
  L3_GND w0.14: DIMM2.130 109.19,80.61 109.02,80.44 108.72,80.44 108.53,80.63 108.53,81.81 109.01,82.29 109.01,83.15 110.23,84.36 110.23,86.8 109.38,87.65 109.38,88.2 110.23,89.05 110.23,90.96 110.71,91.45 110.71,91.78 111.74,92.81 111.74,93.88 112.67,94.8 112.67,98.52 112.48,98.71 112.19,98.71 112,98.9 112,99.17 112.19,99.36 112.48,99.36 112.67,99.55 112.67,99.82 112.48,100.01 112.19,100.01 112,100.2 112,100.47 112.19,100.66 112.48,100.66 112.67,100.85 112.67,101.12 112.48,101.31 112.19,101.31 112,101.5 112,101.77 112.19,101.96 112.48,101.96 112.67,102.15 112.67,102.42 112.48,102.61 112.19,102.61 112,102.8 112,103.07 112.19,103.26 112.48,103.26 112.67,103.45 112.67,103.72 112.48,103.91 112.19,103.91 112,104.1 112,104.37 112.19,104.56 112.48,104.56 112.67,104.75 112.67,105.02 112.48,105.21 112.19,105.21 112,105.4 112,105.67 112.19,105.86 112.48,105.86 112.67,106.05 112.67,106.32 112.48,106.51 112.19,106.51 112,106.7 112,106.97 112.19,107.16 112.48,107.16 112.67,107.35 112.67,107.62 112.48,107.81 112.19,107.81 112,108 112,108.27 112.19,108.46 112.48,108.46 112.67,108.65 112.67,108.92 112.48,109.11 112.19,109.11 112,109.3 112,109.57 112.19,109.76 112.48,109.76 112.67,109.95 112.67,110.22 112.48,110.41 112.19,110.41 112,110.6 112,110.87 112.19,111.06 112.48,111.06 112.67,111.25 112.67,111.52 112.48,111.71 112.19,111.71 112,111.9 112,112.17 112.19,112.36 112.48,112.36 112.67,112.55 112.67,113.04 140.3,140.67 144.23,140.67
M_DB62: length 99.5
  TOP w0.089: CPU.AE7 v1(152.71,143.75)
  L3_GND w0.089: 147.78,145.01 148.02,145.01 148.97,144.06 150.92,144.06 151.08,144.22 151.92,144.22 152.39,143.75 v1(152.71,143.75)
  L3_GND w0.14: 147.78,145.01 138.78,145.01 106.15,112.38 106.15,96.7 102.22,92.77 102.22,90.91 101.68,90.37 101.68,88.75 102.22,88.21 102.22,87.64 101.68,87.1 101.68,83.54 102.22,83 102.22,82.44 101.68,81.9 101.68,79.74 102.39,79.03 DIMM2.282
M_DB63: length 98.7
  TOP w0.089: v1(150.88,142.83) CPU.AF6
  L3_GND w0.089: v1(150.88,142.83) 150.61,142.83 150.18,143.26 149.79,143.26 149.37,142.84 145.25,142.84 145.08,143.01
  L3_GND w0.14: DIMM2.135 104.94,86.9 105.98,87.94 105.98,88.2 106.64,88.86 106.64,90.79 105.98,91.45 105.98,92.48 106.71,93.22 106.71,93.95 109.79,97.03 109.79,98.36 109.6,98.55 109.06,98.55 108.87,98.74 108.87,99.01 109.06,99.2 109.6,99.2 109.79,99.39 109.79,99.66 109.6,99.85 109.06,99.85 108.87,100.04 108.87,100.31 109.06,100.5 109.6,100.5 109.79,100.69 109.79,100.96 109.6,101.15 109.06,101.15 108.87,101.34 108.87,101.61 109.06,101.8 109.6,101.8 109.79,101.99 109.79,102.26 109.6,102.45 109.06,102.45 108.87,102.64 108.87,102.91 109.06,103.1 109.6,103.1 109.79,103.29 109.79,103.56 109.6,103.75 109.06,103.75 108.87,103.94 108.87,104.21 109.06,104.4 109.6,104.4 109.79,104.59 109.79,104.86 109.6,105.05 109.06,105.05 108.87,105.24 108.87,105.51 109.06,105.7 109.6,105.7 109.79,105.89 109.79,106.16 109.6,106.35 109.06,106.35 108.87,106.54 108.87,106.81 109.06,107 109.6,107 109.79,107.19 109.79,107.46 109.6,107.65 109.06,107.65 108.87,107.84 108.87,108.11 109.06,108.3 109.6,108.3 109.79,108.49 109.79,113.27 139.56,143.05 145.04,143.05 145.08,143.01
M_DQ_VREF: length 109.5
  TOP w0.254: CPU.AC39 184.19,144.69 184.84,144.69 187.66,147.51 199.64,147.51 210.71,136.44 210.71,134.1 220.35,124.46 220.35,122.02 226.17,116.2 226.17,107.09 222.96,103.87 222.96,94.14 225.18,91.93 225.18,88.26 v1(227.69,85.75) ; v1(227.36,74.29) 225.52,74.29 C73.1 R63.2
  BOTTOM w0.254: v1(227.36,74.29) 227.67,74.6 227.67,77.55 227.46,77.75 227.46,81.8 228.4,82.74 228.4,85.04 v1(227.69,85.75)
M_DQ_VREF_RC: length 2.2
  TOP w0.254: C73.2 R106.1 226.55,75.88 226.56,75.87 v1(227.01,75.87)
M_DQSA0: length 83.1
  TOP w0.089: 189.29,143.66 189.26,143.66 189.21,143.71 188.79,143.71 186.77,141.7 185.78,141.7 185.69,141.61 185.69,141.27 185.46,141.04 185.12,141.04 185.03,141.13 183.43,141.13 183.32,141.23 183.32,141.53 183.1,141.75 182.89,141.75 182.8,141.66 CPU.AF38
  TOP w0.165: 189.29,143.66 197.94,143.66 206.2,135.4 206.2,123.47 217.85,111.82 217.85,91.37 217.01,90.53 217.01,89.44 217.87,88.59 217.87,87.72 217.73,87.58 217.65,87.54 217.56,87.49 217.34,87.56 DIMM1.153
M_DQSA1: length 73.4
  TOP w0.089: 189.29,137.81 189.19,137.81 189.13,137.87 188.78,137.87 188.44,137.53 185.62,137.53 185.49,137.4 185.12,137.4 185.06,137.47 184.25,137.47 184.04,137.26 183.44,137.26 183.24,137.46 183.24,137.69 183.13,137.8 CPU.AK38
  TOP w0.165: DIMM1.164 208.07,86.85 208.07,87.21 207.64,87.64 207.64,88.55 206.8,89.39 206.8,90.62 207.64,91.46 207.64,96.81 206.76,97.69 206.76,106.25 207.7,107.19 207.7,111.53 204.68,114.55 201.33,114.55 200.31,115.57 200.31,120.04 199.96,120.4 199.96,132.95 195.1,137.81 189.29,137.81
M_DQSA2: length 57.7
  TOP w0.089: CPU.AP38 183.54,133.81 185.06,133.81 185.13,133.74 185.48,133.74 185.85,134.1 186.35,134.1 188.03,132.42 188.03,130.85 187.98,130.8 187.98,130.78
  TOP w0.165: 187.98,130.78 187.98,127.46 189.39,126.05 189.39,106.72 199.33,96.78 199.33,92.32 199.16,92.15 199.16,91.38 198.29,90.52 198.29,89.57 199.16,88.7 199.16,87.46 199.11,87.42 198.95,87.33 198.72,87.4 DIMM1.175
M_DQSA3: length 48.9
  TOP w0.089: CPU.AV36 180.97,130.11 180.63,129.77 180.63,129.09 180.5,128.96 180.5,128.62 180.97,128.15 180.97,126.84 180.92,126.79 180.92,126.76
  TOP w0.165: 180.92,126.76 180.92,101.29 188.95,93.26 188.95,91.23 189.77,90.41 189.77,89.42 188.94,88.59 188.94,87.5 189.3,87.31 189.39,87 189.41,86.93 DIMM1.186
M_DQSA4: length 52.8
  TOP w0.089: 151.58,124.47 151.58,124.49 151.64,124.54 151.64,129.22 151.68,129.27 151.68,130.19 151.92,130.42 151.92,130.68 152.25,131.02 CPU.AV7
  TOP w0.165: 151.58,124.47 151.58,119.73 147.31,115.46 147.31,108.99 135.4,97.07 135.4,93.33 134.52,92.45 134.52,91.34 133.72,90.54 133.72,89.72 134.56,88.88 134.56,87.67 134.4,87.5 134.19,87.5 134.04,87.55 DIMM1.245
M_DQSA5: length 57.3
  TOP w0.089: 145.95,129.21 145.96,129.22 146,129.22 146.07,129.3 146.07,129.68 145.83,129.92 145.83,131.22 146.47,131.86 147.22,131.86 CPU.AU2
  TOP w0.165: DIMM1.256 124.77,86.85 124.73,87 124.7,87.07 124.46,87.2 124.34,87.32 124.34,88.55 125.17,89.38 125.17,90.52 124.37,91.32 124.37,95.39 135.48,106.5 135.48,114.93 145.54,124.99 145.54,128.8 145.95,129.21
M_DQSA6: length 68.5
  TOP w0.089: 142.65,133.95 142.7,133.9 143.48,133.9 145.32,135.74 145.58,135.74 145.7,135.86 145.7,136.24 145.84,136.38 146.27,136.38 146.33,136.31 147.02,136.31 147.17,136.16 147.17,135.92 147.48,135.62 147.97,135.62 148.21,135.86 148.21,136.06 148.14,136.13 147.83,136.13 CPU.AN2
  TOP w0.165: DIMM1.267 115.4,87.67 115.62,87.67 115.87,87.92 115.87,88.62 116.67,89.42 116.67,90.42 115.87,91.22 115.87,92.45 116.45,93.04 116.45,97.28 117.95,98.77 117.95,111.35 123.99,117.39 126.06,117.39 139.52,130.85 139.52,131.52 141.95,133.95 142.65,133.95
M_DQSA7: length 78
  TOP w0.089: CPU.AJ2 147.29,139.63 146.96,139.97 146.43,139.97 146.34,140.06 145.92,140.06 145.71,139.85 142.73,139.85 142.68,139.9 142.66,139.9
  TOP w0.165: 142.66,139.9 138.17,139.9 108.07,109.8 108.07,109.79 107.61,109.34 107.61,94.68 106.24,93.31 105.67,92.74 105.67,91.26 106.52,90.4 106.52,89.43 105.64,88.55 105.64,87.3 106.01,87.11 106.16,86.64 106.03,86.39 DIMM1.278
M_DQSA#0: length 83.1
  TOP w0.089: 189.29,143.96 189.26,143.96 189.21,143.91 188.71,143.91 186.7,141.89 185.05,141.89 184.96,141.8 184.36,141.8 184.03,141.46 CPU.AF39
  TOP w0.165: DIMM1.152 217.84,86.24 217.4,86.37 217.25,86.67 217.35,87 217.37,87.06 217.91,87.35 218.07,87.51 218.16,87.6 218.16,88.71 217.3,89.56 217.3,90.41 218.14,91.25 218.14,111.94 206.5,123.59 206.5,135.52 198.06,143.96 189.29,143.96
M_DQSA#1: length 73.3
  TOP w0.089: CPU.AK39 183.52,137.8 183.43,137.72 183.43,137.53 183.52,137.45 183.96,137.45 184.22,137.7 184.22,137.94 184.42,138.14 184.96,138.14 185.03,138.21 185.45,138.21 185.69,137.97 185.69,137.81 185.78,137.72 188.36,137.72 188.7,138.06 189.13,138.06 189.17,138.1 189.29,138.1
  TOP w0.165: 189.29,138.1 195.22,138.1 200.25,133.08 200.25,120.52 200.61,120.16 200.61,115.69 201.45,114.85 204.8,114.85 208,111.65 208,107.07 207.06,106.13 207.06,97.81 207.93,96.93 207.93,91.34 207.09,90.5 207.09,89.51 207.93,88.67 207.93,87.77 208.19,87.51 208.42,87.51 DIMM1.163
M_DQSA#2: length 57.7
  TOP w0.089: 188.27,130.78 188.27,130.81 188.22,130.86 188.22,132.5 186.43,134.29 185.73,134.29 185.45,134.57 185.05,134.57 184.96,134.48 184.44,134.48 184.1,134.15 CPU.AP39
  TOP w0.165: 188.27,130.78 188.27,127.58 189.68,126.17 189.68,106.84 199.63,96.9 199.63,92.2 199.45,92.02 199.45,91.26 198.58,90.4 198.58,89.69 199.45,88.82 199.45,87.34 199.29,87.18 199.01,87.03 198.98,87.01 198.97,87 198.89,86.73 199.07,86.39 DIMM1.174
M_DQSA#3: length 48.8
  TOP w0.089: CPU.AU36 181.31,130.68 181.31,128.58 181.16,128.44 181.16,126.84 181.21,126.79 181.21,126.76
  TOP w0.165: DIMM1.185 189.78,87.62 189.49,87.53 189.24,87.67 189.24,88.47 190.07,89.3 190.07,90.53 189.24,91.35 189.24,93.38 181.21,101.41 181.21,126.76
M_DQSA#4: length 52.7
  TOP w0.089: 151.88,124.47 151.88,124.49 151.83,124.54 151.83,129.14 151.87,129.19 151.87,130.11 CPU.AW7
  TOP w0.165: DIMM1.244 134.33,86.44 134.18,86.71 134.28,87.03 134.52,87.21 134.86,87.55 134.86,89 134.01,89.84 134.01,90.42 134.82,91.22 134.82,92.33 135.69,93.21 135.69,96.95 147.61,108.86 147.61,115.34 151.88,119.61 151.88,124.47
M_DQSA#5: length 57.2
  TOP w0.089: 146.15,129 146.19,129.03 146.19,129.12 146.19,129.13 146.19,129.15 146.26,129.22 146.26,129.76 146.02,130 146.02,130.26 146.11,130.35 146.42,130.35 147.18,131.11 147.18,131.55 147.61,131.98 147.87,131.98 CPU.AU3
  TOP w0.165: 146.15,129 145.83,128.68 145.83,124.87 135.77,114.81 135.77,106.38 124.66,95.27 124.66,91.44 125.47,90.64 125.47,89.26 124.64,88.43 124.64,87.44 124.64,87.44 124.84,87.33 125.06,87.4 DIMM1.255
M_DQSA#6: length 68.5
  TOP w0.089: CPU.AN3 148.05,135.43 147.4,135.43 147.18,135.64 146.37,135.64 146.28,135.55 145.4,135.55 143.56,133.71 142.72,133.71 142.67,133.66 142.65,133.66
  TOP w0.165: DIMM1.266 115.82,86.23 115.52,86.31 115.32,86.6 115.37,87 116.16,87.8 116.16,88.5 116.97,89.3 116.97,90.54 116.16,91.35 116.16,92.33 116.75,92.92 116.75,97.16 118.24,98.65 118.24,111.23 124.11,117.09 126.18,117.09 139.81,130.73 139.81,131.39 142.07,133.66 142.65,133.66
M_DQSA#7: length 78
  TOP w0.089: CPU.AJ3 147.89,139.29 147.5,139.29 147.41,139.38 147.04,139.38 146.96,139.3 146.37,139.3 146.3,139.23 145.92,139.23 145.49,139.66 142.73,139.66 142.68,139.61 142.66,139.61
  TOP w0.165: DIMM1.277 106.39,87.44 106.14,87.37 105.94,87.48 105.94,88.43 106.81,89.31 106.81,90.53 105.96,91.38 105.96,92.61 107.91,94.56 107.91,109.22 108.36,109.67 108.36,109.67 138.3,139.61 142.66,139.61
M_DQSB0: length 98
  TOP w0.089: v1(180.51,141.92) CPU.AF35
  L3_GND w0.089: 189.9,143.51 189.89,143.51 189.84,143.56 186.64,143.56 185.52,142.44 183.74,142.44 183.51,142.21 180.52,142.21 180.44,142.12 180.44,141.99 v1(180.51,141.92)
  L3_GND w0.14: DIMM2.153 216.85,78.62 216.85,78.1 217.08,77.88 217.49,77.88 217.86,78.25 217.86,79.57 218.75,80.45 218.75,81.48 217.9,82.33 217.9,83.42 218.75,84.27 218.75,86.68 218.45,86.98 217.9,87.53 217.9,88.38 218.67,89.15 218.67,90.56 217.9,91.33 217.9,92.55 216.47,93.98 216.47,95.03 216.27,95.23 215.94,95.23 215.58,95.59 215.58,96.1 215.94,96.47 216.27,96.47 216.47,96.66 216.47,108.91 217,109.45 217,109.75 216.47,110.29 216.47,111.28 217.03,111.83 217.03,112.11 216.47,112.67 216.47,113.66 217,114.19 217,114.5 216.47,115.03 216.47,116 205.32,127.15 205.32,133.91 195.71,143.51 189.9,143.51
M_DQSB1: length 86.4
  TOP w0.089: v1(177.77,137.35) CPU.AL33
  L3_GND w0.089: 188.62,137.31 188.5,137.31 188.46,137.36 185.71,137.36 185.54,137.19 185.03,137.19 184.83,137.39 183.19,137.39 182.56,136.75 179.34,136.75 178.47,137.63 178.33,137.63 178.18,137.78 177.9,137.78 177.77,137.65 v1(177.77,137.35)
  L3_GND w0.14: 188.62,137.31 193.25,137.31 198.61,131.95 198.61,122.66 209.35,111.91 209.35,91.32 208.47,90.43 208.47,89.5 209.31,88.65 209.31,87.54 208.55,86.77 208.55,85.93 209.31,85.17 209.31,82.27 208.55,81.51 208.55,80.41 207.61,79.47 207.61,78.46 208.04,78.03 208.13,77.73 207.93,77.36 DIMM2.164
M_DQSB2: length 76.1
  TOP w0.089: CPU.AP33 178.65,133.72 v1(178.68,133.72)
  L3_GND w0.089: 185,129.8 184.99,129.81 184.99,129.88 183.93,130.94 183.93,132.04 183.36,132.61 179.8,132.61 179.2,133.21 179.04,133.37 178.94,133.47 178.94,133.62 178.84,133.72 v1(178.68,133.72)
  L3_GND w0.14: DIMM2.175 198.15,78.63 198.15,78.33 198.46,78.03 198.9,78.03 199.2,78.33 199.2,79.85 198.33,80.72 198.33,81.66 199.11,82.44 199.11,83.32 199.63,83.83 199.63,84.49 198.35,85.77 198.35,86.72 199.2,87.57 199.2,88.36 198.35,89.21 198.35,90.52 199.2,91.37 199.2,91.99 196.86,94.34 196.86,97.42 196.67,97.61 196.2,97.61 195.84,97.96 195.84,98.46 196.2,98.81 196.44,98.81 196.63,99.01 196.63,99.27 196.44,99.47 196.14,99.47 195.79,99.82 195.79,100.32 196.14,100.67 196.67,100.67 196.86,100.86 196.86,101.55 191.65,106.76 191.65,107.78 191.46,107.97 190.99,107.97 190.63,108.32 190.63,108.83 190.99,109.18 191,109.18 191.14,109.32 191.14,122.2 187.99,125.35 186.72,125.35 185.4,126.67 185.4,127.46 185.73,127.78 186.06,127.78 186.23,127.95 186.23,128.18 186.06,128.34 185.73,128.34 185.4,128.67 185.4,129.4 185,129.8
M_DQSB3: length 71
  TOP w0.089: CPU.AN28 v1(173.23,135.52)
  L3_GND w0.089: v1(173.23,135.52) 173.58,135.17 173.58,134.97 174.59,133.95 174.59,133.54 175.01,133.13 175.01,129.96 177.16,127.81 177.16,127.51 177.12,127.47 177.12,127.44
  L3_GND w0.14: 177.12,127.44 177.12,126.28 177.17,126.23 181.82,121.58 181.82,120.38 182.29,119.91 183.03,119.91 183.22,119.72 183.22,119.22 182.91,118.91 182.91,99.66 183.56,99 183.56,98.73 183.31,98.48 183.31,97.98 183.66,97.62 184.16,97.62 184.42,97.88 184.69,97.88 184.88,97.69 184.88,97.42 184.61,97.15 184.61,96.65 184.97,96.29 185.47,96.29 185.74,96.56 186.01,96.56 188.99,93.58 188.99,91.17 189.76,90.4 189.76,89.85 188.99,89.08 188.99,87.54 189.76,86.77 189.76,85.73 189,84.97 189,82.33 189.76,81.56 189.76,80.84 188.91,79.99 188.91,78.46 189.56,77.81 189.59,77.6 189.48,77.44 DIMM2.186
M_DQSB4: length 72.4
  TOP w0.089: v1(158.57,135.52) CPU.AN12
  L3_GND w0.089: v1(158.57,135.52) 158.57,135.4 158.48,135.31 158.39,135.31 157.04,133.96 157.04,132.07 155.86,130.9 155.86,130 154.31,128.45 153.45,128.45 152.93,127.93 152.93,127.65 152.89,127.61 152.89,127.58
  L3_GND w0.14: DIMM2.245 133.59,78.66 133.59,78.36 133.84,78.1 134.21,78.1 134.6,78.5 134.6,79.31 135.45,80.16 135.45,81.48 134.6,82.33 134.6,83.11 135.45,83.96 135.45,86.88 136.21,87.65 136.21,88.97 135.45,89.73 135.45,90.52 136.21,91.28 136.21,92.07 138.36,94.22 138.86,94.22 139.05,94.03 139.31,94.03 139.51,94.22 139.51,94.49 139.32,94.68 139.32,95.18 139.73,95.59 139.73,99.71 152.46,112.43 152.46,126.57 152.89,127 152.89,127.58
M_DQSB5: length 76.7
  TOP w0.089: v1(152.71,134.6) CPU.AP8
  L3_GND w0.089: 145.09,130.43 145.11,130.44 145.17,130.44 145.47,130.75 145.47,131.16 145.99,131.68 146.5,131.68 147.84,133.01 151.73,133.01 152.23,133.51 152.23,133.83 152.52,134.12 153.02,134.12 153.11,134.21 153.11,134.43 152.94,134.6 v1(152.71,134.6)
  L3_GND w0.14: 145.09,130.43 142.68,128.02 142.68,111.39 133.56,102.27 133.56,98.52 132.98,97.93 132.43,97.93 132,97.5 132,96.88 131.74,96.62 131.12,96.62 130.69,96.19 130.69,95.57 130.42,95.3 129.8,95.3 129.37,94.87 129.37,94.25 128.87,93.75 127.04,93.75 126.1,92.81 126.1,91.53 125.25,90.68 125.25,89.73 126.01,88.97 126.01,87.48 125.25,86.72 125.25,85.93 126.01,85.17 126.01,82.44 125.16,81.59 125.16,80.84 124.31,79.99 124.31,78.46 124.74,78.03 124.77,77.84 DIMM2.256
M_DQSB6: length 85.4
  TOP w0.089: CPU.AL8 v1(153.62,138.26)
  L3_GND w0.089: v1(153.62,138.26) 153.44,138.07 153.14,138.07 152.01,136.94 145.61,136.94 144.73,136.06 144.29,136.06 144.25,136.1 144.23,136.1
  L3_GND w0.14: 144.23,136.1 142.13,136.1 135.33,129.3 135.33,127.39 125.72,117.78 123.82,117.78 118.4,112.35 118.4,93.74 117.6,92.94 117.6,91.37 116.75,90.52 116.75,89.73 117.51,88.97 117.51,87.48 116.75,86.72 116.75,85.73 115.9,84.88 115.9,82.27 116.75,81.42 116.75,80.93 115.9,80.08 115.9,78.53 115.74,78.37 115.5,78.24 115.22,78.32 115.06,78.63 DIMM2.267
M_DQSB7: length 97.8
  TOP w0.089: v1(151.79,141.92) CPU.AG7
  L3_GND w0.089: 144.23,142.23 144.25,142.23 144.29,142.19 145.52,142.19 145.76,141.95 146.39,141.95 146.89,142.45 149.51,142.45 149.62,142.34 151.05,142.34 v1(151.79,141.92)
  L3_GND w0.14: 144.23,142.23 139.65,142.23 110.42,113.01 110.42,96.23 110.96,95.69 110.96,95.42 110.77,95.23 110.5,95.23 109.96,95.76 109.46,95.76 109.11,95.41 109.11,94.91 109.68,94.34 109.68,94.07 109.49,93.88 109.22,93.88 108.65,94.45 108.15,94.45 107.4,93.7 107.4,91.33 108.25,90.48 108.25,89.22 107.4,88.37 107.4,87.59 106.46,86.66 106.46,83.87 105.7,83.11 105.7,82.33 106.46,81.56 106.46,80.31 105.61,79.46 105.61,78.41 105.88,78.14 106.01,77.72 DIMM2.278
M_DQSB#0: length 97.9
  TOP w0.089: v1(179.6,141.92) CPU.AF34
  L3_GND w0.089: v1(179.6,141.92) 180.4,142.4 183.43,142.4 183.66,142.63 185.44,142.63 186.56,143.75 189.81,143.75 189.85,143.79 189.9,143.79
  L3_GND w0.14: 189.9,143.79 195.83,143.79 205.6,134.02 205.6,127.27 216.75,116.12 216.75,115.15 217.28,114.62 217.28,114.08 216.75,113.55 216.75,112.79 217.3,112.23 217.3,111.72 216.75,111.16 216.75,110.4 217.28,109.87 217.28,109.33 216.75,108.8 216.75,96.55 216.38,96.19 216.05,96.19 215.86,95.99 215.86,95.71 216.05,95.51 216.38,95.51 216.75,95.15 216.75,94.1 218.18,92.66 218.18,91.45 218.95,90.67 218.95,89.03 218.18,88.26 218.18,87.65 218.57,87.26 219.03,86.8 219.03,84.16 218.18,83.31 218.18,82.44 219.03,81.59 219.03,80.34 218.14,79.45 218.14,78.13 217.99,77.98 DIMM2.152
M_DQSB#1: length 86.4
  TOP w0.089: CPU.AK33 v1(177.77,138.26)
  L3_GND w0.089: v1(177.77,138.26) 177.77,138.06 177.86,137.97 178.26,137.97 178.41,137.82 178.54,137.82 179.42,136.94 182.48,136.94 183.11,137.58 184.91,137.58 185.11,137.38 185.46,137.38 185.63,137.55 188.56,137.55 188.6,137.59 188.62,137.59
  L3_GND w0.14: DIMM2.163 208.35,78.36 208.16,78.31 207.89,78.58 207.89,79.36 208.83,80.3 208.83,81.39 209.59,82.16 209.59,85.28 208.83,86.05 208.83,86.66 209.59,87.42 209.59,88.77 208.74,89.61 208.74,90.32 209.63,91.21 209.63,112.03 198.89,122.77 198.89,132.07 193.37,137.59 188.62,137.59
M_DQSB#2: length 76.1
  TOP w0.089: v1(178.68,134.6) CPU.AN33
  L3_GND w0.089: 185.2,130 185.19,130.01 185.12,130.01 184.12,131.02 184.12,132.12 183.44,132.8 179.88,132.8 179.66,133.02 179.18,133.51 179.17,133.51 179.17,133.76 v1(178.68,134.6)
  L3_GND w0.14: DIMM2.174 199.29,78.03 199.48,78.21 199.48,79.97 198.61,80.84 198.61,81.55 199.39,82.33 199.39,83.2 199.91,83.72 199.91,84.61 198.63,85.89 198.63,86.6 199.48,87.45 199.48,88.48 198.63,89.33 198.63,90.4 199.48,91.25 199.48,92.11 197.14,94.45 197.14,97.53 196.78,97.89 196.31,97.89 196.12,98.08 196.12,98.34 196.31,98.54 196.55,98.54 196.91,98.89 196.91,99.39 196.55,99.74 196.26,99.74 196.07,99.94 196.07,100.2 196.26,100.39 196.78,100.39 197.14,100.75 197.14,101.67 191.93,106.87 191.93,107.9 191.58,108.25 191.1,108.25 190.91,108.44 190.91,108.71 191.1,108.9 191.12,108.9 191.42,109.2 191.42,122.32 188.11,125.63 186.84,125.63 185.68,126.78 185.68,127.34 185.85,127.51 186.18,127.51 186.51,127.83 186.51,128.3 186.18,128.62 185.85,128.62 185.68,128.79 185.68,129.52 185.2,130
M_DQSB#3: length 71
  TOP w0.089: CPU.AN29 v1(174.11,135.52)
  L3_GND w0.089: v1(174.11,135.52) 173.98,135.52 173.77,135.3 173.77,135.05 174.69,134.12 175.23,134.12 175.45,133.9 175.45,133.53 175.2,133.27 175.2,130.04 177.35,127.89 177.35,127.51 177.39,127.47 177.39,127.44
  L3_GND w0.14: 177.39,127.44 177.39,126.4 182.1,121.69 182.1,120.5 182.4,120.19 183.14,120.19 183.5,119.84 183.5,119.1 183.19,118.8 183.19,99.77 183.84,99.12 183.84,98.62 183.59,98.36 183.59,98.09 183.78,97.9 184.05,97.9 184.3,98.16 184.81,98.16 185.16,97.8 185.16,97.3 184.89,97.03 184.89,96.77 185.08,96.57 185.35,96.57 185.62,96.84 186.12,96.84 189.27,93.7 189.27,91.29 190.04,90.52 190.04,89.73 189.27,88.96 189.27,87.66 190.04,86.88 190.04,85.61 189.28,84.85 189.28,82.44 190.04,81.68 190.04,80.73 189.19,79.88 189.19,78.58 189.46,78.31 189.65,78.36 DIMM2.185
M_DQSB#4: length 72.4
  TOP w0.089: CPU.AN13 v1(159.48,135.52)
  L3_GND w0.089: 153.17,127.58 153.17,127.61 153.12,127.65 153.12,127.85 153.53,128.26 154.39,128.26 156.05,129.92 156.05,130.82 157.23,131.99 157.23,133.88 158.42,135.07 158.72,135.07 158.99,135.34 158.99,135.41 159.1,135.52 v1(159.48,135.52)
  L3_GND w0.14: DIMM2.244 134.69,78.2 134.88,78.38 134.88,79.19 135.73,80.04 135.73,81.59 134.88,82.44 134.88,82.99 135.73,83.84 135.73,86.77 136.49,87.53 136.49,89.08 135.73,89.85 135.73,90.4 136.49,91.16 136.49,91.96 138.47,93.94 138.74,93.94 138.93,93.75 139.43,93.75 139.79,94.11 139.79,94.61 139.6,94.8 139.6,95.07 140.01,95.48 140.01,99.59 152.74,112.32 152.74,126.45 153.17,126.88 153.17,127.58
M_DQSB#5: length 76.6
  TOP w0.089: v1(153.62,134.6) CPU.AR8
  L3_GND w0.089: 145.29,130.23 145.3,130.25 145.3,130.31 145.66,130.67 145.66,131.08 146.07,131.49 146.58,131.49 147.91,132.82 151.83,132.82 152.26,133.25 152.87,133.25 153.13,133.52 153.13,133.96 153.31,134.14 153.31,134.51 153.39,134.6 v1(153.62,134.6)
  L3_GND w0.14: DIMM2.255 125.44,78.61 125.37,78.49 125.29,78.33 125.15,78.29 124.88,78.29 124.59,78.58 124.59,79.88 125.44,80.73 125.44,81.48 126.29,82.33 126.29,85.28 125.53,86.05 125.53,86.6 126.29,87.36 126.29,89.08 125.53,89.85 125.53,90.57 126.38,91.42 126.38,92.69 127.16,93.47 128.99,93.47 129.65,94.13 129.65,94.75 129.92,95.02 130.54,95.02 130.97,95.45 130.97,96.07 131.23,96.34 131.85,96.34 132.28,96.77 132.28,97.39 132.55,97.65 133.09,97.65 133.84,98.4 133.84,102.16 142.96,111.28 142.96,127.9 145.29,130.23
M_DQSB#6: length 85.3
  TOP w0.089: v1(153.62,137.35) CPU.AM8
  L3_GND w0.089: 144.23,135.82 144.25,135.82 144.29,135.87 144.81,135.87 145.69,136.75 152.09,136.75 153.22,137.88 153.42,137.88 153.62,137.68 v1(153.62,137.35)
  L3_GND w0.14: 144.23,135.82 142.25,135.82 135.61,129.19 135.61,127.27 125.84,117.5 123.94,117.5 118.68,112.24 118.68,93.62 117.88,92.83 117.88,91.25 117.03,90.4 117.03,89.85 117.79,89.08 117.79,87.36 117.03,86.6 117.03,85.62 116.18,84.77 116.18,82.39 117.03,81.54 117.03,80.81 116.18,79.96 116.18,78.41 115.91,78.14 115.76,78.06 115.7,77.87 DIMM2.266
M_DQSB#7: length 97.8
  TOP w0.089: v1(150.88,141.92) 151.06,141.59 151.15,141.55 CPU.AG6
  L3_GND w0.089: 144.23,141.95 144.25,141.95 144.29,142 145.44,142 145.68,141.76 146.46,141.76 146.97,142.26 149.43,142.26 149.54,142.16 149.54,141.56 149.62,141.48 150.31,141.48 150.41,141.58 150.41,142.07 150.5,142.15 150.75,142.15 150.88,142.03 v1(150.88,141.92)
  L3_GND w0.14: 144.23,141.95 139.77,141.95 110.7,112.89 110.7,96.34 111.24,95.81 111.24,95.31 110.88,94.95 110.38,94.95 109.85,95.49 109.58,95.49 109.39,95.29 109.39,95.03 109.96,94.45 109.96,93.95 109.61,93.6 109.11,93.6 108.53,94.17 108.26,94.17 107.68,93.58 107.68,91.45 108.53,90.6 108.53,89.1 107.68,88.25 107.68,87.48 106.74,86.54 106.74,83.76 105.98,82.99 105.98,82.44 106.74,81.68 106.74,80.19 105.89,79.34 105.89,78.53 106.05,78.36 106.29,78.24 106.64,78.35 106.75,78.56 DIMM2.277
MIC2-VREFO: length 18
  TOP w0.203: UA1.29 184.98,19.99 184.88,19.89
  TOP w0.254: v1(176.94,23.19) 176.82,23.07 RA73.1 ; v1(176.15,27.43) 175.84,27.43 175.23,26.81 RA72.1 ; 184.88,19.89 184.56,19.57 v1(184.56,19.26)
  BOTTOM w0.254: v1(176.15,27.43) 176.15,26.79 176.94,25.99 v1(176.94,23.19) 176.94,22.99 177.45,22.48 178.09,22.48 180.02,20.55 180.97,20.55 181.76,19.77 184.05,19.77 v1(184.56,19.26)
MSCLK: length 316.1
  TOP w0.102: v1(158.78,224.16) 158.78,225.96 157.59,227.15 157.59,228.4 157.01,228.98 156.24,228.98 154.77,230.45 154.77,232.08 152.93,233.92 152.93,235.6 L14.1 152.76,236.69 RN5.1 ; v1(216.57,46.35) 216.57,46.74 216.06,47.24 214.24,47.24 212.2,45.2 211.4,45.2 209.9,43.69 SIO_5553.115
  BOTTOM w0.102: v1(158.78,224.16) 158.78,224.47 161.39,227.08 166.98,227.08 167.86,227.97 173.07,227.97 174.09,226.95 177.87,226.95 178.73,226.09 179.51,226.09 182.13,228.71 182.13,234.55 185.17,237.59 190.16,237.59 192.55,235.2 205.25,235.2 205.64,235.58 211.78,235.58 213.52,233.85 224.21,233.85 226.31,231.75 226.31,225.23 228.21,223.32 228.21,222.1 240.77,209.54 240.77,138.26 240.01,137.49 240.01,117.47 236.96,114.42 236.96,112.56 226.42,102.02 226.42,95.62 231.73,90.31 231.73,77.34 230.97,76.58 230.97,75.16 230.7,74.88 230.7,65.09 227.13,61.53 227.13,54.46 227.48,54.11 227.48,53.13 223.59,49.24 222.95,49.24 219.81,46.1 217.46,46.1 217.2,46.35 v1(216.57,46.35)
MSDATA: length 313.6
  TOP w0.102: RN5.2 153.56,236.25 L16.1 154.21,235.59 154.21,232.96 155,232.18 155,230.54 156.33,229.21 157.1,229.21 157.82,228.49 157.82,227.25 158.56,226.5 159.42,225.65 v1(159.42,224.41) ; SIO_5553.116 209.82,43.29 211.48,44.96 212.56,44.96 214.34,46.74 215.43,46.74 v1(215.55,46.61)
  BOTTOM w0.102: v1(215.55,46.61) 215.81,46.86 217.2,46.86 217.74,46.33 219.72,46.33 222.86,49.47 223.5,49.47 227.23,53.2 227.23,53.98 226.61,54.6 226.61,61.33 230.47,65.18 230.47,74.98 230.75,75.26 230.75,76.67 231.5,77.43 231.5,90.22 226.19,95.52 226.19,102.12 236.73,112.66 236.73,114.51 239.78,117.56 239.78,137.59 240.55,138.35 240.55,209.44 227.99,222 227.99,223.23 226.05,225.16 226.05,231.68 224.14,233.59 213.41,233.59 211.67,235.33 205.74,235.33 205.36,234.95 192.45,234.95 190.06,237.34 185.28,237.34 182.39,234.45 182.39,228.6 179.61,225.83 178.62,225.83 177.76,226.69 173.98,226.69 172.96,227.71 167.97,227.71 167.08,226.82 161.58,226.82 159.42,224.66 v1(159.42,224.41)
NIC_USB2_N4: length 150.7
  TOP w0.089: U4.AE1 56.38,135.27 56.44,135.33 56.44,136.3 56.77,136.64 57.79,136.64 58.29,137.14 58.29,137.54 58.28,137.55 58.28,137.57
  TOP w0.102: v1(95.67,244.35) 95.67,244.3 95.91,244.05 96.27,244.05 LU2.3 96.6,244.37 RU120.2 ; 58.28,137.57 58.28,143.56 58.66,143.93 58.66,145.21 58.28,145.59 58.28,147.56 58.52,147.8 58.94,147.8 59.12,147.98 v1(59.12,148.26)
  BOTTOM w0.102: 87.89,244.35 v2(87.94,244.3) ; 87.89,244.35 87.44,244.35 86.41,243.32 86.41,242.84 84.54,240.97 77.45,240.97 68.46,231.98 68.46,228.19 67.6,227.32 67.6,222.21 69.68,220.12 69.68,203.28 71.38,201.58 71.38,179.29 61.43,169.34 61.43,164.75 59.7,163.02 59.7,149.83 59.34,149.48 58.69,149.48 58.25,149.04 58.25,148.37 58.79,147.83 59.02,147.83 59.12,147.93 v1(59.12,148.26) ; 87.89,244.35 87.89,244.8 88.85,245.75 89.39,245.75 89.73,246.09 89.73,246.63 90.67,247.57 94.14,247.57 94.81,248.24 95.88,248.24 96.6,247.52 96.6,244.41 96.09,243.89 95.69,243.89 95.54,244.04 95.54,244.23 v1(95.67,244.35)
NIC_USB2_N5: length 141.6
  TOP w0.089: U4.AC2 57.41,134.72 57.73,135.05 57.73,135.63 59.16,137.06 59.16,137.48 59.17,137.48 59.17,137.57
  TOP w0.102: v1(95.66,246.12) 95.94,246.41 96.29,246.41 LU1.4 96.6,246.1 RU3.2 ; 59.17,137.57 59.17,143.17 59.62,143.62 59.62,144.5 60.04,144.92 60.04,146.15 59.91,146.27 59.91,146.54 60.06,146.69 60.24,146.69 60.38,146.54 v1(60.38,146.48)
  BOTTOM w0.102: v1(95.66,246.12) 95.66,246.33 95.51,246.48 93.61,246.48 v2(91.73,244.61) 90.37,243.24 90.37,242.71 90.03,242.36 89.49,242.36 89.24,242.11 86.68,242.11 84.83,240.26 77.81,240.26 69.17,231.62 69.17,227.35 68.36,226.53 68.36,222.49 70.37,220.48 70.37,203.6 72.09,201.87 72.09,177.57 71.08,176.56 69.62,176.56 62.2,169.14 62.2,164.45 60.38,162.64 60.38,149.33 59.97,148.92 59.97,146.64 60.14,146.48 v1(60.38,146.48)
NIC_USB2_P4: length 150.7
  TOP w0.089: 58.48,137.57 58.48,137.55 58.48,137.54 58.48,137.06 57.87,136.45 56.85,136.45 56.63,136.22 56.63,135.13 U4.AE2
  TOP w0.102: 58.48,137.57 58.48,143.47 58.86,143.85 58.86,145.3 58.48,145.68 58.48,147.47 58.61,147.6 59,147.6 59.03,147.57 59.04,147.57 59.14,147.47 v1(59.14,147.37) ; RU5.2 96.6,243.56 LU2.4 96.3,243.85 96.06,243.85 v1(95.66,243.46)
  BOTTOM w0.102: v1(95.66,243.46) 95.89,243.69 96.17,243.69 96.81,244.32 96.81,247.6 95.96,248.45 94.73,248.45 94.06,247.78 90.58,247.78 v2(89.14,246.34) 86.21,243.4 86.21,242.93 84.45,241.17 77.37,241.17 68.26,232.06 68.26,228.27 67.39,227.41 67.39,222.12 69.48,220.04 69.48,203.19 71.18,201.49 71.18,179.38 61.22,169.42 61.22,164.83 59.49,163.1 59.49,149.92 59.26,149.68 58.61,149.68 58.05,149.13 58.05,148.28 58.71,147.62 58.88,147.62 v1(59.14,147.37)
NIC_USB2_P5: length 141.6
  TOP w0.089: 58.97,137.57 58.97,137.55 58.97,137.55 58.97,137.14 57.54,135.7 57.54,135.13 57.39,134.98 57.3,134.98 57.17,134.85 57.17,134.42 U4.AC3
  TOP w0.102: RU4.2 96.6,246.91 LU1.3 96.29,246.61 95.94,246.61 v1(95.66,246.89) ; 58.97,137.57 58.97,143.25 59.42,143.71 59.42,144.58 59.84,145 59.84,146.06 v1(59.48,146.42)
  BOTTOM w0.102: v1(59.48,146.42) 59.77,146.71 59.77,149 60.18,149.41 60.18,162.72 61.99,164.54 61.99,169.22 69.53,176.76 70.99,176.76 71.89,177.66 71.89,201.79 70.16,203.51 70.16,220.4 68.16,222.4 68.16,226.62 68.97,227.43 68.97,231.71 77.72,240.46 84.74,240.46 86.6,242.32 89.15,242.32 v2(89.78,242.95) 91.15,244.31 91.15,244.85 91.49,245.19 92.03,245.19 93.52,246.68 95.46,246.68 v1(95.66,246.89)
O_+12VCOM: length 0.9
  BOTTOM w0.102: v1(180.56,233.28) 180.56,234.03 v2(180.64,234.12)
O_-12VCOM: length 0.9
  BOTTOM w0.102: v2(182.16,224.05) 181.86,224.05 v1(181.44,223.62)
O_A20GATE: length 6.3
  TOP w0.102: R495.2 206.83,43.54 207.47,43.54 207.86,43.15 207.86,42.6 208.36,42.09 SIO_5553.119 209.87,42.09 211.21,43.43 v1(211.21,43.54)
O_AUD_PCSPKR_DET#: length 318.8
  TOP w0.089: U4.AJ33 53.93,119.76 v1(53.75,119.76) ; 50.07,111.25 v1(50.07,112.01)
  TOP w0.102: INT_SPKR.3 162.4,53.15 CA111.1 162.4,49.09 162.21,48.9 162.21,44.63 161.2,43.61 161.2,31.75 v1(161.58,31.37) ; 50.07,111.25 50.07,111.19 RU174.2 ; v1(47.59,79.36) 47.15,78.92 44.76,78.92 44.61,78.77 40.38,78.77 35.78,74.17 33.57,74.17 32.68,73.28 20.61,73.28 16.5,69.16 v1(16.14,69.16)
  BOTTOM w0.089: 49.56,111.25 49.56,111.51 v1(50.07,112.01) 50.52,112.46 50.69,112.63 50.69,115.93 51.11,116.36 51.11,117.42 51.87,118.19 51.87,118.44 53.2,119.76 v1(53.75,119.76)
  BOTTOM w0.102: v1(16.14,69.16) 16.16,69.14 16.16,58.04 14.77,56.64 11.21,56.64 9.91,55.35 9.91,43.97 11.44,42.44 11.44,39.12 10.88,38.56 10.88,33.05 12.33,31.6 19.57,31.6 20.48,32.51 22.13,32.51 22.92,33.3 36.72,33.3 39.92,30.1 47.1,30.1 49.26,27.94 67.47,27.94 77.12,37.59 83.47,37.59 94.52,26.54 126.02,26.54 128.3,24.26 157.51,24.26 161.58,28.32 v1(161.58,31.37) ; 49.56,111.25 49.56,108.71 49.06,108.2 49.06,106.93 48.39,106.27 48.39,104.93 45.32,101.85 45.32,97.46 45.8,96.98 45.8,95.58 45.52,95.3 45.52,88.29 47.45,86.37 47.45,84.77 46.71,84.03 46.71,82.58 46.11,81.98 46.11,81.09 46.71,80.5 46.94,80.5 47.39,80.05 47.39,79.56 v1(47.59,79.36)
O_AUD_PCSPKR_DET#_SIO: length 10.2
  TOP w0.102: v1(232.49,50.44) 231.39,50.44 RO117.2 RO32.2 229.9,48.64 228.36,47.09 225.24,47.09 225.04,46.89 SIO_5553.54
O_CHAFAN_PWM: length 217.3
  TOP w0.102: v1(218.22,46.99) 218.22,46.28 220,44.49 SIO_5553.48 ; RF11.1 221.27,230.95 v1(221.27,231.34) 220.62,231.34 RF5.2
  BOTTOM w0.102: v1(218.22,46.99) 218.22,47.37 218.92,48.07 219.45,48.07 225.75,54.37 225.75,62.97 228.8,66.02 228.8,78.12 228.6,78.32 228.6,81.36 229.16,81.91 230,81.91 230.64,82.55 230.64,85.59 228.6,87.63 228.6,91.9 225.31,95.19 225.31,102.45 235.87,113.02 235.87,116.2 237.14,117.47 237.14,128.52 237.27,128.65 237.27,131.7 236.53,132.44 236.53,135.56 v2(236.63,135.66) 239.68,138.71 239.68,209.02 227.12,221.58 227.12,222.82 225.1,224.84 225.1,229.58 223.34,231.34 v1(221.27,231.34)
O_CPUFAN_PWM: length 107.6
  TOP w0.102: SIO_5553.47 224.98,44.09 225.84,44.96 228.38,44.96 v1(228.89,44.45) ; v1(232.57,130.43) 232.44,130.43 232.21,130.66 232.21,132.74 232.57,133.1 RNF2.8 ; v1(229.78,109.73) 229.14,109.09 229.14,106.03 225.55,102.44 225.55,95.15 230.04,90.66 230.22,90.66 232.66,88.22 232.66,86.52 v1(232.95,86.23) ; v1(235.24,122.94) 234.98,122.68 234.98,121.55
  BOTTOM w0.102: v1(228.89,44.45) v2(229.52,45.09) 230.31,45.09 230.94,45.72 230.94,48.54 230.64,48.85 230.64,50.44 229.79,51.29 229.79,61.37 232.41,63.99 232.41,65.94 232.01,66.34 232.01,74.74 232.82,75.56 232.82,86.11 v1(232.95,86.23) ; v1(229.78,109.73) 234.12,114.07 234.12,119.48 234.6,119.96 234.6,122.25 235.24,122.88 v1(235.24,122.94) 235.34,123.04 235.34,126.84 232.57,129.61 v1(232.57,130.43)
O_CPUFAN_PWM_R: length 20.6
  TOP w0.102: RF6.1 237.33,137.22 v1(237.78,137.67) 239.3,137.67 240.09,136.88 240.09,124.63 U122.3
O_CTS1#: length 14.8
  TOP w0.102: UO2.3 179.37,231.38 v1(179.1,231.65) 178.7,232.05 CNO1.4
  BOTTOM w0.102: VGA_COM.A8 182.76,241.14 182.66,241.05 182.66,238.36 179.54,235.24 179.54,232.08 v1(179.1,231.65)
O_CTS1#_R: length 248.9
  TOP w0.102: v1(190.03,228.47) 190.28,228.73 190.28,230.12 189.02,231.38 UO2.18 ; SIO_5553.101 211.36,49.29 211.57,49.09 218.03,49.09 v1(218.47,48.64)
  BOTTOM w0.102: v1(218.47,48.64) 218.47,51.39 219.15,52.07 220.05,52.07 221.62,53.65 221.62,53.87 222.78,55.03 223.33,55.03 224.43,56.12 224.43,63.52 227.48,66.57 227.48,69.72 225.94,71.26 225.94,76.32 226.51,76.9 226.51,86.44 226.93,86.86 226.93,91.68 223.98,94.62 223.98,103.02 228.35,107.38 228.35,110.33 232.75,114.73 232.75,126.47 230.64,128.57 230.64,134.94 232.43,136.73 234.33,136.73 238.13,140.53 238.13,208.32 224.85,221.6 224.85,222.8 220.78,226.87 220.78,228.3 219.88,229.21 195.33,229.21 194.6,228.47 191.42,228.47 v2(191.04,228.85) 190.66,228.47 v1(190.03,228.47)
O_DCD1#: length 22
  TOP w0.102: CNO2.8 179.03,226.64 v1(179.1,226.57) 180.02,227.48 UO2.9
  BOTTOM w0.102: v1(179.1,226.57) 181.9,229.37 181.9,234.7 185.33,238.12 188.68,238.12 VGA_COM.A1
O_DCD1#_R: length 249.7
  TOP w0.102: v1(220.56,50.42) 220.53,50.39 219.87,50.39 219.74,50.27 212.71,50.27 211.85,51.12 210.77,51.12 210.49,51.39 SIO_5553.96 ; v1(189.26,226.82) 189.01,226.82 188.35,227.48 UO2.12
  BOTTOM w0.102: v1(220.56,50.42) 220.9,50.42 225.12,54.63 225.12,63.23 228.16,66.28 228.16,77.79 227.97,77.99 227.97,81.62 228.89,82.54 228.89,86.12 227.97,87.04 227.97,91.61 224.67,94.91 224.67,102.73 229.04,107.1 229.04,110.05 233.43,114.44 233.43,126.9 231.38,128.96 231.38,134.71 232.71,136.04 234.62,136.04 238.82,140.25 238.82,208.66 226.26,221.22 226.26,222.36 221.47,227.15 221.47,228.59 220.11,229.95 189.54,229.95 188.5,228.9 v2(188.5,228.05) 188.5,227.33 189.01,226.82 v1(189.26,226.82)
