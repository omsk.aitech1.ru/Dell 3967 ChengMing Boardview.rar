# Allegro board Phoenix-A00-Layout-20161019.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB3_TXDP2: length 161.9
  TOP w0.089: U4.A12 68.12,130.16 68.23,130.27 69.12,130.27 69.51,130.66 71.12,130.66 71.13,130.66 71.15,130.66
  TOP w0.102: 71.15,130.66 71.5,130.66 72.38,129.78 72.94,129.78 73.8,128.92 73.8,124.95 75.78,122.98 75.78,121.23 76.51,120.5 76.51,119.48 77.22,118.77 77.22,117.5 75.52,115.8 75.52,109.17 72.4,106.05 72.4,96.93 73.36,95.96 73.36,92.99 75.14,91.21 75.14,85.33 79.26,81.22 79.26,64.09 91.2,52.15 119.46,52.15 139.94,31.66 139.94,25.75 v1(139.61,25.43) 139.94,25.1 139.94,24.79 140.17,24.56 140.17,23.94 139.94,23.71 139.94,23.25 140.04,23.15 140.04,22.94 139.88,22.78 CO46.2
USB3_TXDP3: length 163.9
  TOP w0.089: v3(69.69,130.2) 69.78,130.2 69.93,130.05 69.93,129.81 69.81,129.68 68.93,129.68 68.79,129.82 67.11,129.82 66.81,129.52 U4.D13
  TOP w0.102: v3(95.99,157.44) 95.99,157.19 95.75,156.96 95.6,156.96 95.31,157.25 95.31,157.47 96.93,159.09 96.93,161.04 93.73,164.24 93.73,206.65 101.36,214.27 123.07,214.27 129.47,220.68 129.47,229.71 131.92,232.16 136.62,232.16 138.26,233.8 138.26,234.77 138.37,234.89 CO25.1
  BOTTOM w0.102: v3(95.99,157.44) 95.67,157.12 95.21,157.12 95.05,157.28 93.9,157.28 93.22,156.59 91.5,156.59 89.67,154.76 88.26,154.76 86.13,152.63 84.86,152.63 83.15,150.93 80.35,150.93 79.7,150.28 79.16,150.28 78.11,149.22 78.11,148.68 v2(77.73,148.3) 74.23,144.81 74.23,139.2 72.73,137.7 72.73,131.78 71.78,130.84 70.31,130.84 70.09,130.61 70.09,130.38 69.91,130.2 v3(69.69,130.2)
USB3_TXDP4: length 161.7
  TOP w0.089: v3(69.87,129.03) 70.04,129.03 70.19,128.88 70.19,128.66 70.05,128.52 68.8,128.52 68.61,128.71 68.61,129.07 68.41,129.27 67.86,129.27 U4.B13
  TOP w0.102: CO27.1 136.23,234.48 136.23,233.38 135.77,232.92 131.61,232.92 128.76,230.07 128.76,220.94 122.83,215.01 101.12,215.01 93.05,206.94 93.05,163.96 96.2,160.81 96.2,159.32 94.52,157.65 94.52,156.39 94.73,156.18 94.99,156.18 v3(95.13,156.33)
  BOTTOM w0.089: v3(69.87,129.03) 69.88,129.03
  BOTTOM w0.102: v3(95.13,156.33) 94.77,156.33 94.63,156.46 94.09,156.46 93.53,155.91 91.78,155.91 89.95,154.08 88.55,154.08 86.42,151.94 85.14,151.94 83.44,150.24 81.21,150.24 77.94,146.97 77.4,146.97 76.24,145.81 76.24,145.27 v2(75.86,144.89) 74.91,143.94 74.91,138.9 73.41,137.4 73.41,131.5 71.61,129.69 70.46,129.69 70.24,129.47 70.24,129.23 70.04,129.03 69.88,129.03
USB_N9G_R: length 9.6
  TOP w0.102: UR57.2 162.14,22.39 UL19.1 162.29,22.22 162.29,21.56 161.8,21.07 161.8,20.12 161.33,19.65 161.33,19.23 161.62,18.93 UU4.6 163.12,18.36 163.12,18.11 164.47,16.76 164.47,16.23 164.19,15.95 F_USB2.2
USB_N10G_R: length 18.8
  TOP w0.102: UR13.2 165.49,22.39 UL5.2 165.49,22.27 165.19,21.97 165.19,21.79 166.32,20.65 166.32,19.61 165.65,18.93 UU4.1 164.75,18.6 164.75,18.24 164.96,18.03 165.18,18.03 166.85,16.37 166.85,15.43 166.01,14.59 163.83,14.59 162.9,13.66 162.9,12.93 163.38,12.45 164.25,12.45 164.77,12.97 164.77,13.19 164.63,13.33 F_USB2.6
USB_P9G_R: length 9.6
  TOP w0.102: F_USB2.3 165.5,15.7 165.01,15.7 164.67,16.03 164.67,16.85 163.36,18.16 163.36,20.47 163.02,20.81 UU4.4 162.26,21.09 162.26,21.24 162.5,21.47 162.5,22.05 162.82,22.37 UL19.2 162.95,22.39 UR58.2
USB_P10G_R: length 18.9
  TOP w0.102: F_USB2.7 165.23,13.33 164.97,13.07 164.97,12.88 164.34,12.25 163.29,12.25 162.7,12.85 162.7,13.75 163.74,14.79 165.93,14.79 166.65,15.51 166.65,16.28 165.1,17.83 164.87,17.83 164.09,18.61 164.09,20.21 164.7,20.81 UU4.3 165.39,21.12 165.39,21.3 164.98,21.7 164.98,21.97 164.68,22.27 UL5.1 164.68,22.39 UR14.2
USBPWR0_F_50: length 8.6
  TOP w0.102: 131.19,18.95 v1(131.3,18.85)
  TOP w0.406: UU9.5 151.38,20.81 v1(151.84,21.27)
  TOP w0.889: ECU6.1 130.3,19.93 ; ECU6.1 v1(132.31,19.93) ; ECU6.1 131.19,18.95 ; ECU6.1 131.19,20.82 ; ECU7.1 131.12,27.69 ; ECU7.1 130.23,26.8 ; ECU7.1 131.12,25.91 ; ECU7.1 132.01,26.8
  vias: v1(129.95,26.8) v1(130.15,19.99) v1(131.1,27.94) v1(131.02,25.68) v1(131.22,21.04) v1(132.24,26.8) v1(138.08,19.81)
USBPWR1_F_50: length 11.2
  TOP w0.381: CU2.1 143.92,247.42 v1(143.2,246.7)
  TOP w0.406: v1(135.01,239.85) 134.55,239.39 UU3.5
  TOP w0.508: 136.15,230.76 ECU2.1 137.04,229.87
  TOP w0.889: 140.34,236.85 ECU3.1 ; ECU3.1 141.23,235.97 ; ECU3.1 141.23,237.74 ; ECU3.1 142.12,236.85
  BOTTOM w0.889: 140.34,236.85 ECU3.1 ; ECU3.1 141.23,235.97 ; ECU3.1 141.23,237.74 ; ECU3.1 142.12,236.85
  vias: v1(132.49,229.44) v1(135.8,231.27) v1(135.8,230.5) v1(135.8,229.74) v1(140.72,238.91) v1(140.83,241.55) v1(141.84,241.55) v1(141.84,238.91) v1(143.47,244.6) v1(143.47,243.38)
USBPWR4_F_50: length 8.2
  TOP w0.406: v1(161.76,19.42) 162.22,19.87 UU4.5
  TOP w0.889: ECU10.1 155.04,21.99 ; ECU10.1 154.16,21.1 ; ECU10.1 155.04,20.21 ; ECU10.1 155.93,21.1
  BOTTOM w0.406: F_USB2.1 161.25,18.91 v1(161.76,19.42)
  vias: v1(153.96,21.72) v1(153.96,20.32) v1(155.86,21.97) v1(155.86,20.19)
USBPWR5_F_50: length 9.4
  TOP w0.508: UU13.5 46.39,77.38 v1(45.92,77.85)
  TOP w0.889: ECU9.1 57.97,70.82 ; ECU9.1 57.08,69.93 ; ECU9.1 58.85,69.93
  BOTTOM w0.508: v1(45.92,77.85) 47.58,76.19 47.58,74.18 v1(48.55,73.21)
V_BLUE_R: length 29.6
  TOP w0.254: VGA_COM.B3 182.1,243.59 171.48,243.59 169.2,241.3 169.2,236.14 CG8.1 169.15,236.08 LG1.2 167.67,234.6 167.67,232.03 168.69,231.01 DG2.3
V_GPI_VGA_CBL_DET#: length 332.6
  TOP w0.089: U4.BB33 47.89,119.31 47.09,118.51 46.15,118.51 v1(46.01,118.37)
  TOP w0.102: v1(25.05,111.23) 25.15,111.33 25.15,114.3 21.75,117.7 v1(21.75,118.24) ; v1(170.11,223.88) 171.81,223.88 173.59,222.1 184.96,222.1 187.75,224.89 190.63,224.89 191.93,226.19 191.93,232.02 RG23.2 ; v1(65.79,170) 63.2,172.59 58.5,172.59 55.13,169.21 52,169.21 51.01,168.22 49.89,168.22 48.17,166.5 45.93,166.5 43.9,164.47 41.56,164.47 38.11,161.02 37.5,161.02 v1(37.12,160.63)
  BOTTOM w0.089: v1(46.01,118.37) 45.89,118.25 45.21,118.25 44.55,117.59 43.99,117.59 43.68,117.28
  BOTTOM w0.102: 43.68,117.28 43.57,117.17 42.22,117.17 42.19,117.2 40.66,117.2 40.39,116.94 38.18,116.94 36.85,115.62 35.49,115.62 34.55,114.68 33.53,114.68 31.36,112.5 28.63,112.5 27.35,111.23 v1(25.05,111.23) ; v1(37.12,160.63) 36.69,160.2 36.69,158.67 31.35,153.34 31.35,148.21 29.37,146.23 29.37,143.31 22.49,136.43 22.49,134.19 22.27,133.97 22.27,132.2 21.72,131.66 21.72,123.06 21.9,122.88 21.9,118.77 21.75,118.62 v1(21.75,118.24) ; v1(170.11,223.88) 168.54,225.45 162.65,225.45 159.19,221.99 156.53,221.99 153.25,218.7 147.67,218.7 146.97,219.41 146.97,219.84 146.34,220.47 145.7,220.47 145.07,221.11 139.53,221.11 138.46,222.17 128.61,222.17 126.53,220.09 v1(123.81,220.09) 117.4,220.09 116.74,219.43 113.51,219.43 110.59,222.35 108.97,222.35 108.41,222.91 107.09,222.91 105.9,224.1 99.44,224.1 94.15,229.4 94.15,235.58 92.85,236.87 84.63,236.87 83.27,235.51 79.93,235.51 78.94,236.49 77.5,236.49 76.51,235.51 76.51,232.15 75.5,231.14 75.5,228.13 74.26,226.89 74.26,221.01 72.93,219.68 72.93,204.34 74.1,203.17 74.1,176.56 72.09,174.55 70.47,174.55 65.92,170 v1(65.79,170)
V_GREEN_R: length 28.2
  TOP w0.254: VGA_COM.B2 180.57,244.35 171.17,244.35 168.44,241.62 168.44,237.73 166.8,236.09 CG10.1 166.35,236.08 LG2.2 165.18,234.91 165.18,232.25 DG3.3
V_HDMI_CLK_DN: length 10.2
  TOP w0.102: HDMI.12 216.75,251.13 216.65,251.03 216.65,250.75 215.94,250.04 215.94,249.25 216.62,248.56 216.62,247.64 215.36,246.38 215.36,245.68 215.59,245.45 RV74.1 215.38,244.93 215.38,243.81 CV39.2
V_HDMI_CLK_DP: length 10.2
  TOP w0.102: HDMI.10 216.34,251.13 216.44,251.03 216.44,250.84 215.73,250.12 215.73,249.17 216.42,248.48 216.42,247.73 215.16,246.47 215.16,245.73 214.88,245.45 RV73.1 215.17,244.91 215.17,243.84 CV38.2
V_HDMI_SCL: length 7.5
  TOP w0.102: HDMI.15 218.79,247.96 220.73,246.03 UV7.10 UV7.1 220.73,242.79 RV76.2 C558.1
V_HDMI_SDA: length 10.8
  TOP w0.102: CV42.1 221.96,242.51 221.92,242.46 221.55,242.46 RV85.2 221.23,242.79 UV7.2 UV7.9 221.23,246.37 219.57,248.03 219.57,248.67 218.79,249.44 HDMI.16
V_HDMI_TX0_DN: length 8.2
  TOP w0.102: HDMI.9 215.25,248.13 215.15,248.03 215.15,247.23 214.09,246.18 212.61,246.18 212.31,245.88 212.31,245.56 212.42,245.45 RV72.1 212.3,244.91 212.3,243.84 CV37.2
V_HDMI_TX0_DP: length 8.2
  TOP w0.102: CV36.2 212.1,243.82 212.1,244.93 RV49.1 212.01,245.45 212.11,245.56 212.11,245.97 212.52,246.38 214.01,246.38 214.94,247.32 214.94,248.03 214.84,248.13 HDMI.7
V_HDMI_TX1_DN: length 13.2
  TOP w0.102: HDMI.6 213.75,251.13 213.65,251.03 213.65,250.8 214.41,250.04 214.41,249.2 213.6,248.39 213.6,247.35 213.09,246.84 212.3,246.84 212.02,246.56 209.73,246.56 209.3,246.13 209.3,245.82 209.7,245.43 RV48.2 209.3,244.89 209.3,243.79 CV35.2
V_HDMI_TX1_DP: length 13.2
  TOP w0.102: CV34.2 209.1,243.87 209.1,244.89 RV45.2 208.71,245.43 209.1,245.82 209.1,246.21 209.65,246.76 211.94,246.76 212.22,247.04 213.01,247.04 213.4,247.43 213.4,248.47 214.21,249.28 214.21,249.95 213.44,250.72 213.44,251.03 213.34,251.13 HDMI.4
V_HDMI_TX2_DN: length 11.1
  TOP w0.102: HDMI.3 212.23,248.13 212.13,248.03 212.13,247.58 211.72,247.17 207.4,247.17 206.23,246 206.23,245.54 206.32,245.45 RV46.2 206.23,244.93 206.23,243.81 CV33.2
V_HDMI_TX2_DP: length 11.2
  TOP w0.102: CV32.2 206.03,243.84 206.03,244.91 RV47.2 205.94,245.45 206.03,245.54 206.03,246.08 207.32,247.37 211.64,247.37 211.93,247.66 211.93,248.03 211.82,248.13 HDMI.1
V_HSYNC_5V_R: length 30.3
  TOP w0.102: DG8.3 173.28,230.77 174.79,232.28 174.79,233.31 174.1,234 RG18.2 CG14.1 174.1,236.93 175.55,238.38 175.55,240.66 177.83,242.95 183.35,242.95 185.58,245.18 185.58,246.63 184.44,247.78 184.44,250.91 VGA_COM.B13
V_RED_R: length 28.4
  TOP w0.254: VGA_COM.B1 179.04,245.11 170.85,245.11 167.67,241.93 167.67,238.04 166.61,236.98 165.15,236.98 164.26,236.09 CG12.1 162.43,234.96 LG3.2 162.43,231.57 DG1.3
V_VSYNC_5V_R: length 34.5
  TOP w0.102: DG7.3 173.52,232.66 172.88,233.3 172.88,234.7 172.37,235.2 171.99,235.2 171.86,235.08 RG19.2 CG13.1 171.61,236.09 175.17,239.65 175.17,240.66 177.71,243.2 183.23,243.2 185.33,245.3 185.33,246.51 184.18,247.65 184.18,249.05 183.17,250.06 183.17,251.34 183.69,251.87 185.77,251.87 VGA_COM.B14
VCORE_EN: length 274.5
  TOP w0.102: v1(114.08,196.34) 108.97,191.24 108.97,178.91 114.23,173.65 114.23,164.73 105.2,155.7 104.22,155.7 101.65,153.14 100.62,153.14 v1(100.14,152.65) ; v1(91.6,138.18) 91.98,137.8 91.98,135.62 92.63,134.98 97,134.98 97.48,135.46 PC2.1 98.28,135.46 98.5,135.24 PQ3.D1 ; PU7.27 224.35,187.59 224.56,187.38 225.18,187.38 v1(225.43,187.63)
  TOP w0.254: v1(138.91,208.09) 139.5,207.49 139.5,204.42 138.74,203.66 138.74,197.65 PR198.2 139.29,197.1 140.24,197.1 140.38,196.96 PU13.1
  BOTTOM w0.102: v1(100.14,152.65) 100.14,151.67 99.92,151.45 99.92,144.72 95.87,140.66 95.22,140.66 92.96,138.4 91.83,138.4 v1(91.6,138.18) ; v1(225.43,187.63) 225.43,193.7 225.1,194.03 222.82,194.03 222.03,194.82 222.03,195.48 222.34,195.78 224.37,195.78 226.78,198.2 226.78,200.46 227.96,201.64 232.03,201.64 v2(232.7,202.31) 232.7,202.9 233.15,203.35 233.15,209.73 222.78,220.1 221.51,220.1 219.64,221.97 218.3,221.97 217.39,221.06 188.84,221.06 185.81,218.03 163.46,218.03 155.76,210.34 147,210.34 146.64,210.69 144.94,210.69 142.34,208.09 v1(138.91,208.09) 137.38,208.09 134.96,210.52 121.39,210.52 120.65,209.78 119.78,209.78 114.84,204.84 114.84,201.39 113.19,199.74 113.19,197.23 v1(114.08,196.34)
VCORE_EN_FREQUENCE: length 9.8
  TOP w0.102: PR15.1 101.56,139.26 101.39,139.08 PQ4.D1 ; 100.36,138.43 100.29,138.51 100.29,138.96 100.4,139.08 PQ4.D1 ; 100.36,138.43 100.03,138.43 99.68,138.07 99.68,136.13 ; 100.36,138.43 PQ4.G2 ; PQ4.D1 v1(101,139.69) ; 99.68,136.13 99.91,135.89 PQ3.G1 ; 99.68,136.13 99.44,135.89 PQ3.G2
  BOTTOM w0.102: v2(100.19,139.79) 100.9,139.79 v1(101,139.69)
VCORE_HSN_1: length 3.7
  TOP w0.102: PC107.2 196.44,210.5 v1(195.87,211.07)
  TOP w0.508: PR167.1 196.5,209.74 PC107.2
VCORE_HSN_2: length 2
  TOP w0.508: PR176.1 179.99,206.5 v1(179.39,207.11) PC114.2
VCORE_HSN_3: length 2.4
  TOP w0.102: v1(162.14,207.9) 162.33,208.09 PC122.2
  TOP w0.508: PR179.1 PC122.2
VCORE_PG: length 544.5
  TOP w0.102: v1(230.04,122.36) 237.09,115.32 v1(238.67,115.32) ; v3(230.28,201.17) 229.56,201.9 222.26,201.9 221.13,200.77 221.13,199.72 PR141.2 221.33,199.26 220.51,199.26 220.25,199.01 220.25,195.64 220.44,195.45 220.44,194.91 220.75,194.6 PU7.54 ; v1(131.27,215.82) 127.46,215.82 125.41,213.77 101.68,213.77 94.29,206.38 94.29,164.39 97.42,161.26 97.42,156.54 96.78,155.91 96.78,155.25 91.71,150.18 v1(91.71,146.01) 94.75,142.98 94.75,135.92 95.46,135.2 96.68,135.2 96.98,135.51 96.98,137.85 97.37,138.23 98.25,138.23 98.7,137.78 PQ4.D2 ; v1(42.32,143.38) RX201.2 RX199.2 ; v1(202.47,44.83) 202.73,44.83 202.87,44.69 QO1.1 ; v1(45.58,152.7) 46.62,153.75 46.62,154.89 54.06,162.33 66.17,162.33 68.79,159.71 71.07,159.71 75.97,154.81 75.97,152.38 79.63,148.72 85.14,148.72 86.6,147.26 86.89,147.26 88.3,145.85 v1(88.3,145.16)
  BOTTOM w0.102: v1(88.3,145.16) 88.83,144.62 90.33,144.62 v1(91.71,146.01) ; v1(131.27,215.82) 132.11,216.66 134.27,216.66 137.93,213 155.59,213 159.32,216.74 161.78,216.74 163.35,218.31 185.66,218.31 188.64,221.29 217.29,221.29 218.2,222.2 219.73,222.2 221.6,220.33 222.88,220.33 233.43,209.78 233.43,203.31 233.29,203.17 233.29,201.89 232.57,201.17 v3(230.28,201.17) 230.28,200.91 230.83,200.37 230.83,198.64 231.98,197.49 232.95,197.49 235.41,195.02 235.41,144.18 233.48,142.25 233.48,141.33 232.39,140.23 231.36,140.23 225.7,134.58 225.7,124.68 228.02,122.36 v1(230.04,122.36) ; v1(202.47,44.83) 204,44.83 206.54,47.37 209.02,47.37 211.06,45.34 212.12,45.34 212.55,44.91 219.02,44.91 222.43,48.31 224.11,48.31 224.88,49.09 224.88,49.97 228.44,53.53 228.44,62.22 230.92,64.71 230.92,66.62 231.22,66.92 231.22,75.54 v2(231.71,76.02) 231.96,76.28 231.96,90.4 226.65,95.71 226.65,101.93 237.19,112.47 237.19,113.84 v1(238.67,115.32) ; v1(45.58,152.7) 45.58,152.1 45.22,151.74 43.73,151.74 42.32,150.34 42.32,148.53 41.66,147.87 41.66,144.04 v1(42.32,143.38)
VCORE_PG_R: length 15.4
  TOP w0.089: U4.AY1 48.85,135.68 48.03,136.51 44.76,136.51 43.09,138.17
  TOP w0.102: 43.09,138.17 43.02,138.17 42.68,138.51 42.12,138.51 41.63,139 R6427.1 40.8,139.51 40.8,141.16 RX199.1 40.8,142.18 40.8,143.06 v1(41.15,143.4) 41.31,143.56 RX202.1
VCT: length 5.4
  TOP w0.508: CL23.1 104.55,237.14 NIC_USB.9
VGA_5V_DDC_R: length 24.1
  TOP w0.102: DG6.2 161.72,231.85 v1(161.72,231.9) RG24.1 160.5,233.95 DG5.2 ; v1(172.37,232.66) 172.37,232.46 DG7.2 171.36,231.44 171.36,229.87 173.5,227.72 DG8.2
  BOTTOM w0.102: v1(161.72,231.9) 162.21,232.4 162.21,232.92 163.15,233.86 v2(171.18,233.86) v1(172.37,232.66)
VGA_BLUE_P: length 22.1
  TOP w0.254: v1(169.53,232.79) CG7.1 169.39,233.95 LG1.1 ; RTK_VGA.10 155.82,223.67 RG15.1 157.13,224.98 v1(157.13,225.17)
  BOTTOM w0.254: v1(169.53,232.79) 169.53,232.52 167.13,230.12 164.5,230.12 163.74,229.36 160.97,229.36 157.13,225.52 v1(157.13,225.17)
VGA_GREEN_P: length 18.6
  TOP w0.254: RTK_VGA.12 155.1,224.67 155.99,225.55 RG16.1 v1(156.59,226.35) ; LG2.1 166.6,233.95 CG9.1 v1(166.74,232.79)
  BOTTOM w0.254: v1(166.74,232.79) 166.74,232.62 165.26,231.14 164.24,231.14 163.23,230.12 160.5,230.12 156.72,226.35 v1(156.59,226.35)
VGA_HSYNC: length 27.1
  TOP w0.102: v1(173.52,233.81) 173.21,234.11 RG18.1 ; RTK_VGA.8 153.64,222.43 v3(153.72,222.5)
  BOTTOM w0.102: v1(173.52,233.81) 173.52,232.66 171.37,230.52 169.56,230.52 166.96,227.91 161.59,227.91 157.63,223.95 155.79,223.95 155.1,223.27 154.48,223.27 v3(153.72,222.5)
VGA_PRX_PIN28: length 3.1
  TOP w0.102: RTK_VGA.28 147.99,225.17 147.23,225.93 v1(146.97,225.93) RG27.1
VGA_RED_P: length 15.3
  TOP w0.254: RTK_VGA.15 154.51,226.17 RG17.1 156.05,227.71 v1(156.62,227.71) ; LG3.1 163.8,233.95 CG11.1 v1(163.94,232.82)
  BOTTOM w0.254: v1(156.62,227.71) 157.01,227.71 160.18,230.89 162.59,230.89 163.94,232.23 v1(163.94,232.82)
VGA_RGB_CV: length 10.5
  TOP w0.508: DG1.2 165.08,229.87 166.86,229.87 167.37,229.36 DG3.2 168.39,229.74 v1(169.78,229.74) DG2.2 170.93,228.6 RG25.1
VGA_SCL: length 63.7
  TOP w0.102: v1(157.77,233.17) 157.51,233.17 157.2,232.85 RG20.2 158.15,232.66 159.55,234.06 DG5.3 160.08,237.26 164.14,237.26 164.77,237.9 166.23,237.9 166.76,238.42 166.76,242.31 170.47,246.02 177.6,246.02 179.74,248.16 179.74,249.3 178.85,250.19 178.85,251.59 179.36,252.09 187.83,252.09 VGA_COM.B15 ; RTK_VGA.4 151.18,221.62 v3(151.32,221.49)
  BOTTOM w0.102: v3(151.32,221.49) 151.32,221.63 154,224.31 154,225.54 154.75,226.29 154.75,227.68 157.39,230.32 157.39,232.92 157.64,233.17 v1(157.77,233.17)
VGA_SDA: length 51.5
  TOP w0.102: VGA_COM.B12 181.39,250.96 179.99,249.56 179.99,248.03 177.76,245.8 170.57,245.8 166.99,242.22 166.99,238.33 166.33,237.67 164.87,237.67 164.23,237.03 160.99,237.03 159.77,235.81 159.77,233.15 DG6.3 158.94,232.31 157.86,232.31 RG21.2 v1(157.89,231.65) ; RTK_VGA.6 152.18,221.88 v3(152.45,221.61)
  BOTTOM w0.102: v3(152.45,221.61) 152.96,222.12 152.96,222.88 154.23,224.16 154.23,225.39 155.38,226.54 v2(155.38,227.14) 155.38,227.99 157.89,230.5 v1(157.89,231.65)
VGA_V_GPI_VGA_CBL_DET#_R: length 16.6
  TOP w0.102: RG23.1 RG22.2 190.84,234 CG16.1 190.9,234.68 192.03,235.81 v1(192.03,236.6)
  BOTTOM w0.102: VGA_COM.B4 191.03,241.53 191.03,237.61 v1(192.03,236.6)
VGA_VSYNC: length 31.3
  TOP w0.102: v1(152.99,220.98) 152.99,221.83 152.68,222.14 RTK_VGA.7 ; v1(172.37,234.31) 171.43,234.31 RG19.1
  BOTTOM w0.102: v1(152.99,220.98) 153.18,221.17 153.18,222.76 153.92,223.49 155.01,223.49 155.69,224.18 157.54,224.18 161.52,228.17 166.89,228.17 169.47,230.75 171.28,230.75 172.88,232.35 172.88,233.81 v1(172.37,234.31)
VGAPWR_F_20:
  vias: v1(193.99,251.51)
VGT_BOOT1_20: length 2.5
  TOP w0.254: PU11.1 230.51,158.76
  TOP w0.508: v1(230.75,156.93) PC153.1 230.51,158.04 230.51,158.76
VGT_BOOT1_RC_20: length 3.4
  TOP w0.508: PC153.2 228.71,157.4 227.58,156.27 v1(227.38,156.27) 226.68,155.57 PR188.1
VGT_BOOT2_20: length 3.6
  TOP w0.254: PU12.1 230.05,141.62 230.41,141.26
  TOP w0.508: v1(228.71,139.06) 229.45,139.8 PC173.1 230.41,140.92 230.41,141.26
VGT_BOOT2_RC_20: length 4.5
  TOP w0.508: v1(227.08,138.02) 226.22,138.02 225.71,138.53 PR194.1 226.37,139.22 227.34,139.22 PC173.2
VGT_LG1_R_30: length 16.8
  TOP w0.254: PU11.5 227.78,160.39 227.39,160.78 v1(227.26,160.78)
  TOP w0.508: PQ39.4 217.98,156.18 218.49,156.69 223.68,156.69 224.08,156.29 PQ40.4 v1(224.08,154.94)
  BOTTOM w0.508: v1(224.08,154.94) 225.74,156.6 225.74,160.17 226.35,160.78 v1(227.26,160.78)
VGT_LG2_R_30: length 16.2
  TOP w0.254: PU12.5 227.25,143.12 226.98,143.38 v1(226.86,143.38)
  TOP w0.508: v1(224.2,137.78) PQ43.4 223.45,138.02 222.94,138.53 217.89,138.53 217.35,137.99 PQ42.4
  BOTTOM w0.508: v1(224.2,137.78) 224.67,138.25 224.67,142.72 225.33,143.38 v1(226.86,143.38)
VGT_PHASE1_20: length 17.4
  TOP w0.254: PU11.7 227.49,159.39 v1(227.36,159.26)
  TOP w0.508: 223.4,163.19 223.4,163.19 PR189.2 ; PC155.1 213.58,161.23 213.65,161.16 ; 224.57,157.35 PR188.2 227.06,157.35 v1(227.36,157.66)
  TOP w1.27: PL9.1 219.53,165.98 ; PL9.1 220.89,164.62 ; PL9.1 220.89,167.34 ; PL9.1 222.24,165.98
  BOTTOM w0.254: PL9.1 220.5,165.98 PJP15.1
  BOTTOM w0.508: v1(227.36,157.66) v1(227.36,159.26)
  vias: v1(214.28,160.91) v1(214.28,159.38) v1(214.28,157.86) v1(215.93,160.91) v1(215.93,159.38) v1(215.93,157.86) v1(217.46,160.91) v1(217.46,159.38) v1(217.46,157.86) v1(220.63,160.91) v1(220.63,159.38) v1(220.63,157.86) v1(221.88,170.38) v1(222.28,160.91) v1(222.28,159.38) v1(222.28,157.86) v1(223.81,160.91) v1(223.81,159.38) v1(223.81,157.86) v3(216.19,164.21) v3(217.46,165.61) v3(218.6,164.34) v3(220.76,169.04) v3(221.9,163.96) v3(222.28,168.78) v3(222.79,167.39) v3(223.17,165.48) v3(223.3,170.94) v3(223.3,169.42)
VGT_PHASE2_20: length 20.3
  TOP w0.254: v1(226.86,141.99) 226.99,142.12 PU12.7
  TOP w0.508: PC175.1 213.65,143.07 PQ42.5 ; v1(226.86,140.33) 226.78,140.26 225.79,140.26 PR194.2 224.82,140.33 224.44,140.72 223.81,140.72 ; 223.93,145.54 PR195.2
  TOP w1.27: PL10.1 219.54,147.19 ; PL10.1 222.26,147.19 ; PL10.1 220.9,145.83 ; PL10.1 220.9,148.55
  BOTTOM w0.254: PL10.1 220.62,147.19 PJP17.1
  BOTTOM w0.508: v1(226.86,141.99) 226.98,141.86 226.98,140.46 v1(226.86,140.33)
  vias: v1(213.77,142.88) v1(213.77,141.35) v1(213.77,139.83) v1(215.43,142.88) v1(215.43,141.35) v1(215.43,139.83) v1(216.95,142.88) v1(216.95,141.35) v1(216.95,139.83) v1(220,142.88) v1(220,141.35) v1(220,139.83) v1(221.65,142.88) v1(221.65,141.35) v1(221.65,139.83) v1(222.66,152.07) v1(223.17,142.88) v1(223.17,141.35) v1(223.17,139.83) v3(214.92,144.27) v3(216.19,146.43) v3(218.09,144.4) v3(218.85,146.43) v3(220.76,144.4) v3(221.01,149.35) v3(221.65,151.38) v3(222.66,146.43) v3(223.3,144.4) v3(223.68,152.02) v3(223.68,150.5) v3(223.68,149.1) v3(223.68,147.7)
VGT_SN1_20: length 1.8
  TOP w0.508: PC155.2 v1(212.25,159.54) PR190.1
VGT_SN2_20: length 1.9
  TOP w0.508: PR196.1 v1(211.49,141.48) 211.87,141.86 PC175.2
VGT_UG1_20: length 3
  TOP w0.254: 227.54,158.55 227.88,158.89 PU11.8
  TOP w0.508: 227.54,158.55 v1(226.52,158.55) 226.22,158.85 PR186.1
VGT_UG1_R_20: length 5.6
  TOP w0.508: PQ38.4 224.86,164.3 225.65,163.51 PR189.1 225.71,163.19 226.22,162.69 226.22,161.42 225.74,161.42 v1(225.05,162.1)
VGT_UG2_20: length 2.8
  TOP w0.254: PU12.8 227.38,141.62 226.98,141.22 226.86,141.22
  TOP w0.508: 225.71,142.37 225.71,141.91 v1(226.17,141.45) 226.4,141.22 226.86,141.22
VGT_UG2_R_20: length 4.5
  TOP w0.508: PR191.2 225.78,144.21 PR195.1 ; PR195.1 226.42,145.54 v1(226.73,145.85) ; PR195.1 225.78,145.99 224.99,146.77 PQ41.4
VGT_VCC1_20: length 4.9
  TOP w0.254: 231.16,160.27 231.05,160.39 PU11.4 230.21,160.57
  TOP w0.508: 231.16,160.27 PR187.1 ; v1(231.07,161.14) 230.54,161.67 PC154.1 230.21,160.57
VGT_VCC2_20: length 5.2
  TOP w0.102: v1(229.57,145.82) PC174.1 ; 230.54,143.12 230.67,143.12
  TOP w0.254: PU12.4 230.54,143.12
  TOP w0.508: 230.67,143.12 230.68,143.13 PR193.1 231.38,143.43 230.03,144.78 PC174.1
VIDALERT_#: length 19.8
  TOP w0.102: v3(184.14,161.13) 183.71,160.7 CPU.E39 ; v1(192.82,173.74) 192.82,173.84 193.86,174.88 R2.2
  BOTTOM w0.102: v3(184.14,161.13) 184.33,161.13 184.95,161.75 185.4,161.75 185.71,162.05 185.71,166.98 v2(186.39,167.67) 186.39,168.02 188.93,170.56 189.42,170.56 189.7,170.84 190.18,170.84 192.82,173.48 v1(192.82,173.74)
VIDSCLK: length 21.6
  TOP w0.102: v1(192.18,173.74) 192.18,174.12 193.96,175.89 R6578.2 ; CPU.E38 v3(183.25,161.12)
  BOTTOM w0.102: v3(183.25,161.12) 183.77,161.63 184.34,161.63 184.64,161.93 184.64,163.15 184.49,163.31 184.49,164.76 185.16,165.44 185.16,168.14 188.29,171.27 v2(189.11,171.27) 189.19,171.35 190,171.35 192.18,173.53 v1(192.18,173.74)
VIDSOUT: length 20.4
  TOP w0.102: v3(185.22,161.29) 184.63,160.69 CPU.E40 ; v1(193.45,173.74) 193.58,173.86 R6577.2
  BOTTOM w0.102: v1(193.45,173.74) 193.45,173.35 190.41,170.31 189.96,170.31 v2(188.73,169.08) 186.14,166.49 186.14,166.04 186.25,165.92 186.4,165.92 186.52,165.8 186.52,165.63 186.4,165.51 186.25,165.51 186.14,165.39 186.14,165.22 186.25,165.1 186.4,165.1 186.52,164.98 186.52,164.82 186.4,164.7 186.25,164.7 186.14,164.58 186.14,164.41 186.25,164.29 186.4,164.29 186.52,164.17 186.52,164 186.4,163.88 186.25,163.88 186.14,163.77 186.14,163.6 186.25,163.48 186.4,163.48 186.52,163.36 186.52,163.19 186.4,163.07 186.25,163.07 186.14,162.95 186.14,162.78 186.25,162.67 186.43,162.67 186.55,162.55 186.55,162.38 186.43,162.26 186.25,162.26 185.28,161.29 v3(185.22,161.29)
VISACH1_D2_PCH_GPP_E_5: length 17.2
  TOP w0.089: U4.AG43 55.66,114.39 55.66,113.87 55.34,113.56 55.34,113.13 54.93,112.72 54.59,112.72 53.12,111.25
  TOP w0.102: 53.12,111.25 52.99,111.12 v1(52.99,110.36) ; XDP_PCH.27 51.94,100.34 53.12,101.52 v1(53.12,101.6)
  BOTTOM w0.102: v1(52.99,110.36) 52.97,110.35 52.97,106.57 v2(52.87,106.47) 52.97,106.36 52.97,101.74 v1(53.12,101.6)
VISACH1_D2_PCH_GPP_E_6: length 17.5
  TOP w0.089: v1(54.9,112.01) 56.08,113.2 U4.AE45
  TOP w0.102: v1(53.63,102.11) 52.92,102.11 52.69,101.88 52.69,101.42 51.96,100.69 51.57,100.69 51.44,100.55 XDP_PCH.29
  BOTTOM w0.089: v1(54.9,112.01) 54.14,111.25
  BOTTOM w0.102: 54.14,111.25 53.48,110.6 53.48,109.37 v2(53.81,109.05) 53.69,108.93 53.69,106.18 53.22,105.7 53.22,102.51 v1(53.63,102.11)
VPP_PG: length 140.1
  TOP w0.102: v1(146.9,70.99) 149.05,73.15 152.81,73.15 v1(153.32,73.66) ; v1(223.72,72.06) 224.45,71.32 PQ16.G ; PQ79.3 107.98,64.15 108.33,63.8 108.8,63.8 v1(109.25,64.26) 110.7,65.71 110.7,69.16 109.7,70.17 PR381.2 PR358.1
  BOTTOM w0.102: v1(146.9,70.99) 147.35,70.54 147.35,67.49 144.18,64.31 129.27,64.31 125.53,60.58 116.1,60.58 112.09,64.59 109.58,64.59 v1(109.25,64.26) ; v1(223.72,72.06) 223.72,72.35 v2(223.17,72.9) 222.66,73.41 220.7,73.41 217.76,76.35 181.52,76.35 180.97,75.79 177.1,75.79 176.6,75.29 173.61,75.29 172.85,76.05 158.45,76.05 155.56,73.16 153.83,73.16 v1(153.32,73.66)
VR_HOT: length 240.4
  TOP w0.102: R6576.1 v1(196.12,176.91) R52.2 ; v1(231.81,43.18) 231.81,42.79 227.62,38.6 227.62,38.13 226.51,37.02 R6523.2 226.09,36.22 v1(226.27,36.04) ; v1(230.36,114.94) 230.28,114.86 230.28,106.02 226.37,102.1 226.37,95.49 230.35,91.5 230.63,91.5 233.84,88.29 v1(233.84,87.76) ; PR69.1 223.93,183.67 v1(223.44,184.16) 223.12,184.48 223.12,187.27 222.75,187.65 PU7.23
  BOTTOM w0.102: v1(231.81,43.18) 234.78,46.15 234.78,57.02 233.64,58.17 233.64,85.45 233.97,85.78 233.97,87.62 v1(233.84,87.76) ; v1(230.36,114.94) 230.36,118.67 225.3,123.73 225.3,134.75 231.05,140.5 231.05,141.73 234.68,145.36 234.68,154.61 233.48,155.8 232.77,155.8 232.06,156.51 232.06,158.2 234.27,160.41 234.27,194.4 232.38,196.29 229.08,196.29 227.99,195.2 226.23,195.2 225.84,194.81 225.84,189.33 227.59,187.58 227.59,184.86 226.86,184.12 226.32,184.12 225.97,184.48 225.05,184.48 224.73,184.16 v1(223.44,184.16) 223.32,184.28 219.24,184.28 218.47,185.04 216.31,185.04 214.41,183.13 213.8,183.13 207.3,176.63 196.4,176.63 v1(196.12,176.91)
VR_HOT_1V: length 19.7
  TOP w0.102: CPU.C39 v1(184.18,162.96) ; R6576.2 191.37,174 v1(191.37,173.56)
  BOTTOM w0.102: v1(191.37,173.56) 189.72,171.91 188.24,171.91 184.45,168.12 184.45,165.41 184.18,165.15 v1(184.18,162.96)
VRALERT_N: length 5.1
  TOP w0.089: U4.BD23 46.78,124.56 46,125.33 44.66,125.33 43.28,123.95 R6413.2
VREF_R: length 1.5
  TOP w0.203: PR125.1 220.7,180.73 v1(221.2,181.24) 220.76,181.69 PR124.1
VREF_RA: length 1.7
  TOP w0.203: PR134.1 221.78,178.69 v1(222.31,179.23) PR133.1
VREF_RC: length 1.6
  TOP w0.203: PR127.2 221.65,184.34 v1(221.65,183.51) PC94.1
VREG_PD33: length 7.7
  TOP w0.102: RK31.2 v1(53.88,188.85) 53.88,189.18 53.27,189.79 53.27,192.46 54.62,193.8 55,193.8 55.4,194.2 BRIDGE.D12
VRM_ALERT#: length 38.1
  TOP w0.102: PR140.1 224.57,183.95 v1(224.57,183.01) 225.02,182.56 PR132.1 ; R7.2 v1(196.12,174.88) R2.1
  BOTTOM w0.102: v1(196.12,174.88) 196.12,175.13 196.65,175.67 208.64,175.67 211.81,178.84 211.81,179.09 211.65,179.26 211.65,179.51 211.83,179.69 212.08,179.69 212.25,179.52 212.5,179.52 212.93,179.95 212.93,180.9 214.01,181.98 220.12,181.98 220.57,182.43 222.97,182.43 v2(223.55,183.02) 223.88,183.02 223.89,183.01 v1(224.57,183.01)
VRM_ALERT#_R: length 3.7
  TOP w0.102: v1(224.4,184.75) 224.4,185.02 PR140.2 223.68,187.12 223.15,187.66 PU7.24
VRM_BOOT1_20: length 3.3
  TOP w0.254: 219.44,208 219.02,208.42 PU8.1
  TOP w0.508: 219.44,208 220.17,208 PC109.1 220.33,208.08 v1(221.27,207.14)
VRM_BOOT1_RC_20: length 5.1
  TOP w0.508: v1(215.78,205.61) 217.05,205.61 218.32,206.88 PR170.1 218.52,206.71 PC109.2
VRM_BOOT2_20: length 2.9
  TOP w0.254: PU9.1 193.06,209.05
  TOP w0.508: 193.06,209.05 193.49,209.05 PC116.1 194.29,208.58 v1(194.85,208.03)
VRM_BOOT2_RC_20: length 2.9
  TOP w0.508: PR175.1 192.23,207.21 PC116.2 193.96,206.63 v1(193.58,206.25)
VRM_BOOT3_20: length 2.9
  TOP w0.254: PU10.1 175.66,205.24 176.13,204.77
  TOP w0.508: v1(177.78,205.16) 177.33,205.16 PC123.1 176.13,204.77
VRM_BOOT3_RC_20: length 3.2
  TOP w0.508: v1(178.16,203.25) 178.01,203.4 PC123.2 176.89,203.45 PR181.1
VRM_COMP: length 5.4
  TOP w0.203: PR144.1 215.49,189.04 216,188.53 216.7,188.53 217.2,189.04 217.57,189.04 v1(217.91,189.38) 218.28,189.74 PU7.11
VRM_DVD: length 7.6
  TOP w0.203: PR91.2 222.35,198.5 221.84,197.99 v1(221.84,197.93) 221.88,197.89 221.88,196.68 PR92.1 PC83.1 223.71,196.09 224.35,195.45 PU7.45
  BOTTOM w0.203: v2(221.96,197.01) 221.84,197.13 v1(221.84,197.93)
VRM_FB: length 11.4
  TOP w0.203: PU7.10 217.94,190.14 217.47,189.67 216.95,189.67 PC97.1 216.24,189.04 215.68,189.6 214.24,189.6 v3(214.23,189.61) 214.23,189.8 214.61,190.18 PR143.1 ; PC96.2 215.74,188.02 v1(215.49,188.28) 215.23,188.53 214.28,188.53 PR142.2
  BOTTOM w0.203: v3(214.23,189.61) 215.49,188.35 v1(215.49,188.28)
VRM_IBIAS: length 4.7
  TOP w0.203: PU7.31 225.74,188.94 226.12,188.57 226.52,188.57 227.31,187.78 227.31,187.38 227.93,186.75 228.13,186.75 228.41,187.04 v1(228.41,187.39)
VRM_LG1_R_30: length 11
  TOP w0.254: v1(215.43,210.31) 215.82,209.92 PU8.5
  TOP w0.508: v1(213.27,210.69) PQ30.4 212.12,210.69 211.74,210.31 211.74,205.44 PQ31.4
  BOTTOM w0.508: v1(213.27,210.69) 213.65,210.31 v1(215.43,210.31)
VRM_LG2_R_30: length 20.7
  TOP w0.203: PU9.5 189.38,210.55 v1(189.26,210.44)
  TOP w0.508: v1(195.99,204.6) 195.49,205.1 PQ33.4 194.3,204.35 194.3,197.48 PQ34.4
  BOTTOM w0.508: v1(189.26,210.44) 190.41,209.3 192.31,209.3 194.6,207.01 194.6,206.12 195.99,204.72 v1(195.99,204.6)
VRM_LG3_R_30: length 20.9
  TOP w0.254: v1(172.14,207.44) 172.84,206.74 PU10.5
  TOP w0.508: v1(178.34,201.42) PQ37.4 176.54,200.68 176.54,193.15 PQ36.4
  BOTTOM w0.508: v1(178.34,201.42) 178.34,201.93 173.52,206.76 172.83,206.76 v1(172.14,207.44)
VRM_PHASE1_20: length 20.1
  TOP w0.254: PU8.7 215.56,208.92 v1(215.43,208.79)
  TOP w0.508: v1(215.43,206.88) PR170.2
  TOP w1.27: 204.46,204.75 PL5.1 ; PL5.1 201.74,204.75 ; PL5.1 203.1,206.11 ; PL5.1 203.1,203.39
  BOTTOM w0.203: PL5.1 202.71,204.36 PJP9.1
  BOTTOM w0.508: v1(215.43,206.88) v1(215.43,208.79) 215.81,208.79 216.31,209.3 216.31,210.78 215.38,211.71 211.62,211.71 v1(211.49,211.58)
  vias: v1(204.43,208.58) v1(207.3,210.31) v1(207.3,208.79) v1(207.3,207.26) v1(207.42,204.34) v1(207.42,202.82) v1(207.42,201.29) v1(208.95,210.31) v1(208.95,208.79) v1(208.95,207.26) v1(209.08,204.34) v1(209.08,202.82) v1(209.08,201.29) v1(210.47,210.31) v1(210.47,208.79) v1(210.47,207.26) v1(210.6,204.34) v1(210.6,202.82) v1(210.6,201.29) v3(197.9,207.14) v3(198.15,204.09) v3(199.42,205.61) v3(199.55,208.91) v3(200.82,204.22) v3(201.07,208.91) v3(201.46,206.12) v3(202.47,208.91) v3(205.14,206.12) v3(205.14,203.96)
VRM_PHASE2_20: length 15.9
  TOP w0.254: v1(189.26,209.3) 189.54,209.3 189.8,209.55 PU9.7
  TOP w0.508: PR175.2 190.41,206.76 189.39,205.74 189.39,205.61
  TOP w1.27: PL7.1 184.16,196.37 ; PL7.1 186.88,196.37 ; PL7.1 185.52,197.73 ; PL7.1 185.52,195.01
  BOTTOM w0.254: PJP11.1 183.79,194.63 PL7.1
  BOTTOM w0.508: v1(189.26,209.3) 189.26,205.36
  vias: v1(179.61,203.45) v1(180.25,201.29) v1(180.25,196.98) v1(180.37,199.01) v1(180.37,195.2) v1(182.02,201.42) v1(182.15,203.71) v1(182.15,199.01) v1(182.15,196.98) v1(182.15,195.2) v1(183.68,196.09) v1(184.06,197.74) v1(184.18,203.58) v1(184.69,199.01) v1(184.77,202.69) v1(184.95,201.42) v1(186.09,198.12) v1(186.34,203.45) v1(186.85,199.01) v1(186.98,201.42) v1(188.63,203.58) v1(188.63,201.42) v1(190.03,204.72) v1(190.03,203.2) v1(190.03,201.68) v1(190.15,196.47) v1(190.15,194.94) v1(190.15,193.42) v1(191.42,196.47) v1(191.42,194.94) v1(191.42,193.42) v1(191.68,204.72) v1(191.68,203.2) v1(191.68,201.68) v1(192.95,196.47) v1(192.95,194.94) v1(192.95,193.42) v1(193.2,204.72) v1(193.2,203.2) v1(193.2,201.68)
VRM_PHASE3_20: length 17
  TOP w0.203: PU10.7 172.37,205.74 v1(172.12,205.99)
  TOP w0.508: PR183.2 169.58,202.56 ; PR181.2 172.63,203.45 171.48,202.31
  TOP w1.27: 166.51,196.87 PL8.1 ; PL8.1 167.87,198.23 ; PL8.1 167.87,195.52 ; PL8.1 169.23,196.87
  BOTTOM w0.254: PJP13.1 166.39,195.39 PL8.1
  BOTTOM w0.508: v1(172.12,205.99) 172.12,203.33 171.23,202.44
  vias: v1(161.83,199.26) v1(161.91,197.1) v1(161.91,195.45) v1(162.85,203.71) v1(162.85,201.93) v1(163.48,199.26) v1(163.61,197.23) v1(163.74,195.33) v1(164.5,203.71) v1(164.5,201.93) v1(165.26,195.33) v1(165.77,199.26) v1(165.77,197.1) v1(166.4,203.71) v1(166.4,201.93) v1(168.05,199.26) v1(168.31,203.71) v1(168.31,201.93) v1(168.69,194.82) v1(169.5,200.74) v1(170.21,198.75) v1(170.34,201.93) v1(170.34,196.47) v1(170.47,192.66) v1(172.25,201.17) v1(172.25,199.64) v1(172.25,198.12) v1(172.25,196.34) v1(172.25,194.31) v1(172.25,192.02) v1(172.25,190.5) v1(172.25,188.98) v1(173.9,201.17) v1(173.9,199.64) v1(173.9,198.12) v1(173.9,192.02) v1(173.9,190.5) v1(173.9,188.98) v1(174.02,196.34) v1(174.02,194.44) v1(175.42,201.17) v1(175.42,199.64) v1(175.42,198.12) v1(175.42,192.02) v1(175.42,190.5) v1(175.42,188.98) v1(175.55,196.34) v1(175.67,194.44)
VRM_PWM1_10: length 19.2
  TOP w0.203: PU7.52 221.55,195.3 v3(220.95,195.9) ; PU8.2 219.85,208.92 219.9,208.97 v1(220.2,208.97)
  BOTTOM w0.203: v1(220.2,208.97) 220.2,207.29 218.57,205.66 218.57,200.76 218.22,200.41 218.22,199.95 220.68,197.49 220.74,197.49 221.26,196.97 221.26,196.21 v3(220.95,195.9)
VRM_PWM2_10: length 54.8
  TOP w0.203: PU7.51 221.95,195.79 221.01,196.72 v1(220.76,196.72) ; v1(193.58,210.06) 193.08,209.55 PU9.2
  BOTTOM w0.203: v1(220.76,196.72) 218.93,198.55 217.76,198.55 217.36,198.96 217.36,200.61 v2(217.89,201.14) 217.43,201.6 217.43,205 219.49,207.06 219.49,209.3 220.38,210.19 220.38,211.45 217.84,214 210.03,214 208.82,215.21 206.48,215.21 204.6,213.33 204.6,211.94 204.07,211.4 197.25,211.4 195.63,209.78 193.86,209.78 v1(193.58,210.06)
VRM_PWM3_10: length 74.9
  TOP w0.203: PU10.2 v1(176.18,205.74) ; v3(220.92,195.08) 221.15,194.86 PU7.53
  BOTTOM w0.203: v3(220.92,195.08) 219.87,196.14 218.97,196.14 216.9,198.21 216.9,205.3 218.98,207.39 218.98,209.42 220,210.44 220,211.2 217.66,213.54 209.9,213.54 208.68,214.76 206.79,214.76 205.01,212.98 205.01,211.15 v2(204.93,211.07) 204.68,210.82 197.49,210.82 195.84,209.17 193.71,209.17 192.69,210.19 190.79,210.19 189.9,211.07 189.01,211.07 187.1,209.17 187.1,207.14 185.71,205.74 179.25,205.74 178.93,206.07 176.5,206.07 v1(176.18,205.74)
VRM_RGND: length 10.2
  TOP w0.203: PU7.13 218.82,188.94 218.28,188.4 218.28,187.96 217.33,187.01 217.2,187.01 216.7,186.5 214.66,186.5 PR146.2 214.03,187.13 213.14,187.13 PC100.1 v1(212.63,185.93) 212.95,185.61 PR148.2
VRM_SCLK: length 39.1
  TOP w0.102: R6578.1 v1(196.12,175.89) R9.2 ; PR130.2 225.85,183.95 v1(225.76,183.95) 225.76,186.04 PR138.1
  BOTTOM w0.102: v1(225.76,183.95) 225.48,183.66 223.06,183.66 222.32,182.92 220.37,182.92 219.92,182.46 213.81,182.46 208.33,176.99 v2(208.33,176.83) 207.65,176.15 196.38,176.15 v1(196.12,175.89)
VRM_SCLK_R: length 3.9
  TOP w0.102: PU7.26 223.95,187.67 224.47,187.15 225.7,187.15 PR138.2 226.47,186.37 226.47,186.31 226.65,186.13 v1(226.65,185.85)
VRM_SDIO: length 39.2
  TOP w0.102: PR131.1 226.22,182.6 v1(225.74,183.08) 225.15,183.66 225.15,185.03 PR139.1 ; R6577.1 196.09,173.86 v1(196.12,173.89) 196.15,173.86 R8.2
  BOTTOM w0.102: v1(225.74,183.08) 224.53,181.86 220.68,181.86 220.32,181.5 214.21,181.5 213.41,180.7 213.41,179.75 208.84,175.18 197.05,175.18 196.12,174.25 v1(196.12,173.89)
VRM_SDIO_R: length 2.4
  TOP w0.102: PR139.2 224.95,186.23 v1(224.52,186.65) 223.55,187.63 PU7.25
VRM_SET1: length 13.6
  TOP w0.203: PR105.2 214.41,180.21 v1(214.13,180.49) 213.53,181.1 213.53,184.92 213.9,185.29 214.98,185.29 214.98,185.92 215.22,186.15 216.87,186.15 216.94,186.22 217.19,186.22 217.19,186.25 218.66,187.72 218.66,188.21 218.99,188.54 PU7.14
VRM_SET1_R: length 2.3
  TOP w0.203: PR105.1 PR97.2 214.54,178.18 v1(214.03,177.67)
VRM_SET1_RR: length 3.4
  TOP w0.203: PR108.1 214.83,184.56 v1(214.03,184.56) 214.03,183.42 214.7,182.75 PR107.2
VRM_SET2: length 11.7
  TOP w0.203: 216.12,185.29 215.76,185.66 v1(215.55,185.66) ; 216.12,185.29 216.49,185.29 217.04,185.84 217.29,185.84 219.31,187.86 PU7.15 ; 216.12,185.29 215.97,185.29 215.62,184.94 215.62,180.72 PR104.2
  BOTTOM w0.203: v1(215.55,185.66) 215.55,186.04 v2(215.92,186.4)
VRM_SET2_R: length 1.7
  TOP w0.203: PR96.2 216.06,178.18 215.55,178.69 v1(215.55,178.82) 216.06,179.32 PR104.1
VRM_SET2_RR: length 2.7
  TOP w0.203: PR110.1 v1(216.12,183.67) PR109.2
  BOTTOM w0.203: v2(215.3,183.13) 215.59,183.13 v1(216.12,183.67)
VRM_SET3: length 11
  TOP w0.203: PU7.17 220.35,187.52 219.9,187.07 v1(219.58,187.07) 219.04,187.07 216.67,184.7 216.67,180.81 PR99.2
  BOTTOM w0.203: v2(218.85,187.71) 219.49,187.07 v1(219.58,187.07)
VRM_SET3_R: length 3.3
  TOP w0.203: PR95.2 217.27,178.34 v1(216.84,178.77) 216.84,178.9 PR99.1
  BOTTOM w0.203: v2(217.32,177.18) 216.84,177.66 v1(216.84,178.77)
VRM_SET3_RR: length 2.6
  TOP w0.203: PR112.1 v1(217.27,183.64) PR111.2
  BOTTOM w0.203: v1(217.27,183.64) 216.82,184.09 v2(216.82,184.4)
VRM_SETA1: length 10.3
  TOP w0.203: PR103.2 217.84,180.78 217.84,184.72 218.41,185.29 218.41,185.61 v1(218.73,185.93) 219.38,186.58 219.91,186.58 220.75,187.41 PU7.18
  BOTTOM w0.102: v1(218.73,185.93) v2(217.97,185.93)
VRM_SETA1_R: length 2.6
  TOP w0.203: PR94.2 218.3,178.18 v1(217.81,178.66) 217.81,178.73 PR103.1
  BOTTOM w0.203: v2(218.3,179.39) 217.81,178.91 v1(217.81,178.66)
VRM_SETA1_RR: length 1.8
  TOP w0.203: PR113.2 218.41,183.45 v1(218.6,183.64) 218.41,183.83 PR114.1
VRM_SETA2: length 9.8
  TOP w0.203: PU7.19 221.15,187.08 v1(221.01,186.94) 219.55,185.48 219.55,185.29 218.98,184.72 218.98,184.2 219.11,184.07 219.11,183.1 219.04,183.03 219.04,180.72 PR102.2
  BOTTOM w0.203: v2(220.76,187.71) 220.76,187.2 v1(221.01,186.94)
VRM_SETA2_R: length 2.5
  TOP w0.203: PR102.1 PR93.2 219.69,178.18 220.1,177.77 220.1,177.27 v1(220.2,177.16)
VRM_SETA2_RR: length 3.5
  TOP w0.203: PR115.2 219.74,182.94 219.74,184.21 PR100.1 219.62,184.4 v1(220.12,184.91)
  BOTTOM w0.203: v2(219.87,185.67) 219.87,185.17 v1(220.12,184.91)
VRM_SN1_20:
  vias: v1(207.93,198.25)
VRM_SN2_20:
  vias: v1(190.03,190.25)
VRM_SN3_20:
  vias: v1(174.53,185.8)
VRM_TON: length 2.4
  TOP w0.203: PR119.2 219.81,194.96 v1(219.98,194.78) 220.35,194.42 PU7.55
VRM_UG1_20: length 12.5
  TOP w0.254: PU8.8 216.05,208.42 215.7,208.07
  TOP w0.508: 215.7,208.07 215.18,208.07 214.66,208.58 214.66,210.57 212.63,212.6 209.51,212.6 v1(208.87,211.96) 208.19,211.96 PR168.1
VRM_UG1_R_20: length 5.6
  TOP w0.508: v1(206.76,211.73) 205.9,212.6 PR168.2 205.77,210.25 PR171.1 205.46,210.06 204.08,210.06 PQ29.4
VRM_UG2_20: length 4.6
  TOP w0.254: PU9.8 190.18,208.43
  TOP w0.508: 190.18,208.43 189.52,207.77 PR173.1 187.74,208.66 v1(187.99,208.91)
VRM_UG2_R_20: length 4.9
  TOP w0.508: v1(186.6,205.61) 185.92,205.61 PQ32.4 185.71,205.23 186.22,204.72 187.1,204.72 187.29,204.53 PR177.1 PR173.2
VRM_UG3_20: length 3.8
  TOP w0.254: PU10.8 172.13,205.24 172.12,205.23
  TOP w0.508: v1(170.29,206.98) 170.98,206.3 PR182.1 170.98,205.74 171.48,205.23 172.12,205.23
VRM_UG3_R_21: length 4.2
  TOP w0.508: v1(169.78,205.08) 169.46,205.4 PQ35.4 168.69,205.1 169.51,204.28 PR183.1 170.91,204.28 PR182.2
VRM_VCC: length 5.1
  TOP w0.203: PU7.29 225.83,188.14 v1(226.19,187.78)
  TOP w0.508: PR98.1 PC84.2 227.36,186.06 227.36,186.61 v1(226.19,187.78)
VRM_VCC1_20: length 3.6
  TOP w0.102: 218.52,210.31 218.52,210.44
  TOP w0.254: 218.52,210.31 218.52,209.97 PU8.4
  TOP w0.508: PR169.1 219.36,210.77 v1(219.36,210.82) 219.31,210.82 218.93,211.2 PC110.1 218.52,210.44
VRM_VCC2_20: length 4.1
  TOP w0.102: v1(193.96,210.82) 193.84,210.95 PR174.1
  TOP w0.254: PU9.4 192.41,211.05
  TOP w0.508: PR174.1 192.57,212.04 PC117.1 192.41,211.89 192.41,211.05
VRM_VCC3_20: length 3.9
  TOP w0.102: PR180.1 176.89,207.47 177.2,207.77 v1(177.45,207.77)
  TOP w0.254: 175.22,207.26 175.22,207.01 175.27,206.96 PU10.4
  TOP w0.508: 175.22,207.26 PC124.1 176.13,208.03 PR180.1
VRM_VREF: length 56.1
  TOP w0.203: PRT2.1 v1(213.08,174.56) ; PU7.21 221.95,185.65 221.58,185.29 221.58,185.23 222.08,184.73 222.08,184.01 222.19,183.9 222.19,182.35 PR124.2 221.74,181.71 221.74,180.78 221.71,180.75 PR133.2 221.23,180.24 v1(221.23,176.53) ; PR97.1 214.98,176.97 215.4,176.56 v1(215.81,176.56) 215.92,176.56 216.12,176.76 PR96.1 PR95.1 PR94.1 PR93.1 219.55,176.95 v3(219.13,176.53) 218.1,175.5 215.18,175.5 212.96,177.72 212.96,180.9 210.54,183.32 210.54,192.34 208.41,194.46 208.41,195.94 207.44,196.91 PRT1.1
  BOTTOM w0.203: v3(219.13,176.53) v1(221.23,176.53) ; v1(215.81,176.56) 215.48,176.23 213.34,176.23 212.76,175.64 v2(212.76,175.41) 212.76,174.88 v1(213.08,174.56)
VRM_VSEN: length 12.7
  TOP w0.203: PR149.2 211.62,185.23 211.17,185.67 v1(211.17,187.2) 211.49,187.52 212.12,187.52 PR150.2 213.14,187.52 214.16,187.52 PR142.1 215.3,187.39 215.93,187.39 PC99.2 217.2,187.9 217.2,188.02 217.37,188.02 218.69,189.34 PU7.12
WAKE#_L: length 8.9
  TOP w0.102: RK9.2 51.34,206.69 51.93,206.11 v1(51.93,204.67) 53.08,203.51 53.08,202.95 54.14,201.89 54.14,201.26 BRIDGE.M13
  BOTTOM w0.102: v1(51.93,204.67) v2(51.37,205.22)
WAKE_SLOT1_N: length 266.8
  TOP w0.089: U4.AG42 55.78,114.8 55.78,114.64 55.85,114.57 55.85,113.54 55.65,113.34 55.65,113.15 55.09,112.58 55.07,112.58 55.01,112.53 54.79,112.53 53.52,111.25
  TOP w0.102: v1(38.54,87.12) 39.04,87.12 39.57,87.66 40.7,87.66 43.24,90.2 43.24,95.99 44.1,96.85 49.22,96.85 49.68,96.39 v1(52.08,96.39) ; 53.52,111.25 53.5,111.24 53.5,107.12 RP40.1 54.26,106.04 v1(53.86,105.64) ; XDP_PCH.17 54.44,100.89 v1(54.06,101.27) ; v1(37.95,82.78) 36.46,81.28 33.14,81.28 32.11,82.31 26.56,82.31 25.98,82.89 23.9,82.89 20.84,85.95 20.84,99.37 18.9,101.31 18.9,108.04 14.99,111.95 14.99,119.42 12.25,122.17 12.25,129.26 16.33,133.34 18.83,133.34 22.54,137.06 24.06,137.06 29.2,142.2 29.97,142.2 30.51,142.75 v1(30.51,143.26) ; v1(39.64,159.47) 39.64,160.51 42.53,163.4 44.34,163.4 46.33,165.38 48.56,165.38 50.34,167.16 51.45,167.16 52.44,168.15 55.89,168.15 59.27,171.53 62.68,171.53 65.65,168.55 66.94,168.55 68.99,166.5 v1(71.15,166.5)
  BOTTOM w0.102: v1(38.54,87.12) 38.54,86.45 37.95,85.86 v1(37.95,82.78) ; v1(53.86,105.64) 53.45,105.23 53.45,104.44 54.47,103.43 54.47,102.32 54.06,101.91 v1(54.06,101.27) 54.06,100.56 52.46,98.96 52.46,97.49 52.08,97.11 v1(52.08,96.39) ; v1(71.15,166.5) 71.15,166.62 76.72,172.19 76.72,225.88 79.61,228.78 SLOT1.B11 ; v1(39.64,159.47) 39.49,159.47 32.42,152.4 32.42,147.45 31.53,146.56 31.53,145.19 31.05,144.7 31.05,143.79 v1(30.51,143.26)
WAKE_SLOT_M2_N: length 127.1
  TOP w0.089: 52.61,111.25 52.61,111.38 54.14,112.9 54.14,113.23 54.84,113.93 55.09,113.93 55.18,114.03 55.18,114.23 55.21,114.26 55.21,114.63 55.26,114.68 55.26,115.24 U4.AF41
  TOP w0.102: 52.61,111.25 52.48,111.12 52.48,110.11 53.12,109.47 53.12,105.11 53.39,104.84 R112.1 54.52,104.58 54.52,104.37 54.69,104.19 54.69,100.61 54.94,100.36 XDP_PCH.15 54.94,98.32 54.44,97.82 v1(53.93,97.82) ; v1(85,89.66) 86.49,91.16 88.91,91.16 93.53,95.78 93.53,101.79 89.22,106.1 88.1,106.1 85.43,108.77 85.43,110.87 89.26,114.7 89.26,126.06 89.14,126.19 89.14,127 87.69,128.45 87.69,129.72 v1(87.41,130) ; v1(98.46,130.58) 98.46,131.38 RM4.1 ; v1(66.2,99.44) 65.92,99.16 59.94,99.16 59.51,98.73 59.51,97.98 58.84,97.31 56.85,97.31 55.53,95.99 53.75,95.99 v1(53.55,95.78)
  BOTTOM w0.102: v1(66.2,99.44) 66.71,98.93 67.09,98.93 67.52,99.36 71.19,99.36 71.97,98.58 74.45,98.58 76.31,96.72 76.31,96.07 82.62,89.76 83.16,89.76 83.62,89.76 84.16,89.23 84.56,89.23 v1(85,89.66) ; v1(98.46,130.58) 95.59,130.58 95.17,131 93.11,131 92.36,130.25 91.42,130.25 91.35,130.18 v2(88.3,130.18) 88.12,130 v1(87.41,130) ; v1(53.93,97.82) 53.93,96.16 v1(53.55,95.78)
X1_SMBCLK_R: length 9.4
  TOP w0.102: SLOT2.B5 59.37,234.38 59.33,234.24 59.39,234.11 59.54,233.96 60.74,233.96 61.37,234.6 61.37,234.85 62.24,235.71 63.18,235.71 63.93,234.97 64.98,234.97 65.14,234.81 65.74,234.81 RX19.2
X1_SMBDATA_R: length 9.7
  TOP w0.102: RX20.2 65.74,234.58 65.04,234.58 64.89,234.74 63.83,234.74 63.08,235.49 62.33,235.49 61.6,234.76 61.6,234.5 60.83,233.73 59.45,233.73 59.2,233.98 59.12,234.14 58.99,234.18 SLOT2.B6
X1_TCLK: length 6.7
  TOP w0.102: SLOT2.B9 60.95,231.55 63.28,231.55 63.94,230.89 65.44,230.89 65.69,231.14 RX18.2
X1_TDI: length 1.7
  TOP w0.102: SLOT2.A6 65.29,233.17 RX16.2
X1_TRST: length 4.9
  TOP w0.102: SLOT2.A5 62.68,234.15 64.3,232.54 65.18,232.54 65.57,232.16 RX17.2
X16_RST_SLOT_PEG#: length 3.2
  TOP w0.102: v1(49.44,252.73) 49.18,252.98 UX1.2 48.1,252.98 RX182.1
X16_RST_SLOT_PEG#_R: length 1.8
  TOP w0.102: RX182.2 45.75,251.9 v1(45.75,252.35) 45.75,252.48 46.12,252.84 U1.4
X16_SMBCLK_R: length 5.3
  TOP w0.102: SLOT1.B5 79.84,234.38 79.71,234.42 79.64,234.55 79.37,234.82 78.14,234.82 77.62,234.3 76.44,234.3 RX175.2
X16_SMBDATA_R: length 5
  TOP w0.102: SLOT1.B6 79.46,234.18 79.5,234.32 79.45,234.42 79.28,234.59 78.23,234.59 77.71,234.07 76.44,234.07 RX176.2
X16_TCLK: length 10.4
  TOP w0.102: RNX4.5 88.17,233.17 87.41,233.93 v1(87.1,233.93)
  BOTTOM w0.102: v1(87.1,233.93) 86.98,233.81 86.98,232.82 86.67,232.51 84.87,232.51 83.88,231.52 81.39,231.52 SLOT1.B9
X16_TDI: length 2.7
  TOP w0.102: RNX4.7 87.16,232.92 86.9,233.17 85.76,233.17 SLOT1.A6
X16_TMS: length 4
  TOP w0.102: RNX4.6 87.66,233.04 v1(87.41,233.3)
  BOTTOM w0.102: SLOT1.A8 85.38,231.78 85.43,231.83 86.39,231.83 87.41,232.84 v1(87.41,233.3)
X16_TRST: length 4.4
  TOP w0.102: RNX4.8 85.39,232.54 SLOT1.A5
X16_X_RST_SLOT_PEG#_R: length 5.1
  TOP w0.102: SLOT1.A11 84.35,227.58 85.95,227.58 RX6.1 RX7.1
X_EXP_A_TX_C_DN0: length 11.9
  TOP w0.102: CX16.2 87.85,222.66 87.71,222.66 87.45,222.92 v1(87.45,223.32)
  BOTTOM w0.102: v1(87.45,223.32) 87.05,223.32 86.82,223.55 86.01,223.55 85.38,222.91 84.46,222.91 83.5,221.95 80.07,221.95 79.63,222.38 79.63,223.02 79.7,223.14 80.04,223.26 80.58,222.99 SLOT1.B15
X_EXP_A_TX_C_DN1: length 10.2
  TOP w0.102: CX17.2 87.07,217.98 86.97,218.08 86.67,218.08 v1(86.39,217.8)
  BOTTOM w0.102: SLOT1.B20 79.06,218.19 79.44,218.19 80.05,217.58 83.3,217.58 84.43,218.7 85.26,218.7 85.83,218.14 86.06,218.14 v1(86.39,217.8)
X_EXP_A_TX_C_DN2: length 9.7
  TOP w0.102: v1(86.36,214.48) 86.64,214.77 86.9,214.77 87.08,214.59 CX23.2
  BOTTOM w0.102: v1(86.36,214.48) 86.08,214.77 84.53,214.77 83.56,213.79 79.96,213.79 79.63,214.12 78.99,214.12 SLOT1.B24
X_EXP_A_TX_C_DN3: length 10.3
  TOP w0.102: v1(86.17,211.07) 86.45,210.79 86.72,210.79 86.86,210.93 CX26.2
  BOTTOM w0.102: SLOT1.B28 79.41,210.54 79.41,211.11 80.09,211.79 83.48,211.79 84.47,210.79 85.88,210.79 v1(86.17,211.07)
X_EXP_A_TX_C_DN4: length 9.6
  TOP w0.102: CX28.2 86.89,204.56 86.72,204.73 86.47,204.73 v1(86.19,204.44)
  BOTTOM w0.102: SLOT1.B34 79.06,204.19 79.44,204.19 79.94,203.68 83.48,203.68 84.52,204.72 85.91,204.72 v1(86.19,204.44)
X_EXP_A_TX_C_DN5: length 9.5
  TOP w0.102: CX30.2 86.84,200.58 86.74,200.69 86.3,200.69 v1(86.02,200.41)
  BOTTOM w0.102: v1(86.02,200.41) 85.74,200.69 84.72,200.69 83.73,199.69 79.93,199.69 79.44,200.19 79.06,200.19 SLOT1.B38
X_EXP_A_TX_C_DN6: length 9.6
  TOP w0.102: v1(85.91,196.44) 86.19,196.72 86.7,196.72 86.8,196.62 CX32.2
  BOTTOM w0.102: SLOT1.B42 79.06,196.19 79.44,196.19 79.97,195.66 83.53,195.66 84.6,196.72 85.63,196.72 v1(85.91,196.44)
X_EXP_A_TX_C_DN7: length 9.5
  TOP w0.102: v1(86.1,192.44) 86.37,192.71 86.61,192.71 86.81,192.51 CX34.2
  BOTTOM w0.102: SLOT1.B46 79.06,192.19 79.44,192.19 79.96,191.67 83.58,191.67 84.6,192.68 85.86,192.68 v1(86.1,192.44)
X_EXP_A_TX_C_DN8: length 9.5
  TOP w0.102: CX36.2 86.81,186.64 86.71,186.74 86.28,186.74 v1(86,186.46)
  BOTTOM w0.102: SLOT1.B51 79.95,186.78 79.79,186.94 79.79,187.32 80.2,187.73 83.39,187.73 84.38,186.74 85.72,186.74 v1(86,186.46)
X_EXP_A_TX_C_DN9: length 9.5
  TOP w0.102: v1(85.99,182.34) 86.27,182.62 86.7,182.62 86.8,182.52 CX38.2
  BOTTOM w0.102: v1(85.99,182.34) 85.71,182.62 84.53,182.62 83.46,183.69 80.16,183.69 79.79,183.33 79.79,182.94 79.95,182.78 SLOT1.B55
X_EXP_A_TX_C_DN10: length 9.4
  TOP w0.102: v1(86.09,178.4) 86.37,178.69 86.65,178.69 86.8,178.54 CX98.2
  BOTTOM w0.102: SLOT1.B59 79.95,178.78 79.79,178.94 79.79,179.33 80.14,179.68 83.45,179.68 84.44,178.68 85.81,178.68 v1(86.09,178.4)
X_EXP_A_TX_C_DN11: length 9.5
  TOP w0.102: v1(85.94,174.47) 86.22,174.75 86.67,174.75 86.8,174.63 CX42.2
  BOTTOM w0.102: v1(85.94,174.47) 85.66,174.75 84.26,174.75 83.28,175.73 80.2,175.73 79.79,175.33 79.79,174.94 79.95,174.78 SLOT1.B63
X_EXP_A_TX_C_DN12: length 9.6
  TOP w0.102: v3(86.16,170.39) 86.47,170.7 86.68,170.7 86.93,170.46 CX44.2
  BOTTOM w0.102: v3(86.16,170.39) 85.87,170.69 84.3,170.69 83.26,171.73 80.2,171.73 79.79,171.33 79.79,170.94 79.95,170.78 SLOT1.B67
X_EXP_A_TX_C_DN13: length 9.5
  TOP w0.102: CX46.2 86.8,166.65 86.7,166.75 86.25,166.75 v1(85.97,166.47)
  BOTTOM w0.102: v1(85.97,166.47) 85.69,166.75 84.38,166.75 83.4,167.73 80.2,167.73 79.79,167.33 79.79,166.94 79.95,166.78 SLOT1.B71
X_EXP_A_TX_C_DN14: length 9.8
  TOP w0.102: v3(86.23,162.77) 86.23,162.9 86.39,163.07 86.65,163.07 CX99.2
  BOTTOM w0.102: v3(86.23,162.77) 85.93,163.07 85.79,163.07 85.43,162.7 84.34,162.7 83.32,163.73 80.2,163.73 79.79,163.33 79.79,162.94 79.95,162.78 SLOT1.B75
X_EXP_A_TX_C_DN15: length 9.9
  TOP w0.102: CX101.2 87.09,159.13 86.99,159.23 86.63,159.23 v1(86.35,158.95)
  BOTTOM w0.102: v1(86.35,158.95) 86.07,159.23 85.93,159.23 85.55,158.85 84.63,158.85 83.75,159.73 80.2,159.73 79.79,159.33 79.79,158.94 79.95,158.78 SLOT1.B79
X_EXP_A_TX_C_DP0: length 11.9
  TOP w0.102: CX15.2 87.54,222.35 87.54,222.5 87.26,222.78 v1(86.91,222.78)
  BOTTOM w0.102: SLOT1.B14 79.31,223.45 79.43,223.1 79.43,222.3 79.98,221.74 83.58,221.74 84.55,222.71 85.46,222.71 86.1,223.34 86.74,223.34 86.91,223.18 v1(86.91,222.78)
X_EXP_A_TX_C_DP1: length 10.1
  TOP w0.102: CX21.2 87.07,218.42 86.93,218.28 86.67,218.28 v1(86.39,218.56)
  BOTTOM w0.102: SLOT1.B19 80,218.78 79.76,218.53 79.76,218.15 80.13,217.78 83.22,217.78 84.34,218.91 85.34,218.91 85.91,218.34 86.16,218.34 v1(86.39,218.56)
X_EXP_A_TX_C_DP2: length 9.7
  TOP w0.102: v1(86.36,215.25) 86.64,214.97 86.89,214.97 87.08,215.16 CX22.2
  BOTTOM w0.102: SLOT1.B23 79.94,214.78 79.79,214.63 79.79,214.25 80.04,214 83.47,214 84.45,214.97 86.08,214.97 v1(86.36,215.25)
X_EXP_A_TX_C_DP3: length 10.3
  TOP w0.102: CX24.2 86.86,210.49 86.76,210.59 86.44,210.59 v1(86.17,210.31)
  BOTTOM w0.102: v1(86.17,210.31) 85.89,210.58 84.39,210.58 83.39,211.58 80.17,211.58 79.61,211.02 79.61,210.49 79.79,210.31 80.18,210.31 SLOT1.B27
