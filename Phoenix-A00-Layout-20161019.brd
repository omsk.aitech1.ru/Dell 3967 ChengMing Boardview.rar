# Allegro board Phoenix-A00-Layout-20161019.brd (continued)
## Nets (continued)
+3P3V_MAIN: BRIDGE.C7(VDD_33_9) BRIDGE.D5(VDD_33_7) BRIDGE.D9(VDD_33_8) BRIDGE.E4(VDD_33_6) BRIDGE.H3(VDD_33_5) BRIDGE.J4(VDD_33_3) BRIDGE.J12(VDD_33_4) BRIDGE.K9(VDD_33_2) BRIDGE.L8(VDD_33_1) C24.1 C25.1 C66.1 C67.1 C1646.2 C1808.1 CA23.1 CA89.1 CB4.1 CF13.2 CF19.1 CF103.1 CF104.1 CF105.1 CF106.1 CF107.1 CG17.2 CG19.2 CG25.2 CK7.1 CK9.1 CK26.1 CK28.1 CK29.1 CK39.1 CK40.1 CK41.1 CK42.1 CK43.1 CK44.1 CK45.1 CK46.1 CK47.1 CK58.1 CK63.1 CK65.1 CK68.1 CM5.1 CM6.1 CO3.2 CS111.2 CS118.1 CS120.1 CS128.1 CS129.1 CS131.1 CS132.1 CS133.1 CS171.1 CS175.1 CS176.1 CS177.1 CS180.1 CS181.1 CS182.1 CS183.1 CS184.1 CS185.1 CS186.1 CS187.1 CS188.1 CS189.1 CS190.1 CS191.1 CS192.1 CS193.1 CS194.1 CS195.1 CS196.1 CS197.1 CS198.1 CS199.1 CS200.1 CS201.1 CS202.1 CS203.1 CS204.1 CS205.1 CS206.1 CS207.1 CX14.1 CX20.1 CX55.1 CX56.1 DIMM1.284(VDDSPD) DIMM2.140(SA1) DIMM2.284(VDDSPD) ECK3.1 ECK6.1 ECX11.1 EEPROM_G.3(E2) EEPROM_G.8(VCC) FBA4.1 FBA5.1 FBG1.1 FBG2.1 FBK3.1 LPC_DEBUG.4 M.2_SSD.2(3P3V_9) M.2_SSD.4(3P3V_8) M.2_SSD.12(3P3V_7) M.2_SSD.14(3P3V_6) M.2_SSD.16(3P3V_5) M.2_SSD.18(3P3V_4) M.2_SSD.70(3P3V_3) M.2_SSD.72(3P3V_2) M.2_SSD.74(3P3V_1) PC303.1 PC344.1 PC345.1 PCE32.1 PQ51.S(SOURCE) PR141.1 PR198.1 PR202.1 PR215.1 PR242.1 PR336.1 R20.2 R79.1 R495.1 R497.1 R6369.1 R6403.1 R6427.2 R6431.2 R6540.1 R6586.1 RA69.1 RF9.2 RF55.2 RF63.1 RF64.1 RF77.1 RG5.1 RG6.1 RG7.2 RG9.1 RG11.1 RG13.1 RG25.2 RG31.2 RH7.2 RI1.2 RI2.2 RI3.2 RI4.2 RIO6.1 RK22.1 RK38.2 RK46.2 RK47.2 RK48.2 RL1.1 RL34.1 RL41.1 RM3.1 RM6.1 RM7.1 RNF2.1 RNF2.2 RNF2.3 RNO1.1 RNO1.2 RNO1.3 RNO1.4 RNO2.5 RNO2.6 RNO2.7 RNO2.8 RNX4.2 RNX4.3 RO23.1 RO25.1 RO26.1 RO27.1 RO43.1 RO44.1 RO51.1 RO168.1 RO170.1 RO172.1 RTK_VGA.5(DVCC_33_1) RTK_VGA.20(DVCC_33_2) RV77.1 RV86.2 RV87.2 RX16.1 RX185.1 SATA_PWR.5 SIO_5553.4(VCC) SLOT1.A9(+3.3V_2) SLOT1.A10(+3.3V_3) SLOT1.B8(+3.3V_1) SLOT2.A9(+3.3V_2) SLOT2.A10(+3.3V_3) SLOT2.B8(+3.3V_1) SLOT3.A21(+3.3V1) SLOT3.A27(+3.3V3) SLOT3.A33(+3.3V5) SLOT3.A39(+3.3V7) SLOT3.A45(+3.3V10) SLOT3.A53(+3.3V11) SLOT3.B25(+3.3V2) SLOT3.B31(+3.3V4) SLOT3.B36(+3.3V6) SLOT3.B41(+3.3V8) SLOT3.B43(+3.3V9) SLOT3.B54(+3.3V12) SLOT4.A21(+3.3V1) SLOT4.A27(+3.3V3) SLOT4.A33(+3.3V5) SLOT4.A39(+3.3V7) SLOT4.A45(+3.3V10) SLOT4.A53(+3.3V11) SLOT4.B25(+3.3V2) SLOT4.B31(+3.3V4) SLOT4.B36(+3.3V6) SLOT4.B41(+3.3V8) SLOT4.B43(+3.3V9) SLOT4.B54(+3.3V12) U4.AD13(VCCATS_1P8) U136.B2(VDD) UA2.1(S\H\D\N\) UA2.3(VIN) UF2.9(VDD1) UF2.20(VDD2) UF2.25(VDD3) UF3.6(VDD) UK2.1(S\H\D\N\) UK2.3(VIN)
+3P3V_PCIAUX: CK32.1 CK66.1 CX25.1 CX57.1 ECX12.1 PC26.1 PQ11.D(DRAIN) PQ13.1(DRAIN1) PQ13.2(DRAIN2) PQ13.5(DRAIN3) PQ13.6(DRAIN4) PR32.1 SLOT1.B10(3.3VAUX) SLOT2.B10(3.3VAUX) SLOT3.A14(SB3V) SLOT4.A14(SB3V)
+3P3V_SB: C1647.1 C1807.2 CA106.2 CL55.1 CL56.1 CL57.1 CO1.2 CO2.2 CO4.2 CO5.2 CO6.2 CO7.2 CO8.2 CO9.2 CO13.2 CO19.1 CO20.1 CX1.2 PC17.1 PC18.1 PC24.1 PC25.1 PC309.1 PC333.1 PCE37.1 PJP31.1 PL13.2 PQ2.4(SOURCE) PQ7.S(SOURCE) PQ11.S(SOURCE) PQ13.4(SOURCE) PQ51.D(DRAIN) PR61.1 PR269.1 PR387.1 QL7.S(SOURCE) R6435.1 R6438.1 R6541.1 R6544.2 R6590.1 R6658.1 R6664.1 RA2.2 RB2.1 RIO2.1 RL3.1 RL39.1 RL40.1 RL43.1 RO31.1 SIO_5553.22(V3_DUAL1) SIO_5553.32(V3_DUAL2) SIO_5553.45(HV3_DUAL) SIO_5553.55(V3_DUAL3) SIO_5553.60(V3_DUAL4) SIO_5553.65(V3_DUAL5) SIO_5553.77(V3_DUAL6) SIO_5553.104(V3_DUAL7) SIO_5553.120(V3_DUAL8) U1.5(VCC) U4.BA24(VCCDSW_3P3<1>) U4.W15(VCCDSW_3P3<0>) UX1.5(VCC)
+3P3V_SB_BOOT_20: PR262.1 PU16.9(BOOT2)
+3P3V_SB_BOOTR_20: PC329.1 PR262.2
+3P3V_SB_CS: PR274.1 PU16.5(CS2)
+3P3V_SB_FB: PC334.2 PR265.2 PR267.1 PR268.1 PU16.4(FB2)
+3P3V_SB_FB_R: PC334.1 PJP31.2 PR265.1
+3P3V_SB_LG_25: PQ61.4(G) PU16.11(LGATE2)
+3P3V_SB_PHASE_25: PC329.2 PC330.1 PL13.1 PQ59.1(S1) PQ59.2(S2) PQ59.3(S3) PQ61.5(D1) PR260.2 PU16.8(PHASE2)
+3P3V_SB_PHASE_R: PC330.2 PR263.1
+3P3V_SB_UG25: PR258.1 PU16.10(UGATE2)
+3P3V_SB_UGR_25: PQ59.4(G) PR258.2 PR260.1
+5V/3P3V_VIN: PC325.2 PR256.2 PU16.12(VIN)
+DDR_PGOOD: PC35.1 PR43.2 PU2.1(PGOOD) R6296.2
+VCORE: CPU.A25(VCC_113) CPU.A26(VCC_112) CPU.A27(VCC_111) CPU.A28(VCC_110) CPU.A29(VCC_109) CPU.A30(VCC_108) CPU.AJ11(VCC_119) CPU.AJ12(VCC_127) CPU.AJ13(VCC_120) CPU.AJ14(VCC_126) CPU.AJ15(VCC_118) CPU.AJ16(VCC_125) CPU.AJ17(VCC_116) CPU.AJ18(VCC_124) CPU.AJ19(VCC_117) CPU.AJ20(VCC_123) CPU.AJ21(VCC_121) CPU.AJ22(VCC_122) CPU.B25(VCC_107) CPU.B27(VCC_106) CPU.B29(VCC_105) CPU.B31(VCC_104) CPU.B32(VCC_103) CPU.B33(VCC_102) CPU.B34(VCC_101) CPU.B35(VCC_100) CPU.B36(VCC_99) CPU.B37(VCC_98) CPU.C25(VCC_97) CPU.C26(VCC_96) CPU.C27(VCC_63) CPU.C28(VCC_95) CPU.C29(VCC_60) CPU.C30(VCC_94) CPU.C32(VCC_93) CPU.C34(VCC_92) CPU.C36(VCC_91) CPU.D25(VCC_90) CPU.D27(VCC_89) CPU.D29(VCC_88) CPU.D31(VCC_87) CPU.D32(VCC_58) CPU.D33(VCC_86) CPU.D34(VCC_85) CPU.D35(VCC_56) CPU.D36(VCC_84) CPU.E24(VCC_83) CPU.E25(VCC_82) CPU.E26(VCC_54) CPU.E27(VCC_81) CPU.E28(VCC_44) CPU.E29(VCC_114) CPU.E30(VCC_80) CPU.E32(VCC_79) CPU.E34(VCC_78) CPU.E36(VCC_77) CPU.F23(VCC_76) CPU.F24(VCC_75) CPU.F25(VCC_74) CPU.F27(VCC_73) CPU.F29(VCC_115) CPU.F31(VCC_41) CPU.F32(VCC_72) CPU.F33(VCC_71) CPU.F34(VCC_40) CPU.G23(VCC_70) CPU.G24(VCC_69) CPU.G25(VCC_68) CPU.G26(VCC_37) CPU.G27(VCC_67) CPU.G28(VCC_35) CPU.G29(VCC_66) CPU.G30(VCC_65) CPU.G32(VCC_64) CPU.H22(VCC_62) CPU.H23(VCC_61) CPU.H25(VCC_59) CPU.H27(VCC_57) CPU.H29(VCC_55) CPU.H31(VCC_53) CPU.H32(VCC_33) CPU.J21(VCC_52) CPU.J22(VCC_51) CPU.J23(VCC_50) CPU.J24(VCC_31) CPU.J25(VCC_49) CPU.J26(VCC_29) CPU.J27(VCC_48) CPU.J28(VCC_15) CPU.J29(VCC_47) CPU.J30(VCC_46) CPU.J31(VCC_45) CPU.K16(VCC_43) CPU.K18(VCC_42) CPU.K20(VCC_39) CPU.K21(VCC_38) CPU.K23(VCC_36) CPU.K25(VCC_34) CPU.K27(VCC_32) CPU.K29(VCC_30) CPU.K31(VCC_28) CPU.L14(VCC_27) CPU.L15(VCC_26) CPU.L16(VCC_13) CPU.L17(VCC_25) CPU.L18(VCC_11) CPU.L19(VCC_24) CPU.L20(VCC_9) CPU.L21(VCC_23) CPU.L22(VCC_7) CPU.L23(VCC_22) CPU.L24(VCC_5) CPU.L25(VCC_21) CPU.L26(VCC_3) CPU.L27(VCC_20) CPU.L28(VCC_1) CPU.L29(VCC_19) CPU.L30(VCC_18) CPU.M13(VCC_17) CPU.M14(VCC_16) CPU.M16(VCC_14) CPU.M18(VCC_12) CPU.M20(VCC_10) CPU.M22(VCC_8) CPU.M24(VCC_6) CPU.M26(VCC_4) CPU.M28(VCC_2) CPU.M30(VCC_0) PC128.1 PC129.1 PC130.1 PC131.1 PC132.1 PC133.1 PC134.1 PC135.1 PC136.1 PC137.1 PC138.1 PC139.1 PC140.1 PC141.1 PC142.1 PC143.1 PC144.1 PC148.1 PC149.1 PC150.1 PCE15.1 PCE16.1 PCE17.1 PCE18.1 PCE19.1 PJP10.1 PJP12.1 PJP14.1 PL5.2 PL7.2 PL8.2 PR150.1
+VPP: C22.1 C23.1 C64.1 C65.1 DIMM1.142(VPP_0) DIMM1.143(VPP_1) DIMM1.286(VPP_2) DIMM1.287(VPP_3) DIMM1.288(VPP_4) DIMM2.142(VPP_0) DIMM2.143(VPP_1) DIMM2.286(VPP_2) DIMM2.287(VPP_3) DIMM2.288(VPP_4) PC236.1 PC310.1 PC311.1 PC312.1 PC313.1 PJP32.2 PL15.2 PR386.1
+VPP_BST: PR384.1 PU18.5(BOOT)
+VPP_BST_RC: PC234.1 PR384.2
+VPP_EN: PC240.2 PQ22.D2 PR279.2 PU18.6(EN/SYNC)
+VPP_FB: PR385.1 PU18.8(FB)
+VPP_FB_R: PC348.2 PJP32.1 PR282.2
+VPP_FB_RC: PC348.1 PR282.1 PR283.1 PR284.1 PR385.2
+VPP_LSN: PC342.2 PR380.1
+VPP_PG: PC241.1 PR358.2 PU18.1(PG)
+VPP_PVCC: PC349.1 PU18.7(PVCC)
+VPP_SW: PC234.2 PC342.1 PL15.1 PU18.3(SW)
+VPP_VIN: PC229.1 PC230.1 PC231.1 PFB12.1 PU18.2(VIN)
+VTT: C20.1 C21.1 C62.1 C63.1 DIMM1.77(VTT_0) DIMM1.221(VTT_1) DIMM2.77(VTT_0) DIMM2.221(VTT_1) PC50.1 PR56.1 PU3.4(VOUT)
A_CBN: CA91.2 UA1.35(CBN)
A_CBP: CA91.1 UA1.37(CBP)
A_CPVEE: CA90.2 UA1.34(CPVEE)
A_EAPD_R: R6538.1 U136.B1(M\U\T\E\)
A_FP_PRES#: RA69.2 U4.R36(GPP_G13_GSXSLOAD)
A_GND: CA1.2 CA3.2 CA4.2 CA5.1 CA6.2 CA7.2 CA12.2 CA74.1 CA75.1 CA76.1 CA77.1 CA78.2 CA80.2 CA102.2 CA103.2 CA104.1 CA105.1 CA106.1 CA107.1 CA108.1 CA109.1 CA110.1 CA116.1 CA117.2 CA118.2 CA119.2 CA120.2 CA121.2 CA124.1 CA125.1 CA126.1 F_AUDIO.5 F_AUDIO.7(HOLD1) F_AUDIO.8(HOLD2) QA4.S(SOURCE) RA1.2 RA42.1 RA43.1 RA44.1 REAR_AUDIO.1 REAR_AUDIO.3 UA1.25(AVSS1) UA1.38(AVSS2)
A_GND_C: CA117.1 U136.A2(GND)
A_HPOUT-L_R: IO_FBI9.1 RA74.2
A_HPOUT-R_R: IO_FBI10.1 RA75.2
A_JD1: CA105.2 RA16.1 RA18.1 UA1.13(HP/LINE1 JD(JD1))
A_JD2: CA104.2 RA15.1 RA17.1 UA1.14(MIC2/LINE2 JD(JD2))
A_LDO1_C: CA1.1 RA1.1 UA1.27(LDO1-CAP)
A_LDO3_C: CA18.2 UA1.7(LDO3-CAP)
A_LINE1-L_C: CA123.2 RA41.1
A_LINE1-R_C: CA122.2 RA40.1
A_LINE2_L_C: CA85.2 RA71.1
A_LINE2_R_C: CA83.2 RA70.1
A_MIC_C: CA12.1 UA1.19(MIC_CAP)
A_PCBEEP_C: CA17.2 CA92.1 RA4.1 RA5.1 RA6.1
A_PVDD1: CA10.1 CA11.2 CA15.1 CA16.2 FBA3.2 UA1.41(PVDD1) UA1.46(PVDD2)
A_QA3_G: CS69.1 QA3.G(GATE) R6540.2 RA58.2
A_QA4_G: QA3.D(DRAIN) QA4.G(GATE) R6539.2 R6541.2
A_SET: CA116.2 U136.B3(SET)
A_SPEAKER_C: CA19.1 RA5.2
A_SPKR_C: CA20.1 RA4.2
A_USB2_COMP: R6466.2 U4.AG3(USB2_COMP)
A_VD33_STB: CA103.1 RA2.1 UA1.20(VD33 STB)
A_VREF: CA5.2 UA1.28(VREF)
APS_PIN1: APS/PETS.1 RB1.2
APS_PIN2: APS/PETS.2 RB8.1
APS_PIN3: APS/PETS.3 RB2.2
APS_PIN4: APS/PETS.4 RB7.1 RB9.1
APS_PIN5: APS/PETS.5 RB3.2
APS_PIN6: APS/PETS.6 RB10.1
APS_PIN9: APS/PETS.9 RB4.2
APS_PIN11: APS/PETS.11 RB5.2
APS_PIN13: APS/PETS.13 RB6.2
APU_PCI_BCLK: CPU.W1(PCI_BCLK) U4.J2(CLKOUT_CPUPCIBCLKP)
APU_PCI_BCLK#: CPU.W2(PCI_BCLK#) U4.J1(CLKOUT_CPUPCIBCLKN)
APU_RST: CPU.E7(RESET#) R6575.2
AUD_BITCLK: R6339.1 RA19.1
AUD_BITCLK_R: CA29.1 RA19.2 UA1.6(BCLK)
AUD_LINK_RESET#: CA25.1 R6341.1 RA36.1 RA58.1 UA1.11(RESETB)
AUD_LINK_SDI0: RA20.2 U4.BE7(HDA_SDI0)
AUD_LINK_SDIO_R: RA20.1 UA1.8(SDATA-IN)
AUD_SYNC: CA24.1 R6348.1 UA1.10(SYNC)
AUX_N: CG2.2 RG7.1 RTK_VGA.27(AUX_N)
AUX_P: CG1.2 RG8.1 RTK_VGA.26(AUX_P)
B_ATX_PWROK: ATX_SYS.4 PC301.1 PQ52.G1 PQ57.G(GATE) PR65.2 PR230.2
BATT1: BATTERY.1(POS1) R6453.1
BATT_R_2: D1.1(NODE1) D5.2(NODE2) R6453.2
BRG_CLK_F3: BRIDGE.F3(CLK) RK6.1
BRG_REF0_PCIE: BRIDGE.K12(REF0_PCIE) RK8.2
BRG_REF1_PCIE: BRIDGE.K13(REF1_PCIE) RK7.2
BRG_REF01_PCIE_R: RK7.1 RK8.1
BRG_RXN: BRIDGE.E12(RXN) CX118.2
BRG_RXP: BRIDGE.E13(RXP) CX119.2
BRG_TP_L10: BRIDGE.L10(JTAG_TMS) TPS108.1(TP)
BRG_TP_M11: BRIDGE.M11(JTAG_TDO) TPS107.1(TP)
BRG_TP_N12: BRIDGE.N12(JTAG_TDI) TPS106.1(TP)
BRG_TXN: BRIDGE.G12(TXN) CX126.2
BRG_TXP: BRIDGE.G13(TXP) CX127.2
BRG_VDD_15_COMB: BRIDGE.L13(VDD_15_COMB) CK16.1 CK19.1 CK20.1
BRG_VDD_33_COMB: BRIDGE.J13(VDD_33_COMB) CK8.1 CK10.1 CK11.1
BRG_VDD_33_COMBIO: BRIDGE.K11(VDD_33_COMBIO) CK13.1 CK14.1 CK15.1
BT_USB2_N6: LU23.1 RU62.1 U4.AF2(USB2N6)
BT_USB2_N8: LU24.2 RU67.1 U4.AL8(USB2N8)
BT_USB2_P6: LU23.2 RU63.1 U4.AF3(USB2P6)
BT_USB2_P8: LU24.1 RU66.1 U4.AL7(USB2P8)
C_CLK_OUT0: BRIDGE.B5(CLKOUT0) RK18.1
C_CLK_OUT1: BRIDGE.B6(CLKOUT1) RK56.1
C_PCI_SL1: RK18.2 SLOT3.B16(CLK)
C_PCI_SL2: RK56.2 SLOT4.B16(CLK)
CFG0: CPU.H15(CFG[0]) R39.2 R6682.1 XDP_CPU.9(OBSDATA_A0)
CFG1: CPU.F15(CFG[1]) R40.2 XDP_CPU.11(OBSDATA_A1)
CFG2: CPU.F16(CFG[2]) R45.2 XDP_CPU.15(OBSDATA_A2)
CFG3: CPU.H16(CFG[3]) R46.2 R97.1 XDP_CPU.17(OBSDATA_A3)
CFG4: CPU.F19(CFG[4]) R47.2 XDP_CPU.27(OBSDATA_B0)
CFG5: CPU.H18(CFG[5]) R38.2 XDP_CPU.29(OBSDATA_B1)
CFG6: CPU.G21(CFG[6]) R1.2 XDP_CPU.33(OBSDATA_B2)
CFG7: CPU.H20(CFG[7]) R12.2 XDP_CPU.35(OBSDATA_B3)
CFG8: CPU.G16(CFG[8]) R15.2 XDP_CPU.10(OBSDATA_C0)
CFG9: CPU.E16(CFG[9]) R16.2 XDP_CPU.12(OBSDATA_C1)
CFG10: CPU.F17(CFG[10]) R17.2 XDP_CPU.16(OBSDATA_C2)
CFG11: CPU.H17(CFG[11]) R21.2 XDP_CPU.18(OBSDATA_C3)
CFG12: CPU.G20(CFG[12]) R22.2 XDP_CPU.28(OBSDATA_D0)
CFG13: CPU.F20(CFG[13]) R25.2 XDP_CPU.30(OBSDATA_D1)
CFG14: CPU.F21(CFG[14]) R26.2 XDP_CPU.34(OBSDATA_D2)
CFG15: CPU.H19(CFG[15]) R27.2 XDP_CPU.36(OBSDATA_D3)
CFG16: CPU.E14(CFG[16]) R30.2 XDP_CPU.6(OBSFN_C1)
CFG17: CPU.F14(CFG[17]) R31.2 XDP_CPU.4(OBSFN_C0)
CFG18: CPU.G18(CFG[18]) R33.2 XDP_CPU.24(OBSFN_D1)
CFG19: CPU.F18(CFG[19]) R37.2 XDP_CPU.22(OBSFN_D0)
CFG_RCOMP: CPU.M11(CFG_RCOMP) R49.2
CIIC_SCL: RG3.1 RG5.2 RTK_VGA.2(SMB_SCL)
CIIC_SDA: RG4.1 RG6.2 RTK_VGA.3(SMB_SDA)
CK_100M_H_ITP: U4.L2(CLKOUT_ITPXDPP) XDP_CPU.40(ITP_CLKP/HOOK4)
CK_100M_H_ITP#: U4.L1(CLKOUT_ITPXDPN) XDP_CPU.42(ITP_CLKN/HOOK5)
CK_PE_100M_DMI: CPU.W5(BCLK) U4.G2(CLKOUT_CPUBCLKP)
CK_PE_100M_DMI#: CPU.W4(BCLK#) U4.H2(CLKOUT_CPUBCLKN)
CKBCLK: C410.1 KYBD_MOUSE.5 L15.2 UU27.6(I/O_4)
CKBDATA: C411.1 KYBD_MOUSE.1 L13.2 UU27.1(I/O_1)
CL_CLK_WLAN: U4.AV2(CL_CLK) WF_BT_USB.11
CL_DATA_WLAN: U4.AV3(CL_DATA) WF_BT_USB.13
CL_RST_WLAN#: U4.AW2(CL_RST_N) WF_BT_USB.12
CL_SENCE#: R6533.2 U4.U35(GPP_G21) WF_BT_USB.14
CLASSD_L+: CA79.2 CA84.2 CA86.1 INT_SPKR.1 IO_FBI14.1 IO_FBI14.2 UA1.42(SPK-OUT-L+)
CLASSD_L-: CA82.1 CA86.2 CA87.1 INT_SPKR.2 IO_FBI13.1 IO_FBI13.2 UA1.43(SPK-OUT-L-)
CLK_24M_N: CPU.J9(CLK24#) U4.F1(CLKOUT_CPUNSSCN)
CLK_24M_P: CPU.K9(CLK24) U4.G1(CLKOUT_CPUNSSCP)
CLK_REQ2_LAN_N: RL32.1 U4.AT24(GPP_B7_SRCCLKREQ2_N)
CLKOUT_PCI0: R6393.2 R6615.2 U4.BC17(GPP_A9_CLKOUT_LPC0_ESPI_CLK)
CLKOUT_PCIE2: RTK_LAN.15(REFCLK_F) U4.F2(CLKOUT_PCIE_P2)
CLKOUT_PCIE2#: RTK_LAN.16(REFCLK_N) U4.D3(CLKOUT_PCIE_N2)
CLKOUT_PCIE3: RM16.1 U4.G4(CLKOUT_PCIE_P3)
CLKOUT_PCIE3#: RM15.1 U4.E5(CLKOUT_PCIE_N3)
CLKOUT_PCIE8: SLOT1.A13(REFCLK+) U4.W11(CLKOUT_PCIE_P8)
CLKOUT_PCIE8#: SLOT1.A14(REFCLK-) U4.W10(CLKOUT_PCIE_N8)
CLKOUT_PCIE10: BRIDGE.C13(REFCLK+) U4.P2(CLKOUT_PCIE_P10)
CLKOUT_PCIE10#: BRIDGE.C12(REFCLK-) U4.P3(CLKOUT_PCIE_N10)
CLKOUT_PCIE11: SLOT2.A13(REFCLK+) U4.R4(CLKOUT_PCIE_P11)
CLKOUT_PCIE11#: SLOT2.A14(REFCLK-) U4.R3(CLKOUT_PCIE_N11)
CLKREQB: RL1.2 RL32.2 RTK_LAN.12(CLKREQB)
CLKRUN_EN: BRIDGE.A13(CLKRUN_EN) RK41.2
CMCLR_2: P2.2 RS166.1
CMSCLK: C413.1 KYBD_MOUSE.11 L14.2 UU27.3(I/O_2)
CMSDATA: C412.1 KYBD_MOUSE.7 L16.2 UU27.4(I/O_3)
COMP_R: PR143.2 PR144.2
COMPA_R: PR154.2 PR155.1
CPU_FAN_+12V: CF3.1 FAN_CPU.3 RF10.1
CPU_PCH_TRIGGER_OUT: R6614.2 U4.AK1(TRIGGER_IN)
CPU_PCH_TRIGGER_OUT_R: CPU.B3(PROC_TRIGOUT) R6614.1
CPU_PRDY_N: CPU.B10(PRDY#) R48.1 R148.1 XDP_CPU.5(OBSFN_A1)
CPU_PREQ_N: CPU.B9(PREQ#) R116.2 R149.1 XDP_CPU.3(OBSFN_A0)
CPU_SELECT#: CPU.AB36(SELECT#) R6579.2 R6665.2
CS1+_RT3607: PC85.2 PR101.1 PU7.5(ISEN1P)
CS1-_RT3607: PR106.1 PU7.4(ISEN1N)
CS2+_RT3607: PC87.2 PR116.1 PU7.6(ISEN2P)
CS2-_RT3607: PR117.1 PU7.7(ISEN2N)
CS2_LFRAM#: RF28.1 RF43.2
CS3+_RT3607: PC91.2 PR123.1 PU7.2(ISEN3P)
CS3-_RT3607: PR126.1 PU7.3(ISEN3N)
CS4-_RT3607: PR137.1 PU7.8(ISEN4N) PU7.9(ISEN4P)
D1_1: C766.1 D1.2(NODE2) R6590.2 R6591.1
DDPB_CTRLCLK: RV75.1 RV86.1 U4.BA5(GPP_I5_DDPB_CTRLCLK)
DDPB_CTRLDATA: RV84.1 RV87.1 U4.BC4(GPP_I6_DDPB_CTRLDATA)
DDR4_DRAMRST#: DIMM1.58(RESET_N) DIMM2.58(RESET_N) RD4.2
DDR_VTT_CNTL: CPU.AC36(DDR_VTT_CNTL) PR57.2
DEPOP_LEFT: IO_FBI11.1 RA71.2 U136.A1(INL)
DEPOP_LEFT_F: CA80.1 DA6.2(IO2) IO_FBI11.2 REAR_AUDIO.2
DEPOP_RIGHT: IO_FBI12.1 RA70.2 U136.A3(INR)
DEPOP_RIGHT_F: CA78.1 DA6.1(IO1) IO_FBI12.2 REAR_AUDIO.5
DIMM_DQ_CPU_VREF_A: CPU.AC40(SA_DIMM_VREFDQ) TPS46.1(TP)
DIMMA_VREF_RC: RD6.2 RD7.1 RD8.1
DIMMB_VREF_RC: R61.2 R62.1 R65.1
DMI_CPU_PCH_RXN0: CPU.AC1(DMI_TX#[0]) U4.L27(DMI_RXN0)
DMI_CPU_PCH_RXN1: CPU.AD2(DMI_TX#[1]) U4.E24(DMI_RXN1)
DMI_CPU_PCH_RXN2: CPU.AE1(DMI_TX#[2]) U4.G27(DMI_RXN2)
DMI_CPU_PCH_RXN3: CPU.AF3(DMI_TX#[3]) U4.L29(DMI_RXN3)
DMI_CPU_PCH_RXP0: CPU.AC2(DMI_TX[0]) U4.N27(DMI_RXP0)
DMI_CPU_PCH_RXP1: CPU.AD3(DMI_TX[1]) U4.G24(DMI_RXP1)
DMI_CPU_PCH_RXP2: CPU.AE2(DMI_TX[2]) U4.E26(DMI_RXP2)
DMI_CPU_PCH_RXP3: CPU.AF2(DMI_TX[3]) U4.K29(DMI_RXP3)
DMI_PCH_CPU_RXN0: CPU.Y4(DMI_RX#[0]) U4.C27(DMI_TXN0)
DMI_PCH_CPU_RXN1: CPU.AA5(DMI_RX#[1]) U4.B28(DMI_TXN1)
DMI_PCH_CPU_RXN2: CPU.AB3(DMI_RX#[2]) U4.B29(DMI_TXN2)
DMI_PCH_CPU_RXN3: CPU.AC5(DMI_RX#[3]) U4.B30(DMI_TXN3)
DMI_PCH_CPU_RXP0: CPU.Y3(DMI_RX[0]) U4.B27(DMI_TXP0)
DMI_PCH_CPU_RXP1: CPU.AA4(DMI_RX[1]) U4.A28(DMI_TXP1)
DMI_PCH_CPU_RXP2: CPU.AB4(DMI_RX[2]) U4.C29(DMI_TXP2)
DMI_PCH_CPU_RXP3: CPU.AC4(DMI_RX[3]) U4.A30(DMI_TXP3)
DP_HPD: QG1.D(DRAIN) R6636.1 RG28.2 RG30.2 RH7.1 RTK_VGA.1(HPD) U4.R43(GPP_G9_FAN_PWM_1)
DPB_HPD_R: QV49.S(SOURCE) RV77.2 U4.AW4(GPP_I0_DDPB_HPD0) U4.T45(GPP_G6_FAN_TACH_6)
DPB_LANE_DN0_C: CPU.D21(DDIB_TXB#[0]) CV33.1
DPB_LANE_DN1_C: CPU.E22(DDIB_TXB#[1]) CV35.1
DPB_LANE_DN2_C: CPU.A23(DDIB_TXB#[2]) CV37.1
DPB_LANE_DN3_C: CPU.D23(DDIB_TXB#[3]) CV39.1
DPB_LANE_DP0_C: CPU.C21(DDIB_TXB[0]) CV32.1
DPB_LANE_DP1_C: CPU.D22(DDIB_TXB[1]) CV34.1
DPB_LANE_DP2_C: CPU.B23(DDIB_TXB[2]) CV36.1
DPB_LANE_DP3_C: CPU.C23(DDIB_TXB[3]) CV38.1
EAPD: R6538.2 RA7.1
EAPD_R: RA7.2 RA37.2 UA1.4(DC DET)
EDP_AUX_DN_C: CG2.1 CPU.E12(EDP_AUX#)
EDP_AUX_DP_C: CG1.1 CPU.D12(EDP_AUX)
EDP_HPD_DDPE: RG30.1 U4.BA4(GPP_I3_DDPE_HPD3)
EDP_HPD_R: QG1.S(SOURCE) RG28.1 U4.BD7(GPP_I4_EDP_HPD)
EDP_LANE_DN2_C: CG4.1 CPU.H10(EDP_TX#[2])
EDP_LANE_DN3_C: CG6.1 CPU.G9(EDP_TX#[3])
EDP_LANE_DP2_C: CG3.1 CPU.G10(EDP_TX[2])
EDP_LANE_DP3_C: CG5.1 CPU.F9(EDP_TX[3])
EDP_RCOMP: CPU.M9(EDP_RCOMP) R6290.2
ESPI_ALERT0: R6391.2 U4.AW17(GPP_A7_PIRQA_N_ESPI_ALERT0_N)
EVENT_A_R: DIMM1.78(EVENT_N) RD5.2
EVENT_B_R: DIMM2.78(EVENT_N) R60.2
EXP_A_PRSNT2#: R6619.2 SLOT1.B17(PRSNT2#_1) SLOT1.B31(PRSNT2#_2) SLOT1.B48(PRSNT2#_3) SLOT1.B81(PRSNT2#_4) U4.BE25(GPP_B10_SRCCLKREQ5_N)
EXP_A_RXN_0: CPU.B7(PEG_RX#[0]) SLOT1.A17(PERN0)
EXP_A_RXN_1: CPU.C6(PEG_RX#[1]) SLOT1.A22(PERN1)
EXP_A_RXN_2: CPU.D5(PEG_RX#[2]) SLOT1.A26(PERN2)
EXP_A_RXN_3: CPU.E4(PEG_RX#[3]) SLOT1.A30(PERN3)
EXP_A_RXN_4: CPU.F5(PEG_RX#[4]) SLOT1.A36(PERN4)
EXP_A_RXN_5: CPU.G4(PEG_RX#[5]) SLOT1.A40(PERN5)
EXP_A_RXN_6: CPU.H5(PEG_RX#[6]) SLOT1.A44(PERN6)
EXP_A_RXN_7: CPU.J4(PEG_RX#[7]) SLOT1.A48(PERN7)
EXP_A_RXN_8: CPU.K5(PEG_RX#[8]) SLOT1.A53(PERN8)
EXP_A_RXN_9: CPU.L4(PEG_RX#[9]) SLOT1.A57(PERN9)
EXP_A_RXN_10: CPU.M5(PEG_RX#[10]) SLOT1.A61(PERN10)
EXP_A_RXN_11: CPU.N4(PEG_RX#[11]) SLOT1.A65(PERN11)
EXP_A_RXN_12: CPU.P5(PEG_RX#[12]) SLOT1.A69(PERN12)
EXP_A_RXN_13: CPU.R4(PEG_RX#[13]) SLOT1.A73(PERN13)
EXP_A_RXN_14: CPU.T5(PEG_RX#[14]) SLOT1.A77(PERN14)
EXP_A_RXN_15: CPU.U4(PEG_RX#[15]) SLOT1.A81(PERN15)
EXP_A_RXP_0: CPU.B8(PEG_RX[0]) SLOT1.A16(PERP0)
EXP_A_RXP_1: CPU.C7(PEG_RX[1]) SLOT1.A21(PERP1)
EXP_A_RXP_2: CPU.D6(PEG_RX[2]) SLOT1.A25(PERP2)
EXP_A_RXP_3: CPU.E5(PEG_RX[3]) SLOT1.A29(PERP3)
EXP_A_RXP_4: CPU.F6(PEG_RX[4]) SLOT1.A35(PERP4)
EXP_A_RXP_5: CPU.G5(PEG_RX[5]) SLOT1.A39(PERP5)
EXP_A_RXP_6: CPU.H6(PEG_RX[6]) SLOT1.A43(PERP6)
EXP_A_RXP_7: CPU.J5(PEG_RX[7]) SLOT1.A47(PERP7)
EXP_A_RXP_8: CPU.K6(PEG_RX[8]) SLOT1.A52(PERP8)
EXP_A_RXP_9: CPU.L5(PEG_RX[9]) SLOT1.A56(PERP9)
EXP_A_RXP_10: CPU.M6(PEG_RX[10]) SLOT1.A60(PERP10)
EXP_A_RXP_11: CPU.N5(PEG_RX[11]) SLOT1.A64(PERP11)
EXP_A_RXP_12: CPU.P6(PEG_RX[12]) SLOT1.A68(PERP12)
EXP_A_RXP_13: CPU.R5(PEG_RX[13]) SLOT1.A72(PERP13)
EXP_A_RXP_14: CPU.T6(PEG_RX[14]) SLOT1.A76(PERP14)
EXP_A_RXP_15: CPU.U5(PEG_RX[15]) SLOT1.A80(PERP15)
EXP_A_TXN_0_C: CPU.A6(PEG_TX#[0]) CX16.1
EXP_A_TXN_1_C: CPU.B5(PEG_TX#[1]) CX17.1
EXP_A_TXN_2_C: CPU.C4(PEG_TX#[2]) CX23.1
EXP_A_TXN_3_C: CPU.D3(PEG_TX#[3]) CX26.1
EXP_A_TXN_4_C: CPU.E2(PEG_TX#[4]) CX28.1
EXP_A_TXN_5_C: CPU.F3(PEG_TX#[5]) CX30.1
EXP_A_TXN_6_C: CPU.G2(PEG_TX#[6]) CX32.1
EXP_A_TXN_7_C: CPU.H3(PEG_TX#[7]) CX34.1
EXP_A_TXN_8_C: CPU.J2(PEG_TX#[8]) CX36.1
EXP_A_TXN_9_C: CPU.K3(PEG_TX#[9]) CX38.1
EXP_A_TXN_10_C: CPU.L2(PEG_TX#[10]) CX98.1
EXP_A_TXN_11_C: CPU.M3(PEG_TX#[11]) CX42.1
EXP_A_TXN_12_C: CPU.N2(PEG_TX#[12]) CX44.1
EXP_A_TXN_13_C: CPU.P3(PEG_TX#[13]) CX46.1
EXP_A_TXN_14_C: CPU.R1(PEG_TX#[14]) CX99.1
EXP_A_TXN_15_C: CPU.T3(PEG_TX#[15]) CX101.1
EXP_A_TXP_0_C: CPU.A5(PEG_TX[0]) CX15.1
EXP_A_TXP_1_C: CPU.B4(PEG_TX[1]) CX21.1
EXP_A_TXP_2_C: CPU.C3(PEG_TX[2]) CX22.1
EXP_A_TXP_3_C: CPU.D2(PEG_TX[3]) CX24.1
EXP_A_TXP_4_C: CPU.E1(PEG_TX[4]) CX27.1
EXP_A_TXP_5_C: CPU.F2(PEG_TX[5]) CX29.1
EXP_A_TXP_6_C: CPU.G1(PEG_TX[6]) CX31.1
EXP_A_TXP_7_C: CPU.H2(PEG_TX[7]) CX33.1
EXP_A_TXP_8_C: CPU.J1(PEG_TX[8]) CX35.1
EXP_A_TXP_9_C: CPU.K2(PEG_TX[9]) CX37.1
EXP_A_TXP_10_C: CPU.L1(PEG_TX[10]) CX39.1
EXP_A_TXP_11_C: CPU.M2(PEG_TX[11]) CX41.1
EXP_A_TXP_12_C: CPU.N1(PEG_TX[12]) CX43.1
EXP_A_TXP_13_C: CPU.P2(PEG_TX[13]) CX45.1
EXP_A_TXP_14_C: CPU.R2(PEG_TX[14]) CX47.1
EXP_A_TXP_15_C: CPU.T2(PEG_TX[15]) CX100.1
EXTARB_EN: BRIDGE.C10(EXT_ARB_EN) RK33.2
F_PCH_JTAG_TDI: RS223.1 U4.AP2(JTAG_TDI)
F_PCH_JTAG_TDO: RS226.1 U4.AP1(JTAG_TDO)
F_PCH_JTAG_TMS: RS224.1 U4.AR2(JTAG_TMS)
F_SPI_CLK_PRI_SEC_FLSH_R: RF16.2 SPI1.6(SCLK) SPI_1.6(CLK)
F_SPI_CLK_PRI_SEC_FLSH_TPM: RF17.2 RF37.1
F_SPI_HOLD#: R6643.2 RF23.2 SPI1.7(SIO3) SPI_1.7(HOLD#)
F_SPI_MISO_R: RF61.2 SPI1.2(SO/SIO1) SPI_1.2(DO)
F_SPI_MISO_TPM: RF41.1 RF60.2
F_SPI_MOSI_PRI_SEC_FLSH_R: RF18.2 SPI1.5(SI/SIO0) SPI_1.5(DIO)
F_SPI_MOSI_PRI_SEC_FLSH_TPM: RF21.2 RF39.1
F_SPI_VCC: CF8.1 CF9.1 CF10.1 CF11.2 CF12.1 CF18.1 CF20.1 CF21.1 R6642.1 R6643.1 RF25.1 RF27.1 RF53.1 RF54.2 RF56.1 RF59.1 RF62.2 SPI1.8(VCC) SPI_1.8(VCC) UF1.1(VSB)
F_SPI_WP#: R6642.2 RF24.2 SPI1.3(SIO2) SPI_1.3(WP#)
F_TP_XDP_RST: RS18.2 RS22.2 RS232.2 XDP_PCH.39(HOOK0)
F_USB2_N9: U4.AA1(USB2N9) UL19.4 UR57.1
F_USB2_N10: U4.AJ8(USB2N10) UL5.3 UR13.1
F_USB2_P9: U4.AA2(USB2P9) UL19.3 UR58.1
F_USB2_P10: U4.AJ7(USB2P10) UL5.4 UR14.1
F_USB3_N1: LU36.3 RU54.1 U4.AF5(USB2N1)
F_USB3_N2: LU37.4 RU58.1 U4.AD5(USB2N2)
F_USB3_P1: LU36.4 RU55.1 U4.AG7(USB2P1)
F_USB3_P2: LU37.3 RU59.1 U4.AD7(USB2P2)
FAN_CPU_PIN1: CF2.1 FAN_CPU.2 RF7.2 RNF2.5 RNF2.6
FAN_CPU_PWM: CF1.1 FAN_CPU.1 RF6.2
FLASH_OVERRIDE#: P3.2 QS10.C(COLLECTOR) R6346.1
FP_RST#: CO55.1 R6431.1 R6659.1 RB6.1 RB16.1 RIO6.2 U4.AW1(SYS_RESET_N)
FPNL_SATA_LED#_R: QO6.2(BASE) RIO10.2
GPIO0: RF64.2 UF1.29(SDA/GPIO0)
GPIO2: RF63.2 UF1.3(GPX/GPIO2)
GPIO4: BRIDGE.M10(GPIO4//SCL) RK39.2
GPIO_PEG SLOT_RESET: RP41.1 U1.2(B) U4.W39(GPP_F22)
GPP_A0: R73.2 R6369.2 U4.AT17(GPP_A0_RCIN_N_ESPI_ALERT1_N)
GPP_A8: R6392.2 U4.AW22(GPP_A8_CLKRUN_N)
GPP_A13: R6663.2 U4.BD19(GPP_A13_SUSWARN_N_SUSPWRDNACK)
GPP_B14: R114.2 U4.BD26(GPP_B14_SPKR)
GPP_F17: RH8.2 U4.W44(GPP_F17_USB2_OCB_6)
GPP_F18: R6618.2 U4.W43(GPP_F18_USB2_OCB_7)
GT1+_RT3607: PC95.2 PR145.1 PU7.38(ISENA1P)
GT1-_RT3607: PR147.1 PU7.39(ISENA1N)
GT2+_RT3607: PC101.2 PR151.1 PU7.37(ISENA2P)
GT2-_RT3607: PR156.1 PU7.36(ISENA2N)
GT3-_RT3607: PR160.1 PU7.40(ISENA3N) PU7.41(ISENA3P)
GT_COMPA: PC104.2 PR155.2 PU7.34(COMPA)
GT_FBA: PC103.2 PC104.1 PR152.2 PR154.1 PU7.35(FBA)
GT_ISEN1+: PJP15.2 PR145.2
GT_ISEN1-: PC95.1 PC98.1 PJP16.2 PR147.2
GT_ISEN2+: PJP17.2 PR151.2
GT_ISEN2-: PC101.1 PC102.1 PJP18.2 PR156.2
GT_VSENA: PC103.1 PC105.2 PR152.1 PR158.2 PR161.2 PU7.33(VSENA)
H_BPM#0: CPU.D16(BPM#[0]) XDP_CPU.21(OBSFN_B0)
H_BPM#1: CPU.D17(BPM#[1]) XDP_CPU.23(OBSFN_B1)
H_CATERR#: CPU.D13(CATERR#) R51.2 TPS41.1(TP)
H_PECI: CPU.G7(PECI) R6255.1 R6408.2 RO10.1
H_PECI_C: CO14.1 RO10.2 SIO_5553.30(PECI/LVSMB_CLK1)
H_PWRGOOD: CPU.F8(PROCPWRGD) R6596.2
H_PWRGOOD_R: R6596.1 U4.AM3(PROCPWRGD)
H_SKTOCC#: CPU.AB35(SKTOCC#) R6573.1 U4.Y44(GPP_F14)
H_TCK: CPU.F11(TCK) R152.2 RS225.2 XDP_CPU.57(TCK0)
H_TDI: CPU.G12(TDI) R6680.2 RS223.2 XDP_CPU.56(TDI)
H_TDO: CPU.H13(TDO) R117.2 RS226.2 XDP_CPU.52(TDO)
H_THERMTRIP#: CPU.D11(THERMTRIP#) R6434.2 R6585.2
H_TMS: CPU.F13(TMS) RS224.2 XDP_CPU.58(TMS)
H_TRST#: CPU.F12(TRST#) R6574.2 R6595.1 XDP_CPU.54(TRST#)
H_TRST#_R: R6574.1 RP5.1 U4.AY5(CPU_TRST_N)
HDMI_D41_PIN1: D41.1 RV88.2
HDMI_D41_PIN2: D41.2 RV89.2
HDMI_HPD: CV40.1 CV41.1 HDMI.19(HPD) QV49.D(DRAIN) RV79.1 RV80.1 UV7.4(CH3) UV7.7(NC3)
HDMI_Q99_S: Q99.S(SOURCE) RV75.2
HDMI_Q104_S: Q104.S(SOURCE) RV84.2
HDMI_V_HDMI_SCL_R: Q99.D(DRAIN) RV76.1 RV88.1
HDMI_V_HDMI_SDA_R: Q104.D(DRAIN) RV85.1 RV89.1
HDMID_FET_SINK: QV22.D(DRAIN) RV45.1 RV46.1 RV47.1 RV48.1 RV49.2 RV72.2 RV73.2 RV74.2
HPOUT-JD: F_AUDIO.6 RA16.2
HPOUT-L: RA41.2 RA74.1 RA77.2 UA1.32(HPOUT-L(PORT-I-L))
HPOUT-R: RA40.2 RA75.1 RA76.2 UA1.33(HPOUT-R(PORT-I-R))
HS_DET#: HS_CLIP2.1 HS_CLIP2.2 R67.2 U4.AB36(GPP_F8_DEVSLP6)
ICH_RTCRST#: C1639.2 P2.1 R6467.2 RB4.1 U4.BC10(RTCRST#)
ICH_RTCX1: C1641.1 R6468.2 U4.BC9(RTCX1) Y5.4
ICH_RTCX2: C1640.1 R6468.1 U4.BD10(RTCX2) Y5.1
IMON: PR129.2 PU7.20(IMON)
IMON_L: PR128.1 PRT1.2
IMON_R: PR125.2 PR128.2 PR129.1
IMONA: PR136.2 PU7.22(IMONA)
IMONA_L: PR135.1 PRT2.2
IMONA_R: PR134.2 PR135.2 PR136.1
ISEN1+: PJP9.2 PR101.2
ISEN1-: PC85.1 PC86.1 PJP10.2 PR106.2
ISEN2+: PJP11.2 PR116.2
ISEN2-: PC87.1 PC88.1 PJP12.2 PR117.2
ISEN3+: PJP13.2 PR123.2
ISEN3-: PC91.1 PC92.1 PJP14.2 PR126.2
ISOLATEB: RL34.2 RL35.1 RTK_LAN.20(ISOLATEB)
JTAG_TCK: BRIDGE.M12(JTAG_TCK) RK35.2
JTAG_TRST#: BRIDGE.L9(JTAG_TRST#) RK34.2
K_AD0: BRIDGE.C5(AD0) SLOT3.A58(AD(0)) SLOT4.A58(AD(0))
K_AD1: BRIDGE.A3(AD1) SLOT3.B58(AD(1)) SLOT4.B58(AD(1))
K_AD2: BRIDGE.B4(AD2) SLOT3.A57(AD(2)) SLOT4.A57(AD(2))
K_AD3: BRIDGE.B3(AD3) SLOT3.B56(AD(3)) SLOT4.B56(AD(3))
K_AD4: BRIDGE.A2(AD4) SLOT3.A55(AD(4)) SLOT4.A55(AD(4))
K_AD5: BRIDGE.C4(AD5) SLOT3.B55(AD(5)) SLOT4.B55(AD(5))
K_AD6: BRIDGE.B2(AD6) SLOT3.A54(AD(6)) SLOT4.A54(AD(6))
K_AD7: BRIDGE.C3(AD7) SLOT3.B53(AD(7)) SLOT4.B53(AD(7))
K_AD8: BRIDGE.D3(AD8) SLOT3.B52(AD(8)) SLOT4.B52(AD(8))
K_AD9: BRIDGE.C2(AD9) SLOT3.A49(AD(9)) SLOT4.A49(AD(9))
K_AD10: BRIDGE.C1(AD10) SLOT3.B48(AD(10)) SLOT4.B48(AD(10))
K_AD11: BRIDGE.D2(AD11) SLOT3.A47(AD(11)) SLOT4.A47(AD(11))
K_AD12: BRIDGE.D1(AD12) SLOT3.B47(AD(12)) SLOT4.B47(AD(12))
K_AD13: BRIDGE.E3(AD13) SLOT3.A46(AD(13)) SLOT4.A46(AD(13))
K_AD14: BRIDGE.E2(AD14) SLOT3.B45(AD(14)) SLOT4.B45(AD(14))
K_AD15: BRIDGE.E1(AD15) SLOT3.A44(AD(15)) SLOT4.A44(AD(15))
K_AD16: BRIDGE.K1(AD16) SLOT3.A32(AD(16)) SLOT4.A32(AD(16))
K_AD17: BRIDGE.K2(AD17) RK55.2 SLOT3.B32(AD(17)) SLOT4.B32(AD(17))
K_AD18: BRIDGE.L1(AD18) RK13.2 SLOT3.A31(AD(18)) SLOT4.A31(AD(18))
K_AD18_R: RK13.1 SLOT3.A26(IDSEL)
K_AD19: BRIDGE.L2(AD19) SLOT3.B30(AD(19)) SLOT4.B30(AD(19))
K_AD20: BRIDGE.M1(AD20) SLOT3.A29(AD(20)) SLOT4.A29(AD(20))
K_AD21: BRIDGE.L3(AD21) SLOT3.B29(AD(21)) SLOT4.B29(AD(21))
K_AD22: BRIDGE.M2(AD22) SLOT3.A28(AD(22)) SLOT4.A28(AD(22))
K_AD23: BRIDGE.L4(AD23) SLOT3.B27(AD(23)) SLOT4.B27(AD(23))
K_AD24: BRIDGE.M3(AD24) SLOT3.A25(AD(24)) SLOT4.A25(AD(24))
K_AD25: BRIDGE.N2(AD25) SLOT3.B24(AD(25)) SLOT4.B24(AD(25))
K_AD26: BRIDGE.M4(AD26) SLOT3.A23(AD(26)) SLOT4.A23(AD(26))
K_AD27: BRIDGE.N3(AD27) SLOT3.B23(AD(27)) SLOT4.B23(AD(27))
K_AD28: BRIDGE.M5(AD28) SLOT3.A22(AD(28)) SLOT4.A22(AD(28))
K_AD29: BRIDGE.L5(AD29) SLOT3.B21(AD(29)) SLOT4.B21(AD(29))
K_AD30: BRIDGE.N4(AD30) SLOT3.A20(AD(30)) SLOT4.A20(AD(30))
K_AD31: BRIDGE.N5(AD31) SLOT3.B20(AD(31)) SLOT4.B20(AD(31))
K_C/BE#0: BRIDGE.B1(C/BE#0) SLOT3.A52(C/BE#(0)) SLOT4.A52(C/BE#(0))
K_C/BE#1: BRIDGE.F2(C/BE#1) SLOT3.B44(C/BE#(1)) SLOT4.B44(C/BE#(1))
K_C/BE#2: BRIDGE.J3(C/BE#2) SLOT3.B33(C/BE#(2)) SLOT4.B33(C/BE#(2))
K_C/BE#3: BRIDGE.N1(C/BE#3) SLOT3.B26(C/BE#(3)) SLOT4.B26(C/BE#(3))
K_DEVSEL#: BRIDGE.H2(DEVSEL#) RNK6.3 SLOT3.B37(DEVSEL#) SLOT4.B37(DEVSEL#)
K_FRAME#: BRIDGE.J2(FRAME#) RNK6.1 SLOT3.A34(FRAME#) SLOT4.A34(FRAME#)
K_GNT#0: BRIDGE.A5(GNT0#) SLOT3.A17(GNT#)
K_GNT#1: BRIDGE.C6(GNT1#) SLOT4.A17(GNT#)
K_INTA#: BRIDGE.M6(INTA#) RNK1.4 SLOT3.A7(INTC#) SLOT4.B8(INTD#)
K_INTB#: BRIDGE.N6(INTB#) RNK1.3 SLOT3.B8(INTD#) SLOT4.A6(INTA#)
K_INTC#: BRIDGE.M7(INTC#) RNK1.1 SLOT3.A6(INTA#) SLOT4.B7(INTB#)
K_INTD#: BRIDGE.L7(INTD#) RNK1.2 SLOT3.B7(INTB#) SLOT4.A7(INTC#)
K_IRDY#: BRIDGE.J1(IRDY#) RNK6.2 SLOT3.B35(IRDY#) SLOT4.B35(IRDY#)
K_LOCK#: BRIDGE.M8(LOCK#) RNK5.1 SLOT3.B39(LOCK#) SLOT4.B39(LOCK#)
K_PAR: BRIDGE.F1(PAR) SLOT3.A43(PAR) SLOT4.A43(PAR)
K_PCI_M66EN: BRIDGE.L6(M66EN) RK24.1 RK25.2
K_PCI_PME#: BRIDGE.L12(PME#) RK28.2 RK40.1
K_PCIRST#_N: BRIDGE.N7(PRST#) RK14.1
K_PCIRST#_SLOT: CK23.2 RK14.2 RK32.1 SLOT3.A15(RESET#) SLOT4.A15(RESET#)
K_PERR#: BRIDGE.G2(PERR#) RNK5.2 SLOT3.B40(PERR#) SLOT4.B40(PERR#)
K_PME#: RK30.2 RK40.2 RK53.2 SLOT3.A19(PCI_PME#) SLOT4.A19(PCI_PME#)
K_REQ#0: BRIDGE.A4(REQ0#) RK37.1 SLOT3.B18(REQ#)
K_REQ#1: BRIDGE.A6(REQ1#) RK49.1 SLOT4.B18(REQ#)
K_SERR#: BRIDGE.G3(SERR#) RNK5.4 SLOT3.B42(SERR#) SLOT4.B42(SERR#)
K_STOP#: BRIDGE.G1(STOP#) RNK5.3 SLOT3.A38(STOP#) SLOT4.A38(STOP#)
K_TCK: RNK4.6 SLOT3.B2(TCK)
K_TCK1: RNK7.6 SLOT4.B2(TCK)
K_TDI: RNK4.8 SLOT3.A4(TDI)
K_TDI1: RNK7.8 SLOT4.A4(TDI)
K_TMS: RNK4.7 SLOT3.A3(TMS)
K_TMS1: RNK7.7 SLOT4.A3(TMS)
K_TRDY#: BRIDGE.H1(TRDY#) RNK6.4 SLOT3.A36(TRDY#) SLOT4.A36(TRDY#)
K_TRST: RNK4.5 SLOT3.A1(TRST#)
K_TRST1: RNK7.5 SLOT4.A1(TRST#)
KBDCLK: L15.1 RN5.4 SIO_5553.113(KCLK)
KBDDATA: L13.1 RN5.3 SIO_5553.114(KDAT)
KBRST#: R73.1 R497.2 SIO_5553.118(GP063/NKBDRST)
L_ACTLEDN: RL30.1 RTK_LAN.27(LED0)
L_ACTLEDN_R: CL34.2 NIC_USB.22(D4) RL30.2
L_LINK100#: RL28.1 RTK_LAN.25(LED2)
L_LINK100#_R: CL31.1 NIC_USB.20(D2) RL28.2
L_LINK1000#: RL29.1 RTK_LAN.26(LED1/GPO)
L_LINK1000#_R: CL32.1 NIC_USB.19(D1) RL29.2
L_MDI_0+: NIC_USB.10(MDID+) RTK_LAN.1(MDIP0) UU17.3
L_MDI_0-: NIC_USB.11(MDID-) RTK_LAN.2(MDIN0) UU17.1
L_MDI_1+: NIC_USB.12(MDI1+) RTK_LAN.4(MDIP1) UU18.4
L_MDI_1-: NIC_USB.13(MDI1-) RTK_LAN.5(MDIN1) UU18.6
L_MDI_2+: NIC_USB.14(MDI2+) RTK_LAN.6(MDIP2) UU17.4
L_MDI_2-: NIC_USB.15(MDI2-) RTK_LAN.7(MDIN2) UU17.6
L_MDI_3+: NIC_USB.16(MDI3+) RTK_LAN.9(MDIP3) UU18.3
L_MDI_3-: NIC_USB.17(MDI3-) RTK_LAN.10(MDIN3) UU18.1
LAD0_MISO: RF41.2 UF1.24(LAD0/MISO)
LAD1_MOSI: RF39.2 UF1.21(LAD1/MOSI)
LAD2_SPIIRQ: RF45.2 UF1.18(LAD2/S\P\I\_\I\R\Q\)
LAN_DISABLE#: RL37.1 U4.AR15(GPD11_LANPHYPC)
LAN_DISABLE#_R: CL52.1 QL4.B(BASE) RL37.2 RL38.1
LAN_QL5_B: QL4.C(COLLECTOR) QL5.B(BASE) RL38.2 RL39.2
LAN_QL5_C: QL5.C(COLLECTOR) QL6.C(COLLECTOR) RL40.2 RL42.1
LAN_QL6_B: CL53.1 QL6.B(BASE) RL41.2
LAN_QL7_G: CL54.1 CL55.2 QL7.G(GATE) RL42.2
LAN_WAKE#: RL3.2 RTK_LAN.21(LANWAKEB) U4.BD11(GPD2_LAN_WAKE_N)
LANE0_N: CG4.2 RTK_VGA.30(LANE0N)
LANE0_P: CG3.2 RTK_VGA.29(LANE0P)
LANE1_N: CG6.2 RTK_VGA.32(LANE1N)
LANE1_P: CG5.2 RTK_VGA.31(LANE1P)
LD_FP_RST#_R: CB5.1 RB16.2 RST_SWH.1
LD_LPC_DEBUG_PIN2: LPC_DEBUG.2 RB12.1
LD_LPC_DEBUG_PIN6: LPC_DEBUG.6 RB13.1
LD_SIO_24M_CLOCKI_R: CB1.1 LPC_DEBUG.1 RB11.2
LDO2_C: CA3.1 UA1.39(LDO2-CAP)
LDO_EN: RG9.2 RG10.1 RTK_VGA.21(LDO_EN)
LED_M2_SSD_ACT_N: M.2_SSD.10(DAS/DSS#) RM6.2 RM8.2
LED_YELLOW_R: AUX_PWR1.1(ANODE) PR232.2
LINE1-L: CA123.1 UA1.22(LINE1-L(PORT-C-L))
LINE1-L_J: CA121.1 DA4.2(IO2) F_AUDIO.1 IO_FBI9.2
LINE1-R: CA122.1 UA1.21(LINE1-R(PORT-C-R))
LINE1-R_J: CA120.1 DA4.1(IO1) F_AUDIO.2 IO_FBI10.2
LINE1-VREFO-L: RA77.1 UA1.31(LINE1-VREFO-L)
LINE1-VREFO-R: RA76.1 UA1.30(LINE1-VREFO-R)
LINE2-JD: RA15.2 REAR_AUDIO.4
LINE2-L: CA85.1 UA1.24(LINE2-L(PORT-E-L))
LINE2-R: CA83.1 UA1.23(LINE2-R(PORT-E-R))
LPC_AD0: R6375.1 RB17.1 RB18.1 SIO_5553.8(LAD0)
LPC_AD0_DEBUG: LPC_DEBUG.5 RB17.2
LPC_AD0_TCM: RB18.2 UF2.27(LAD0)
LPC_AD1: R6378.1 RB19.1 RB20.1 SIO_5553.9(LAD1)
LPC_AD1_DEBUG: LPC_DEBUG.7 RB19.2
LPC_AD1_TCM: RB20.2 UF2.24(LAD1)
LPC_AD2: R6380.1 RB21.1 RB22.1 SIO_5553.10(LAD2)
LPC_AD2_DEBUG: LPC_DEBUG.9 RB21.2
LPC_AD2_TCM: RB22.2 UF2.21(LAD2)
LPC_AD3: R6383.1 RB23.1 RB24.1 SIO_5553.11(LAD3)
LPC_AD3_DEBUG: LPC_DEBUG.11 RB23.2
LPC_AD3_TCM: RB24.2 UF2.19(LAD3)
LPC_FRAME#: R6388.1 RB25.1 RB26.1 SIO_5553.12(NLFRAME)
LPC_FRAME#_DEBUG: LPC_DEBUG.13 RB25.2
LPC_FRAME#_TCM: RB26.2 UF2.23(LFRAME#)
M2_DEVSLP: M.2_SSD.38(DEVSLP) RM5.2
M2_PE_WAKE#: M.2_SSD.54(PE_WAKE#) RM4.2
M2_Q1_C: QM2.5(BASE) QM2.6(COLLECTOR) RM7.2
M2_Q1A_B: QM2.2(BASE) RM8.1
M2_Q2_B: QM1.B(BASE) RM2.1
M2_SATA_RXN3_C: CM3.1 M.2_SSD.43(PE_RXP0/SATA_B-)
M2_SATA_RXP3_C: CM4.1 M.2_SSD.41(PE_RXN0/SATA_B+)
M2_SATA_TXN3_C: CM2.1 M.2_SSD.47(PE_TXN0/SATA_A-)
M2_SATA_TXP3_C: CM1.1 M.2_SSD.49(PE_TXP0/SATA_A+)
M.2_PEDET: M.2_SSD.69(PEDET) RM1.2 RM2.2 RM3.2
M.2_SSD_PEDET: QM1.C(COLLECTOR) RM1.1 RP26.2
M_A_ACT_N: CPU.AU24(SA_MA[15]/SA_CAA[8]/SA_ACT#) DIMM1.62(ACT_N)
M_A_ALERT_N: CPU.AT23(SA_ALERT#) DIMM1.208(ALERT_N)
M_A_BA0: CPU.AY13(SA_BA[0]/SA_CAB[4]/SA_BA[0]) DIMM1.81(BA0)
M_A_BA1: CPU.AV15(SA_BA[1]/SA_CAB[6]/SA_BA[1]) DIMM1.224(BA1)
M_A_BA2: CPU.AW23(SA_BA[2]/SA_CAA[5]/SA_BG[0]) DIMM1.63(BG0)
M_A_BG1: CPU.AV23(SA_MA[14]/SA_CAA[9]/SA_BG[1]) DIMM1.207(BG1)
M_A_CK_DN0: CPU.AV18(SA_CK#[0]) DIMM1.75(CK0N)
M_A_CK_DN1: CPU.AY17(SA_CK#[1]) DIMM1.219(CK1N)
M_A_CK_DP0: CPU.AW18(SA_CK[0]) DIMM1.74(CK0P)
M_A_CK_DP1: CPU.AW17(SA_CK[1]) DIMM1.218(CK1P)
M_A_CKE0: CPU.AY24(SA_CKE[0]) DIMM1.60(CKE0)
M_A_CKE1: CPU.AW24(SA_CKE[1]) DIMM1.203(CKE1)
M_A_CS_N0: CPU.AW12(SA_CS#[0]) DIMM1.84(S0_N)
M_A_CS_N1: CPU.AU11(SA_CS#[1]) DIMM1.89(S1_N)
M_A_MA0: CPU.AW15(SA_MA[0]/SA_CAB[9]/SA_MA[0]) DIMM1.79(A0)
M_A_MA1: CPU.AU18(SA_MA[1]/SA_CAB[8]/SA_MA[1]) DIMM1.72(A1)
M_A_MA2: CPU.AU17(SA_MA[2]/SA_CAB[5]/SA_MA[2]) DIMM1.216(A2)
M_A_MA3: CPU.AV19(SA_MA[3]) DIMM1.71(A3)
M_A_MA4: CPU.AT19(SA_MA[4]) DIMM1.214(A4)
M_A_MA5: CPU.AU20(SA_MA[5]/SA_CAA[0]/SA_MA[5]) DIMM1.213(A5)
M_A_MA6: CPU.AV20(SA_MA[6]/SA_CAA[2]/SA_MA[6]) DIMM1.69(A6)
M_A_MA7: CPU.AU21(SA_MA[7]/SA_CAA[4]/SA_MA[7]) DIMM1.211(A7)
M_A_MA8: CPU.AT20(SA_MA[8]/SA_CAA[3]/SA_MA[8]) DIMM1.68(A8)
M_A_MA9: CPU.AT22(SA_MA[9]/SA_CAA[1]/SA_MA[9]) DIMM1.66(A9)
M_A_MA10: CPU.AY14(SA_MA[10]/SA_CAB[7]/SA_MA[10]) DIMM1.225(A10)
M_A_MA11: CPU.AU22(SA_MA[11]/SA_CAA[7]/SA_MA[11]) DIMM1.210(A11)
M_A_MA12: CPU.AV22(SA_MA[12]/SA_CAA[6]/SA_MA[12]) DIMM1.65(A12)
M_A_MA13: CPU.AV12(SA_MA[13]/SA_CAB[0]/SA_MA[13]) DIMM1.232(A13)
M_A_MA14: CPU.AV14(SA_WE#/SA_CAB[2]/SA_MA[14]) DIMM1.228(A14_WE_N)
M_A_MA15: CPU.AY11(SA_CAS#/SA_CAB[1]/SA_MA[15]) DIMM1.86(A15_CAS_N)
M_A_MA16: CPU.AW13(SA_RAS#/SA_CAB[3]/SA_MA[16]) DIMM1.82(A16_RAS_N)
M_A_ODT0: CPU.AW11(SA_ODT[0]) DIMM1.87(ODT0)
M_A_ODT1: CPU.AU14(SA_ODT[1]) DIMM1.91(ODT1)
M_A_PAR: CPU.AY15(SA_PAR) DIMM1.222(PAR)
M_A_VREF: CD2.1 CD3.1 CD5.1 DIMM1.146(VREFCA) RD8.2 RD9.1
M_AB_RESET_N: RD1.1 RD2.1 U4.BC14(DRAM_RESET_N) U139.1(A)
M_AB_RESET_N_R: CD1.1 RD2.2 RD3.2 RD4.1 U139.4(Y)
M_B_ACT_N: CPU.AU28(SB_MA[15]/SB_CAA[8]/SB_ACT#) DIMM2.62(ACT_N)
M_B_ALERT_N: CPU.AY25(SB_ALERT#) DIMM2.208(ALERT_N)
M_B_BA0: CPU.AL18(SB_BA[0]/SB_CAB[4]/SB_BA[0]) DIMM2.81(BA0)
M_B_BA1: CPU.AM18(SB_BA[1]/SB_CAB[6]/SB_BA[1]) DIMM2.224(BA1)
M_B_BA2: CPU.AW28(SB_BA[2]/SB_CAA[5]/SB_BG[0]) DIMM2.63(BG0)
M_B_BG1: CPU.AY28(SB_MA[14]/SB_CAA[9]/SB_BG[1]) DIMM2.207(BG1)
M_B_CK_DN0: CPU.AM21(SB_CK#[0]) DIMM2.75(CK0N)
M_B_CK_DN1: CPU.AP21(SB_CK#[1]) DIMM2.219(CK1N)
M_B_CK_DP0: CPU.AM20(SB_CK[0]) DIMM2.74(CK0P)
M_B_CK_DP1: CPU.AP22(SB_CK[1]) DIMM2.218(CK1P)
M_B_CKE0: CPU.AY29(SB_CKE[0]) DIMM2.60(CKE0)
M_B_CKE1: CPU.AV29(SB_CKE[1]) DIMM2.203(CKE1)
M_B_CS_N0: CPU.AP17(SB_CS#[0]) DIMM2.84(S0_N)
M_B_CS_N1: CPU.AN15(SB_CS#[1]) DIMM2.89(S1_N)
M_B_MA0: CPU.AL19(SB_MA[0]/SB_CAB[9]/SB_MA[0]) DIMM2.79(A0)
M_B_MA1: CPU.AL22(SB_MA[1]/SB_CAB[8]/SB_MA[1]) DIMM2.72(A1)
M_B_MA2: CPU.AM22(SB_MA[2]/SB_CAB[5]/SB_MA[2]) DIMM2.216(A2)
M_B_MA3: CPU.AM23(SB_MA[3]) DIMM2.71(A3)
M_B_MA4: CPU.AP23(SB_MA[4]) DIMM2.214(A4)
M_B_MA5: CPU.AL23(SB_MA[5]/SB_CAA[0]/SB_MA[5]) DIMM2.213(A5)
M_B_MA6: CPU.AW26(SB_MA[6]/SB_CAA[2]/SB_MA[6]) DIMM2.69(A6)
M_B_MA7: CPU.AY26(SB_MA[7]/SB_CAA[4]/SB_MA[7]) DIMM2.211(A7)
M_B_MA8: CPU.AU26(SB_MA[8]/SB_CAA[3]/SB_MA[8]) DIMM2.68(A8)
M_B_MA9: CPU.AW27(SB_MA[9]/SB_CAA[1]/SB_MA[9]) DIMM2.66(A9)
M_B_MA10: CPU.AP18(SB_MA[10]/SB_CAB[7]/SB_MA[10]) DIMM2.225(A10)
M_B_MA11: CPU.AU27(SB_MA[11]/SB_CAA[7]/SB_MA[11]) DIMM2.210(A11)
M_B_MA12: CPU.AV27(SB_MA[12]/SB_CAA[6]/SB_MA[12]) DIMM2.65(A12)
M_B_MA13: CPU.AR15(SB_MA[13]/SB_CAB[0]/SB_MA[13]) DIMM2.232(A13)
M_B_MA14: CPU.AL17(SB_WE#/SB_CAB[2]/SB_MA[14]) DIMM2.228(A14_WE_N)
M_B_MA15: CPU.AP16(SB_CAS#/SB_CAB[1]/SB_MA[15]) DIMM2.86(A15_CAS_N)
M_B_MA16: CPU.AN18(SB_RAS#/SB_CAB[3]/SB_MA[16]) DIMM2.82(A16_RAS_N)
M_B_ODT0: CPU.AM16(SB_ODT[0]) DIMM2.87(ODT0)
M_B_ODT1: CPU.AL16(SB_ODT[1]) DIMM2.91(ODT1)
M_B_PAR: CPU.AL20(SB_PAR) DIMM2.222(PAR)
M_B_VREF: C68.1 C69.1 C72.1 DIMM2.146(VREFCA) R62.2 R63.1
M_CA_VREF: CD6.1 CPU.AB40(DDR_VREF_CA) RD9.2
M_CA_VREF_RC: CD6.2 RD10.1
M_DA0: CPU.AE38(SA_DQ[0]) DIMM1.148(DQ5)
M_DA1: CPU.AE37(SA_DQ[1]) DIMM1.150(DQ1)
M_DA2: CPU.AG38(SA_DQ[2]) DIMM1.12(DQ2)
M_DA3: CPU.AG37(SA_DQ[3]) DIMM1.157(DQ3)
M_DA4: CPU.AE39(SA_DQ[4]) DIMM1.3(DQ4)
M_DA5: CPU.AE40(SA_DQ[5]) DIMM1.5(DQ0)
M_DA6: CPU.AG39(SA_DQ[6]) DIMM1.10(DQ6)
M_DA7: CPU.AG40(SA_DQ[7]) DIMM1.155(DQ7)
M_DA8: CPU.AJ39(SA_DQ[13]) DIMM1.14(DQ12)
M_DA9: CPU.AJ37(SA_DQ[9]) DIMM1.161(DQ9)
M_DA10: CPU.AL38(SA_DQ[10]) DIMM1.23(DQ10)
M_DA11: CPU.AL37(SA_DQ[11]) DIMM1.168(DQ11)
M_DA12: CPU.AJ40(SA_DQ[12]) DIMM1.16(DQ8)
M_DA13: CPU.AJ38(SA_DQ[8]) DIMM1.159(DQ13)
M_DA14: CPU.AL39(SA_DQ[14]) DIMM1.21(DQ14)
M_DA15: CPU.AL40(SA_DQ[15]) DIMM1.166(DQ15)
M_DA16: CPU.AN38(SA_DQ[16]/SA_DQ[32]) DIMM1.170(DQ21)
M_DA17: CPU.AN40(SA_DQ[17]/SA_DQ[33]) DIMM1.27(DQ16)
M_DA18: CPU.AR38(SA_DQ[18]/SA_DQ[34]) DIMM1.34(DQ18)
M_DA19: CPU.AR37(SA_DQ[19]/SA_DQ[35]) DIMM1.179(DQ19)
M_DA20: CPU.AN39(SA_DQ[20]/SA_DQ[36]) DIMM1.25(DQ20)
M_DA21: CPU.AN37(SA_DQ[21]/SA_DQ[37]) DIMM1.172(DQ17)
M_DA22: CPU.AR39(SA_DQ[22]/SA_DQ[38]) DIMM1.32(DQ22)
M_DA23: CPU.AR40(SA_DQ[23]/SA_DQ[39]) DIMM1.177(DQ23)
M_DA24: CPU.AW37(SA_DQ[24]/SA_DQ[40]) DIMM1.183(DQ25)
M_DA25: CPU.AU37(SA_DQ[28]/SA_DQ[44]) DIMM1.181(DQ29)
M_DA26: CPU.AU35(SA_DQ[31]/SA_DQ[47]) DIMM1.45(DQ26)
M_DA27: CPU.AV35(SA_DQ[26]/SA_DQ[42]) DIMM1.190(DQ27)
M_DA28: CPU.AU38(SA_DQ[25]/SA_DQ[41]) DIMM1.36(DQ28)
M_DA29: CPU.AV37(SA_DQ[29]/SA_DQ[45]) DIMM1.38(DQ24)
M_DA30: CPU.AT35(SA_DQ[30]/SA_DQ[46]) DIMM1.43(DQ30)
M_DA31: CPU.AW35(SA_DQ[27]/SA_DQ[43]) DIMM1.188(DQ31)
M_DA32: CPU.AY8(SA_DQ[32]/SB_DQ[0]) DIMM1.97(DQ32)
M_DA33: CPU.AU8(SA_DQ[36]/SB_DQ[4]) DIMM1.242(DQ33)
M_DA34: CPU.AV6(SA_DQ[34]/SB_DQ[2]) DIMM1.104(DQ34)
M_DA35: CPU.AU6(SA_DQ[35]/SB_DQ[3]) DIMM1.249(DQ35)
M_DA36: CPU.AW8(SA_DQ[33]/SB_DQ[1]) DIMM1.95(DQ36)
M_DA37: CPU.AV8(SA_DQ[37]/SB_DQ[5]) DIMM1.240(DQ37)
M_DA38: CPU.AW6(SA_DQ[38]/SB_DQ[6]) DIMM1.247(DQ39)
M_DA39: CPU.AY6(SA_DQ[39]/SB_DQ[7]) DIMM1.102(DQ38)
M_DA40: CPU.AY4(SA_DQ[40]/SB_DQ[8]) DIMM1.106(DQ44)
M_DA41: CPU.AV4(SA_DQ[41]/SB_DQ[9]) DIMM1.108(DQ40)
M_DA42: CPU.AT1(SA_DQ[42]/SB_DQ[10]) DIMM1.258(DQ47)
M_DA43: CPU.AT2(SA_DQ[43]/SB_DQ[11]) DIMM1.260(DQ43)
M_DA44: CPU.AV3(SA_DQ[44]/SB_DQ[12]) DIMM1.253(DQ41)
M_DA45: CPU.AW4(SA_DQ[45]/SB_DQ[13]) DIMM1.251(DQ45)
M_DA46: CPU.AT4(SA_DQ[46]/SB_DQ[14]) DIMM1.113(DQ46)
M_DA47: CPU.AT3(SA_DQ[47]/SB_DQ[15]) DIMM1.115(DQ42)
M_DA48: CPU.AP1(SA_DQ[54]/SB_DQ[38]) DIMM1.119(DQ48)
M_DA49: CPU.AM4(SA_DQ[49]/SB_DQ[33]) DIMM1.124(DQ54)
M_DA50: CPU.AP3(SA_DQ[50]/SB_DQ[34]) DIMM1.262(DQ53)
M_DA51: CPU.AM2(SA_DQ[53]/SB_DQ[37]) DIMM1.271(DQ51)
M_DA52: CPU.AP4(SA_DQ[52]/SB_DQ[36]) DIMM1.117(DQ52)
M_DA53: CPU.AM3(SA_DQ[51]/SB_DQ[35]) DIMM1.126(DQ50)
M_DA54: CPU.AP2(SA_DQ[48]/SB_DQ[32]) DIMM1.264(DQ49)
M_DA55: CPU.AM1(SA_DQ[55]/SB_DQ[39]) DIMM1.269(DQ55)
M_DA56: CPU.AK3(SA_DQ[56]/SB_DQ[40]) DIMM1.273(DQ61)
M_DA57: CPU.AH1(SA_DQ[57]/SB_DQ[41]) DIMM1.280(DQ63)
M_DA58: CPU.AK4(SA_DQ[58]/SB_DQ[42]) DIMM1.128(DQ60)
M_DA59: CPU.AH2(SA_DQ[59]/SB_DQ[43]) DIMM1.282(DQ59)
M_DA60: CPU.AH4(SA_DQ[60]/SB_DQ[44]) DIMM1.135(DQ62)
M_DA61: CPU.AK2(SA_DQ[61]/SB_DQ[45]) DIMM1.275(DQ57)
M_DA62: CPU.AH3(SA_DQ[62]/SB_DQ[46]) DIMM1.137(DQ58)
M_DA63: CPU.AK1(SA_DQ[63]/SB_DQ[47]) DIMM1.130(DQ56)
M_DB0: CPU.AD34(SB_DQ[0]/SA_DQ[16]) DIMM2.3(DQ4)
M_DB1: CPU.AD35(SB_DQ[1]/SA_DQ[17]) DIMM2.148(DQ5)
M_DB2: CPU.AH34(SB_DQ[7]/SA_DQ[23]) DIMM2.12(DQ2)
M_DB3: CPU.AH35(SB_DQ[3]/SA_DQ[19]) DIMM2.157(DQ3)
M_DB4: CPU.AE35(SB_DQ[4]/SA_DQ[20]) DIMM2.150(DQ1)
M_DB5: CPU.AE34(SB_DQ[5]/SA_DQ[21]) DIMM2.5(DQ0)
M_DB6: CPU.AG34(SB_DQ[6]/SA_DQ[22]) DIMM2.10(DQ6)
M_DB7: CPU.AG35(SB_DQ[2]/SA_DQ[18]) DIMM2.155(DQ7)
M_DB8: CPU.AL34(SB_DQ[13]/SA_DQ[29]) DIMM2.16(DQ8)
M_DB9: CPU.AL35(SB_DQ[9]/SA_DQ[25]) DIMM2.161(DQ9)
M_DB10: CPU.AK32(SB_DQ[10]/SA_DQ[26]) DIMM2.21(DQ14)
M_DB11: CPU.AL32(SB_DQ[11]/SA_DQ[27]) DIMM2.166(DQ15)
M_DB12: CPU.AK34(SB_DQ[12]/SA_DQ[28]) DIMM2.14(DQ12)
M_DB13: CPU.AK35(SB_DQ[8]/SA_DQ[24]) DIMM2.159(DQ13)
M_DB14: CPU.AK31(SB_DQ[14]/SA_DQ[30]) DIMM2.23(DQ10)
M_DB15: CPU.AL31(SB_DQ[15]/SA_DQ[31]) DIMM2.168(DQ11)
M_DB16: CPU.AP34(SB_DQ[21]/SA_DQ[53]) DIMM2.170(DQ21)
M_DB17: CPU.AP35(SB_DQ[16]/SA_DQ[48]) DIMM2.27(DQ16)
M_DB18: CPU.AN32(SB_DQ[18]/SA_DQ[50]) DIMM2.32(DQ22)
M_DB19: CPU.AP32(SB_DQ[19]/SA_DQ[51]) DIMM2.177(DQ23)
M_DB20: CPU.AN35(SB_DQ[17]/SA_DQ[49]) DIMM2.25(DQ20)
M_DB21: CPU.AN34(SB_DQ[20]/SA_DQ[52]) DIMM2.172(DQ17)
M_DB22: CPU.AN31(SB_DQ[22]/SA_DQ[54]) DIMM2.34(DQ18)
M_DB23: CPU.AP31(SB_DQ[23]/SA_DQ[55]) DIMM2.179(DQ19)
M_DB24: CPU.AL29(SB_DQ[24]/SA_DQ[56]) DIMM2.36(DQ28)
M_DB25: CPU.AM29(SB_DQ[25]/SA_DQ[57]) DIMM2.38(DQ24)
M_DB26: CPU.AP29(SB_DQ[26]/SA_DQ[58]) DIMM2.43(DQ30)
M_DB27: CPU.AR29(SB_DQ[27]/SA_DQ[59]) DIMM2.45(DQ26)
M_DB28: CPU.AM28(SB_DQ[28]/SA_DQ[60]) DIMM2.183(DQ25)
M_DB29: CPU.AL28(SB_DQ[29]/SA_DQ[61]) DIMM2.181(DQ29)
M_DB30: CPU.AR28(SB_DQ[30]/SA_DQ[62]) DIMM2.190(DQ27)
M_DB31: CPU.AP28(SB_DQ[31]/SA_DQ[63]) DIMM2.188(DQ31)
M_DB32: CPU.AR12(SB_DQ[32]/SB_DQ[16]) DIMM2.97(DQ32)
M_DB33: CPU.AP12(SB_DQ[33]/SB_DQ[17]) DIMM2.242(DQ33)
M_DB34: CPU.AM12(SB_DQ[38]/SB_DQ[22]) DIMM2.247(DQ39)
M_DB35: CPU.AL12(SB_DQ[39]/SB_DQ[23]) DIMM2.249(DQ35)
M_DB36: CPU.AR13(SB_DQ[36]/SB_DQ[20]) DIMM2.95(DQ36)
M_DB37: CPU.AP13(SB_DQ[37]/SB_DQ[21]) DIMM2.240(DQ37)
M_DB38: CPU.AM13(SB_DQ[34]/SB_DQ[18]) DIMM2.102(DQ38)
M_DB39: CPU.AL13(SB_DQ[35]/SB_DQ[19]) DIMM2.104(DQ34)
M_DB40: CPU.AR10(SB_DQ[41]/SB_DQ[25]) DIMM2.251(DQ45)
M_DB41: CPU.AP10(SB_DQ[40]/SB_DQ[24]) DIMM2.106(DQ44)
M_DB42: CPU.AR7(SB_DQ[42]/SB_DQ[26]) DIMM2.113(DQ46)
M_DB43: CPU.AR6(SB_DQ[46]/SB_DQ[30]) DIMM2.258(DQ47)
M_DB44: CPU.AP9(SB_DQ[45]/SB_DQ[29]) DIMM2.108(DQ40)
M_DB45: CPU.AR9(SB_DQ[44]/SB_DQ[28]) DIMM2.253(DQ41)
M_DB46: CPU.AP7(SB_DQ[43]/SB_DQ[27]) DIMM2.115(DQ42)
M_DB47: CPU.AP6(SB_DQ[47]/SB_DQ[31]) DIMM2.260(DQ43)
M_DB48: CPU.AM10(SB_DQ[48]) DIMM2.117(DQ52)
M_DB49: CPU.AL10(SB_DQ[49]) DIMM2.262(DQ53)
M_DB50: CPU.AL6(SB_DQ[55]) DIMM2.126(DQ50)
M_DB51: CPU.AL7(SB_DQ[51]) DIMM2.271(DQ51)
M_DB52: CPU.AM9(SB_DQ[52]) DIMM2.119(DQ48)
M_DB53: CPU.AL9(SB_DQ[53]) DIMM2.264(DQ49)
M_DB54: CPU.AM6(SB_DQ[54]) DIMM2.124(DQ54)
M_DB55: CPU.AM7(SB_DQ[50]) DIMM2.269(DQ55)
M_DB56: CPU.AJ6(SB_DQ[56]) DIMM2.273(DQ61)
M_DB57: CPU.AH7(SB_DQ[60]) DIMM2.128(DQ60)
M_DB58: CPU.AE6(SB_DQ[58]) DIMM2.280(DQ63)
M_DB59: CPU.AF7(SB_DQ[59]) DIMM2.137(DQ58)
M_DB60: CPU.AH6(SB_DQ[61]) DIMM2.275(DQ57)
M_DB61: CPU.AJ7(SB_DQ[57]) DIMM2.130(DQ56)
M_DB62: CPU.AE7(SB_DQ[62]) DIMM2.282(DQ59)
M_DB63: CPU.AF6(SB_DQ[63]) DIMM2.135(DQ62)
M_DQ_VREF: C73.1 CPU.AC39(SB_DIMM_VREFDQ) R63.2
M_DQ_VREF_RC: C73.2 R106.1
M_DQSA0: CPU.AF38(SA_DQS[0]) DIMM1.153(DQS0P)
M_DQSA1: CPU.AK38(SA_DQS[1]) DIMM1.164(DQS1P)
M_DQSA2: CPU.AP38(SA_DQS[2]/SA_DQS[4]) DIMM1.175(DQS2P)
M_DQSA3: CPU.AV36(SA_DQS[3]/SA_DQS[5]) DIMM1.186(DQS3P)
M_DQSA4: CPU.AV7(SA_DQS[4]/SB_DQS[0]) DIMM1.245(DQS4P)
M_DQSA5: CPU.AU2(SA_DQS[5]/SB_DQS[1]) DIMM1.256(DQS5P)
M_DQSA6: CPU.AN2(SA_DQS[6]/SB_DQS[4]) DIMM1.267(DQS6P)
M_DQSA7: CPU.AJ2(SA_DQS[7]/SB_DQS[5]) DIMM1.278(DQS7P)
M_DQSA#0: CPU.AF39(SA_DQS#[0]) DIMM1.152(DQS0N)
M_DQSA#1: CPU.AK39(SA_DQS#[1]) DIMM1.163(DQS1N)
M_DQSA#2: CPU.AP39(SA_DQS#[2]/SA_DQS#[4]) DIMM1.174(DQS2N)
M_DQSA#3: CPU.AU36(SA_DQS#[3]/SA_DQS#[5]) DIMM1.185(DQS3N)
M_DQSA#4: CPU.AW7(SA_DQS#[4]/SB_DQS#[0]) DIMM1.244(DQS4N)
M_DQSA#5: CPU.AU3(SA_DQS#[5]/SB_DQS#[1]) DIMM1.255(DQS5N)
M_DQSA#6: CPU.AN3(SA_DQS#[6]/SB_DQS#[4]) DIMM1.266(DQS6N)
M_DQSA#7: CPU.AJ3(SA_DQS#[7]/SB_DQS#[5]) DIMM1.277(DQS7N)
M_DQSB0: CPU.AF35(SB_DQS[0]/SA_DQS[2]) DIMM2.153(DQS0P)
M_DQSB1: CPU.AL33(SB_DQS[1]/SA_DQS[3]) DIMM2.164(DQS1P)
M_DQSB2: CPU.AP33(SB_DQS[2]/SA_DQS[6]) DIMM2.175(DQS2P)
M_DQSB3: CPU.AN28(SB_DQS[3]/SA_DQS[7]) DIMM2.186(DQS3P)
M_DQSB4: CPU.AN12(SB_DQS[4]/SB_DQS[2]) DIMM2.245(DQS4P)
M_DQSB5: CPU.AP8(SB_DQS[5]/SB_DQS[3]) DIMM2.256(DQS5P)
M_DQSB6: CPU.AL8(SB_DQS[6]) DIMM2.267(DQS6P)
M_DQSB7: CPU.AG7(SB_DQS[7]) DIMM2.278(DQS7P)
M_DQSB#0: CPU.AF34(SB_DQS#[0]/SA_DQS#[2]) DIMM2.152(DQS0N)
M_DQSB#1: CPU.AK33(SB_DQS#[1]/SA_DQS#[3]) DIMM2.163(DQS1N)
M_DQSB#2: CPU.AN33(SB_DQS#[2]/SA_DQS#[6]) DIMM2.174(DQS2N)
M_DQSB#3: CPU.AN29(SB_DQS#[3]/SA_DQS#[7]) DIMM2.185(DQS3N)
M_DQSB#4: CPU.AN13(SB_DQS#[4]/SB_DQS#[2]) DIMM2.244(DQS4N)
M_DQSB#5: CPU.AR8(SB_DQS#[5]/SB_DQS#[3]) DIMM2.255(DQS5N)
M_DQSB#6: CPU.AM8(SB_DQS#[6]) DIMM2.266(DQS6N)
M_DQSB#7: CPU.AG6(SB_DQS#[7]) DIMM2.277(DQS7N)
MIC2-VREFO: RA72.1 RA73.1 UA1.29(MIC2-VREFO)
MSCLK: L14.1 RN5.1 SIO_5553.115(MCLK)
MSDATA: L16.1 RN5.2 SIO_5553.116(MDAT)
NIC_USB2_N4: LU2.3 RU120.2 U4.AE1(USB2N4)
NIC_USB2_N5: LU1.4 RU3.2 U4.AC2(USB2N5)
NIC_USB2_P4: LU2.4 RU5.2 U4.AE2(USB2P4)
NIC_USB2_P5: LU1.3 RU4.2 U4.AC3(USB2P5)
O_+12VCOM: C386.1 CO32.1 CPO1.1 DO2.2(CATHODE) UO2.1(VDD)
O_-12VCOM: C383.1 CO33.1 CPO2.1 DO3.1(ANODE) UO2.10(VSS)
O_A20GATE: R495.2 SIO_5553.119(GP064/A20M)
O_AUD_PCSPKR_DET#: CA111.1 INT_SPKR.3 RU174.2 U4.AJ33(GPP_D5_SSP0_SFRM)
O_AUD_PCSPKR_DET#_SIO: RO32.2 RO117.2 SIO_5553.54((PC_SPKR_DET) GP031)
O_CHAFAN_PWM: RF5.2 RF11.1 SIO_5553.48(GP023/PWM2)
O_CPUFAN_PWM: RNF2.8 SIO_5553.47(GP022/PWM1) U122.4(EMITTER)
O_CPUFAN_PWM_R: RF6.1 U122.3(COLLECTOR)
O_CTS1#: CNO1.4 UO2.3(RA2) VGA_COM.A8(23)
O_CTS1#_R: SIO_5553.101(NCTS1/GP050) UO2.18(RY2)
O_DCD1#: CNO2.8 UO2.9(RA5) VGA_COM.A1(16)
O_DCD1#_R: SIO_5553.96(NDCD1/GP043) UO2.12(RY5)
O_DSR1#: CNO1.6 UO2.4(RA3) VGA_COM.A6(21)
O_DSR1#_R: SIO_5553.97(NDSR1/GP044) UO2.17(RY3)
O_DTR1#: CNO2.2 UO2.6(DY2) VGA_COM.A4(19)
O_DTR1#_R: RO27.2 SIO_5553.102(NDTR1/GP051) UO2.15(DA2)
O_FIO_SATA_LED#: CO53.1 HDD_LED.2(LED-) QM2.3(COLLECTOR) QO6.3(COLLECTOR) RNO2.4
O_FP_CBL_DET#_SIO: RO176.1 SIO_5553.50((NFP_CBL_DET) GP025)
O_GREEN#: CO52.1 QO12.2(BASE) RNO5.8 SIO_5553.2(GP000/PWM4) SIO_5553.24(NGREEN/GP007)
O_GREEN#_CTL: QO12.5(BASE) QO12.6(COLLECTOR) RNO5.7
O_GREEN#_R: PWR_SW.4(L2) QO12.3(COLLECTOR) RIO9.2
O_MB_REG_PG: RO16.1 SIO_5553.109((MB_REG_PG) GP057)
O_MB_REG_PG_R: QO1.6(COLLECTOR) QO2.3(COLLECTOR) QO4.3(COLLECTOR) QO4.6(COLLECTOR) RNO1.7 RO16.2
O_MEM_REG_PG: RO18.1 SIO_5553.111((MEM_REG_PG) GP061)
O_MEM_REG_PG_R: QO1.3(COLLECTOR) RNO1.6 RO18.2
O_PCIAUX_CTRL: PR31.2 PR35.1 QS11.D1 QS11.D2 QV72.D(DRAIN) RO99.1
O_PCIAUX_CTRL_R: RO99.2 SIO_5553.91(NC9)
O_PSON#: ATX_SYS.8 PC302.1 PQ71.G(GATE) PR231.2 RO9.1 SIO_5553.53(NPS_ON/GP030)
O_PWR2_PRSNT_R: QO5.6(COLLECTOR) RNO1.8 SIO_5553.108((PWR2_PRSNT) GP056)
O_QO11_2: RNF2.4 U122.2(BASE)
O_QO11_5: RNF2.7 U122.5(BASE)
O_RI1#: CNO1.2 UO2.2(RA1) VGA_COM.A9(24)
O_RI1#_R: SIO_5553.103(NRI1/GP052) UO2.19(RY1)
O_RTS1#: CNO1.8 UO2.5(DY1) VGA_COM.A7(22)
O_RTS1#_R: RNO1.5 SIO_5553.99(NRTS1/GP046) UO2.16(DA1)
O_RXD1: CNO2.4 UO2.7(RA4) VGA_COM.A2(17)
O_RXD1_R: SIO_5553.98(RXD1/GP045) UO2.14(RY4)
O_SEN_CHAFAN: CF4.1 RF2.1 RF3.1 SIO_5553.38(TACH2/GP020)
O_SEN_CPUFAN: RF8.1 SIO_5553.37(TACH1/GP017)
O_SEN_CPUFAN_R: RF7.1 RF8.2 RF9.1 U122.6(COLLECTOR)
O_SPEAKER: CA19.2 RO39.2 RO169.1 SIO_5553.125(SPEAKER [NDIAG_EN]/GP070)
O_SUS_3V_F_ON: RO33.2 SIO_5553.56(NSUS3V_FON/GP032)
O_SUS_3V_ON: RO35.2 SIO_5553.74(NSUS3V_ON/GP076)
O_SUS_3VON: CO19.2 CO20.2 DO1.2(C) PR30.2 RO31.2 RO33.1 RO35.1
O_SUS_5VON: RO167.1 SIO_5553.73(NSUS5V_ON/GP075)
O_SUS_ACK_EN_R#: PR382.2 SIO_5553.94(NSUS_ACK_EN/GP127)
O_TR_CPU+: C1724.1 CO16.1 SIO_5553.41(REMOTE1+) THRM_1.B(BASE) THRM_1.C(COLLECTOR)
O_TR_CPU-: C1724.2 CO16.2 SIO_5553.42(REMOTE1-) THRM_1.E(EMITTER)
O_TR_MB+: C1723.1 CO17.1 SIO_5553.43(REMOTE2A+/REMOTE2B-) THRM_2.B(BASE) THRM_2.C(COLLECTOR)
O_TR_MB-: C1723.2 CO17.2 SIO_5553.44(REMOTE2A-/REMOTE2B+) THRM_2.E(EMITTER)
O_TRST#: RO28.2 SIO_5553.124(NTRST)
O_TXD1: CNO2.6 UO2.8(DY3) VGA_COM.A3(18)
O_TXD1_R: QO2.6(COLLECTOR) RO11.2 RO23.2 UO2.13(DA3)
O_TXD1_R_C: RO11.1 SIO_5553.100((5V_PRSNT) GP047/TXD1)
O_V5_ALW_MON: QO3.6(COLLECTOR) RO52.1 RO189.2 SIO_5553.15(V5_ALW_MON)
O_V_IN: RO21.1 SIO_5553.46(V_IN)
O_YELLOW#: CO54.1 QO14.2(BASE) RNO5.6 SIO_5553.23(NYELLOW/GP006)
O_YELLOW#_CTL: QO14.5(BASE) QO14.6(COLLECTOR) RNO5.5
O_YELLOW#_R: PWR_SW.1(L1) QO14.3(COLLECTOR) RIO8.2
OQ14_C: QO6.5(BASE) QO6.6(COLLECTOR) RNO2.2
PCH_24M_PCICLK: R6394.2 U4.AV19(GPP_A10_CLKOUT_LPC1)
PCH_AUD_MUTE: RA8.1 U4.BC35(GPP_H13_SML3CLK)
PCH_CPU_TRIGGER_IN: R6613.2 U4.AL2(TRIGGER_OUT)
PCH_CPU_TRIGGER_IN_R: CPU.D1(PROC_TRIGIN) R6613.1
PCH_DISPA_BCLK: CPU.V3(PROC_AUDIO_CLK) R6350.1
PCH_DISPA_BCLK_R: R6350.2 U4.AM2(DISPA_BCLK)
PCH_DISPA_SDI: R50.2 U4.AN2(DISPA_SDI)
PCH_DISPA_SDI_R: CPU.U1(PROC_AUDIO_SDO) R50.1
PCH_DISPA_SDO: CPU.V2(PROC_AUDIO_SDI) R6351.1
PCH_DISPA_SDO_R: R6351.2 U4.AM1(DISPA_SDO)
PCH_DPWROK: R6628.1 RO89.1 U4.AV11(DSW_PWROK)
PCH_DPWROK_C: RO89.2 SIO_5553.28(DPWROK/GP013)
PCH_FVS: FVS.1 R6669.2 U4.L43(GPP_G23)
PCH_GPD0: R6664.2 U4.BD13(GPD0_BATLOW_N)
PCH_GPD1: R6435.2 U4.BB15(GPD1_ACPRESENT)
PCH_GPD4: R6660.1 U4.AW15(GPD4_SLP_S3#)
PCH_GPD5: R6661.1 U4.BD15(GPD5_SLP_S4#)
PCH_GPD6: R6662.1 U4.BC15(GPD6_SLP_A_N)
PCH_HDBCLK: R6339.2 U4.BA9(HDA_BCLK)
PCH_HDRST#: R6341.2 U4.BD8(HDA_RST#)
PCH_HDSDO: R6346.2 R6347.2 U4.BB7(HDA_SDO)
PCH_HDSYNC: R6348.2 U4.BD9(HDA_SYNC)
PCH_HSIN5: CL1.1 U4.K19(PERN5)
PCH_HSIN5_C: CL4.2 RTK_LAN.14(HSIN)
PCH_HSIN6: CX126.1 U4.G22(PERN6)
PCH_HSIN7: SLOT2.A17(PERN0) U4.L22(PERN7)
PCH_HSIP5: CL2.1 U4.L19(PERP5)
PCH_HSIP5_C: CL3.2 RTK_LAN.13(HSIP)
PCH_HSIP6: CX127.1 U4.E22(PERP6)
PCH_HSIP7: SLOT2.A16(PERP0) U4.K22(PERP7)
PCH_HSON5: CL4.1 U4.D22(PETN5)
PCH_HSON5_C: CL1.2 RTK_LAN.18(HSON)
PCH_HSON6: CX118.1 U4.B22(PETN6)
PCH_HSON7: CX53.1 U4.C23(PETN7)
PCH_HSON7_C: CX53.2 SLOT2.B15(PETN0)
PCH_HSOP5: CL3.1 U4.C22(PETP5)
PCH_HSOP5_C: CL2.2 RTK_LAN.17(HSOP)
PCH_HSOP6: CX119.1 U4.A23(PETP6)
PCH_HSOP7: CX52.1 U4.B23(PETP7)
PCH_HSOP7_C: CX52.2 SLOT2.B14(PETP0)
PCH_ITP_PMODE: RS16.2 U4.AT2(TP1)
PCH_JTAG_TCK: RP8.1 U4.AN3(JTAG_TCK) XDP_CPU.55(TCK1)
PCH_LPC_AD0: R6375.2 U4.AT22(GPP_A1_LAD0_ESPI_IO0)
PCH_LPC_AD1: R6378.2 U4.AV22(GPP_A2_LAD1_ESPI_IO1)
PCH_LPC_AD2: R6380.2 U4.AT19(GPP_A3_LAD2_ESPI_IO2)
PCH_LPC_AD3: R6383.2 U4.BD16(GPP_A4_LAD3_ESPI_IO3)
PCH_LPC_FRAME#: R6388.2 U4.BE16(GPP_A5_LFRAME_N_ESPI_CS_N)
PCH_M2_SSD_CLKREQ_N: M.2_SSD.52(CLKREQ#) RX185.2 U4.BD25(GPP_B8_SRCCLKREQ3_N)
PCH_OC#_0: RU47.1 RU147.2 U4.AD43(GPP_E9_USB2_OC0_N) XDP_PCH.10(OBSDATA_C0)
PCH_OC#_1: RU26.2 RU29.1 U4.AD42(GPP_E10_USB2_OC1_N) XDP_PCH.12(OBSDATA_C1)
PCH_OC#_2: RH5.2 U4.AD39(GPP_E11_USB2_OC2_N) XDP_PCH.16(OBSDATA_C2)
PCH_OC#_3: PR344.1 PR345.1 PU20.3(F\L\G\) R6607.1 R6608.2 U4.AC44(GPP_E12_USB2_OC3_N) XDP_PCH.18(OBSDATA_C3)
PCH_OC#_4: RU134.2 RU135.1 U4.Y43(GPP_F15_USB2_OCB_4)
PCH_OC#_5: CU13.1 RU68.1 RU69.1 U4.Y41(GPP_F16_USB2_OCB_5)
PCH_PCIE_RCOMP: R6465.1 U4.B18(PCIE_RCOMPN)
PCH_PECI_R: CO51.1 R6408.1 R6582.1 U4.AL3(PECI)
PCH_PRDY_N: R148.2 U4.AT4(PRDY_N)
PCH_PREQ_N: R149.2 U4.AT3(PREQ_N)
PCH_RSMRST#: R6418.1 U4.BA11(RSMRST_N)
PCH_STRAP_BBS: R74.2 R75.1 U4.AT29(GPP_B22_GSPI1_MOSI)
PCH_STRAP_ESPI_EN: R71.1 R72.1 U4.BA40(GPP_C5_SML0ALERT#)
PCH_STRAP_EXI_N: Q3.S(SOURCE) R77.1 RA12.2 U4.AT27(GPP_B23_SML1ALERT_N_PCHHOT_N)
PCH_STRAP_GPP_B18: R79.2 R80.1 U4.BD28(GPP_B18_GSPI0_MOSI)
PCH_STRAP_GPP_H12: R81.2 RA59.2 U4.BD35(GPP_H12_SML2ALERT_N)
PCH_STRAP_TLS: R69.1 R70.1 U4.BB41(GPP_C2_SMBALERT#)
PCH_WAKE#: R6544.1 RK9.1 SLOT2.B11(W\A\K\E\) U4.BC13(WAKE_N)
PCI_CLKREQ#: BRIDGE.D11(CLKREQ#) RK27.2
PCI_FBCLK: BRIDGE.B11(CLKOUT6) RK6.2
PCI_REQ2#: BRIDGE.A8(REQ2#) RK47.1
PCI_REQ3#: BRIDGE.C8(REQ3#) RK48.1
PCI_REQ4#: BRIDGE.C9(REQ4#) RK46.1
PCI_REQ5#: BRIDGE.A12(REQ5#) RK38.1
PCIAUX_GATE_R: RO3.1 RO7.1 RO100.2 SIO_5553.92(GP125)
PCIE_RCOMP_R: R6465.2 U4.C17(PCIE_RCOMPP)
PCIE_SLOT2_PRSNT_N: RX165.2 SLOT2.B17(P\R\S\N\T\2) U4.AR24(GPP_B15_GSPI0_CS_N)
PCIR: BRIDGE.A1(PCIR_2) BRIDGE.K3(PCIR_1) CK53.1 CK54.1 RK42.1
PCLK66_SEL: BRIDGE.B12(PCLK66_SEL) RK22.2
PD_USB2_VBUSSENSE: R6331.1 U4.AD10(USB2_VBUSSENSE)
