# Allegro board Phoenix-A00-Layout-20161019.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+5VAUX_BOOT_20: length 0.8
  TOP w0.203: 43.34,52.32 43.45,52.22 PU16.17
  vias: v1(42.45,53.21)
+5VAUX_BOOTR_20: length 2.7
  TOP w0.508: PC328.1 39.53,53.16 PR257.1 39.53,54.86 v1(40.04,55.37)
+5VAUX_CS: length 3.9
  TOP w0.203: PU16.1 44.83,50.03 44.75,49.95
  TOP w0.254: PR273.1 v1(43.27,48.13) 43.47,48.13 44.61,49.28 44.61,49.81 44.75,49.95
+5VAUX_EN: length 5.2
  TOP w0.203: 44.11,50.42 PU16.20
  TOP w0.254: PR276.1 40.52,50.58 40.52,50.19 v1(40.55,50.16) 41.63,50.16 PC339.1 PR275.1 43.8,50.1 44.11,50.42
+5VAUX_FB: length 8.4
  TOP w0.102: PR266.2 44.47,47.05 44.69,46.84 44.69,45.59 44.61,45.52 v1(44.61,45.34)
  TOP w0.203: 45.23,49.89 PU16.2
  TOP w0.254: 45.23,49.89 45.23,49.26 44.23,48.26 PR266.2 PC335.2 PR270.1 PR271.1
+5VAUX_FB_R: length 48.5
  TOP w0.254: v1(43.34,45.45) PC335.1 PR266.1
  BOTTOM w0.254: v1(43.34,45.45) 44.36,44.43 44.36,40.39 42.45,38.48 27.59,38.48 v2(27.21,38.86) 26.42,39.65 26.42,43.74 23.27,46.89 23.27,53.59 18.83,58.04 PJP30.2
+5VAUX_LG_25:
  vias: v1(35.59,53.85) v1(36.23,53.85) v1(43.47,54.1) v1(44.1,54.1) v2(36.94,53.39)
+5VAUX_LPS_LDO: length 709.2
  TOP w0.203: PU16.13 PC337.1
  TOP w0.508: PR236.1 34.58,62.1 31.94,59.46 ; v1(198.15,19.09) DA7.1 196.84,19.64 FBA1.1 ; v1(18.32,62.74) 18.42,62.64 28.76,62.64 31.94,59.46 ; v1(120.56,42.29) 118.33,40.07 PR243.1 ; v1(66.58,63.25) 66.58,61.09 69.63,58.04 69.63,50.67 68.11,49.15 68.11,47.12 65.37,44.39 v1(59.41,44.39) ; v1(19.12,79.59) 15.51,79.59 12.68,76.75 12.68,74.18 ; 12.68,74.18 6.49,74.18 5.74,73.43 5.74,49.4 11.9,43.24 PR231.1 ; 12.68,74.18 13.83,73.03 v1(14.82,73.03) ; v1(14.82,73.03) 14.82,71.93 14,71.12 RO189.1 ; v1(14.82,73.03) 16.73,73.03 PR24.1 ; 31.94,59.46 31.94,57.33 32.55,56.72 44.22,56.72 45.61,55.32 PC337.1 ; v1(19.44,87) 19.39,87.05 11.36,87.05 7.45,90.96 7.45,98.78 v1(9.66,100.99) ; RO167.2 v1(221.39,58.8) 222.69,58.8 227.26,54.23 230.41,54.23 231.24,55.05 PR392.1 PR389.1 v1(232.95,54.15) ; RO9.2 v1(233.08,47.62) ; v1(75.6,80.52) 75.6,74.06 74.46,72.92 74.46,62.86 78.27,59.06 v1(78.27,58.67) ; v1(13.75,161.42) 13.72,161.42 11.78,163.37 11.78,182.54 10.27,184.05 7.48,184.05 6.18,185.35 6.18,207.89 PR31.1 ; v1(94.65,103.12) 100.21,103.12 100.87,102.46 100.87,99.76 PR76.1 ; PR17.1 v1(232.51,59.87) ; PR41.1 223.3,69.91 v1(223.3,69.85) ; v1(220.25,63.25) 218.47,63.25 216.95,64.77 211.2,64.77 202.56,56.13 199.93,56.13 197.01,53.21 v1(194.6,53.21) 193.71,52.32 193.71,43.78 206.66,30.83 206.66,24.38 207.66,23.39 v1(207.66,19.09) ; v1(168.56,55.5) 168.18,55.12 168.18,50.05 167.65,49.51 167.65,46.63 163.74,42.72 v1(163.74,39.57)
  BOTTOM w0.508: v1(13.75,161.42) 12.99,160.66 12.99,158.45 13.37,158.06 13.37,148.97 13.7,148.64 13.7,141.17 10.5,137.97 10.5,126.09 12.56,124.03 12.56,111.8 12.02,111.26 12.02,103.35 v1(9.66,100.99) ; v1(163.74,39.57) 154.03,39.57 153.06,40.55 150.95,40.55 149.92,41.58 146.46,41.58 145.43,40.55 139.32,40.55 138.29,41.58 124.87,41.58 124.16,42.29 v1(120.56,42.29) 120.05,42.29 118.37,43.97 115.13,43.97 109.49,49.61 97.77,49.61 96.43,48.26 92.87,48.26 86.48,54.65 84.58,54.65 81.93,57.29 79.65,57.29 v1(78.27,58.67) 78.27,59.06 75.95,61.37 71.22,61.37 69.34,63.25 v1(66.58,63.25) ; v1(168.56,55.5) 169.45,56.39 169.45,57.28 170.09,57.91 178.34,57.91 179.13,57.12 189.67,57.12 193.58,53.21 v1(194.6,53.21) ; v1(221.39,58.8) 221.39,60.32 220.25,61.47 v1(220.25,63.25) 220.25,64.13 223.3,67.17 v1(223.3,69.85) ; v1(233.08,47.62) 233.76,48.31 233.76,53.34 v1(232.95,54.15) 232.51,54.6 v1(232.51,59.87) ; v1(19.44,87) 19.44,84.4 18.4,83.36 18.4,82.47 19.12,81.75 v1(19.12,79.59) ; v1(59.41,44.39) 59.41,40.96 57.56,39.12 44.61,39.12 43.47,37.97 26.78,37.97 25.69,39.07 25.69,43.76 22.77,46.68 22.77,53.38 17.05,59.1 17.05,61.21 18.32,62.48 v1(18.32,62.74) 18.32,63.73 17.2,64.85 v2(17.2,69.47) 17.2,70.64 v1(14.82,73.03) ; v1(207.66,19.09) 207.65,19.09 v1(198.15,19.09) ; v1(75.6,80.52) 77.22,80.52 77.43,80.72 84.64,80.72 88.96,85.04 88.96,91.85 93.23,96.11 93.23,101.7 v1(94.65,103.12)
+5VAUX_PHASE_25: length 1
  TOP w0.203: PU16.18 43.09,51.82
  vias: v1(28.74,48.51) v1(30.51,52.83) v1(30.51,51.44) v1(30.51,49.78) v1(32.16,52.83) v1(32.16,51.41) v1(32.16,49.78) v1(33.82,52.83) v1(33.82,51.31) v1(33.82,49.78) v1(34.58,47.88) v1(35.21,47.88) v1(41.82,52.45) v1(42.32,52.07)
+5VAUX_PHASE_R:
  vias: v1(39.15,48.64)
+5VAUX_UG_25:
  vias: v1(39.53,47.5) v1(40.29,47.5) v1(43.47,53.21) v1(44.1,53.21) v2(43.98,52.07)
+5VAUX_UGR_25:
  vias: v1(29.88,47.24) v1(29.88,46.61) v1(36.61,46.23) v1(37.24,46.23) v2(30.87,46.23)
+5VAUX_VCLK: length 3.9
  TOP w0.203: PU16.19 43.77,51.42 43.45,51.1
  TOP w0.254: PR272.1 41.75,50.93 v1(42.32,50.93) 42.37,50.88 43.23,50.88 43.45,51.1
+12V_CPU: length 190.6
  TOP w0.508: RO56.1 214.85,62.04 214.92,61.98 v1(221.27,61.98) ; v1(231.89,199.31) 231.05,200.15 231.05,202.42 ATX_CPU.3
  TOP w0.889: 219.5,214.59 PL6.1 ; PL6.1 220.47,215.55 ; PL6.1 221.43,214.59 ; PL6.1 220.47,213.62
  TOP w1.27: 229.33,207.13 ATX_CPU.4 ; ATX_CPU.4 230.55,208.35 ; ATX_CPU.4 228.11,208.35 ; ATX_CPU.4 229.33,209.57 ; ATX_CPU.3 230.55,204.15 ; ATX_CPU.3 228.11,204.15 ; ATX_CPU.3 229.33,205.37
  BOTTOM w0.508: v1(221.27,61.98) v2(222.03,61.98) 222.03,64.19 224.8,66.96 224.8,76.89 225.38,77.47 225.38,87.01 225.81,87.43 225.81,91.14 222.84,94.11 222.84,103.53 227.24,107.92 227.24,110.82 231.53,115.11 231.53,125.5 v1(228.76,128.27) 228.2,128.83 228.2,136.2 231.5,139.5 232.52,139.5 233.92,140.89 233.92,142.07 235.87,144.03 235.87,196.6 v2(233.45,199.02) 233.16,199.31 v1(231.89,199.31)
  BOTTOM w0.889: PL6.1 221.43,214.59 ; PL6.1 220.47,215.55 ; PL6.1 219.5,214.59 ; PL6.1 220.47,213.62
  BOTTOM w1.27: ATX_CPU.3 228.11,204.15 ; ATX_CPU.3 229.33,205.37 ; ATX_CPU.3 230.55,204.15 ; ATX_CPU.4 229.33,209.57 ; ATX_CPU.4 228.11,208.35 ; ATX_CPU.4 229.33,207.13 ; ATX_CPU.4 230.55,208.35
  vias: v1(222.28,215.77) v1(222.28,214.76) v1(222.28,213.61) v1(222.28,212.6) v1(222.66,209.93) v1(222.66,207.14) v1(222.66,205.99) v1(223.05,211.07) v1(223.43,215.77) v1(223.43,214.76) v1(223.43,213.61) v1(223.43,212.6) v1(224.32,211.07) v1(225.46,211.07) v1(225.46,210.06) v1(225.46,207.14) v1(225.46,205.87) v1(226.47,204.6) v1(226.6,212.6) v1(226.6,211.07) v1(226.6,210.06) v1(226.6,208.53) v1(226.6,206.88) v1(226.6,205.87) v1(227.87,211.07) v1(227.87,210.06) v1(227.87,206.88) v1(227.87,205.87) v1(229.01,206.88) v1(229.01,205.87) v1(230.16,206.88) v1(230.16,205.87)
+12V_CPU_VIN: length 59.8
  TOP w0.254: PR120.1 PR91.1 v1(222.47,200.19) ; PR118.1 v1(218.73,200.15)
  TOP w0.508: PC152.1 226.6,169.42 226.73,169.29 ; PC167.1 228.25,151.51
  TOP w0.762: PCE13.1 173.49,213.74 ; PCE13.1 174.43,214.68 ; PCE13.1 174.43,212.8 ; PCE13.1 175.37,213.74
  TOP w0.889: PC179.1 149.29,205.05 ; PC179.1 150.23,205.99 ; PC179.1 148.35,205.99 ; PCE14.1 227.34,176.4 ; PCE14.1 228.28,177.34 ; PCE14.1 229.22,176.4 ; PCE14.1 228.28,175.46 ; 215,218.99 PL6.2 ; PL6.2 215.97,218.02 ; PL6.2 216.93,218.99 ; PL6.2 215.97,219.95 ; PCE12.1 188.02,217.86 ; PCE12.1 187.08,216.92 ; PCE12.1 188.02,215.98 ; PCE12.1 188.96,216.92
  BOTTOM w0.254: v3(216.71,215.14) 217.58,215.14 220.89,211.84 220.89,208.23 220.56,207.9 220.56,202.92 218.93,201.29 218.93,200.36 v1(218.73,200.15) 218.98,199.9 220.3,199.9 220.61,200.2 222.46,200.2 v1(222.47,200.19)
  BOTTOM w0.889: 173.49,213.74 PCE13.1 ; PCE13.1 174.43,214.68 ; PCE13.1 175.37,213.74 ; PCE13.1 174.43,212.8 ; PC179.1 149.29,206.93 ; PC179.1 150.23,205.99 ; PC179.1 149.29,205.05 ; PC179.1 148.35,205.99 ; 187.08,216.92 PCE12.1 ; PCE12.1 188.02,217.86 ; PCE12.1 188.02,215.98 ; PCE12.1 188.96,216.92
  BOTTOM w1.016: PL6.2 216.93,218.99 ; PL6.2 215.97,219.95 ; PL6.2 215.97,218.02 ; PL6.2 215,218.99
  vias: v1(146.46,193.68) v1(146.46,193.04) v1(147.23,193.68) v1(147.23,193.04) v1(147.35,202.56) v1(147.35,201.93) v1(147.48,206.76) v1(147.48,206.12) v1(147.48,205.49) v1(147.86,197.36) v1(147.86,196.34) v1(147.86,195.33) v1(147.99,202.56) v1(147.99,201.93) v1(147.99,193.68) v1(147.99,193.04) v1(148.12,206.76) v1(148.12,206.12) v1(148.12,205.49) v1(150.53,206.76) v1(150.53,206.12) v1(150.53,205.49) v1(165.13,210.31) v1(165.13,208.91) v1(165.13,207.26) v1(166.78,210.31) v1(166.78,208.89) v1(166.78,207.26) v1(167.55,213.87) v1(168.44,213.87) v1(168.44,210.31) v1(168.44,208.79) v1(168.44,207.26) v1(169.32,213.87) v1(170.21,213.87) v1(171.23,213.87) v1(181.39,213.74) v1(182.28,210.69) v1(182.28,208.91) v1(182.28,207.14) v1(182.41,213.74) v1(183.29,213.74) v1(183.8,210.69) v1(183.8,208.91) v1(183.8,207.14) v1(184.31,213.74) v1(185.2,213.74) v1(185.33,210.69) v1(185.33,208.91) v1(185.33,207.14) v1(200.57,215.01) v1(200.57,213.49) v1(200.57,211.96) v1(202.22,215.01) v1(202.22,213.49) v1(202.22,211.96) v1(203.74,215.01) v1(203.74,213.49) v1(203.74,211.96) v1(219.5,218.31) v1(220.87,218.31) v1(222.02,218.31) v1(226.73,168.4) v1(226.73,166.88) v1(226.73,165.35) v1(226.86,150.75) v1(226.86,149.22) v1(226.86,147.7) v1(228.38,175.26) v1(228.38,168.4) v1(228.38,166.88) v1(228.38,165.35) v1(228.51,150.75) v1(228.51,149.22) v1(228.51,147.7) v1(228.53,177.75) v1(229.52,176.53) v1(229.9,168.4) v1(229.9,166.88) v1(229.9,165.35) v1(230.03,150.75) v1(230.03,149.22) v1(230.03,147.7) v1(234.63,205.14) v1(234.64,202.58) v2(188.68,213.89) v3(162.47,209.55) v3(162.59,211.58) v3(164.63,214.12) v3(166.15,215.77) v3(169.96,217.04) v3(172.88,213.61) v3(173.26,217.04) v3(174.4,215.26) v3(174.4,212.22) v3(175.93,213.74) v3(176.31,217.04) v3(180.12,217.04) v3(186.47,216.79) v3(187.87,215.65) v3(188.88,218.06) v3(189.52,216.92) v3(193.58,219.84) v3(195.18,214.1) v3(195.36,219.84) v3(196.2,214.1) v3(196.25,212.09) v3(197.09,214.1) v3(198.03,219.84) v3(198.1,214.1) v3(198.41,212.09) v3(199.12,214.1) v3(200.31,217.17) v3(202.09,219.84) v3(204.25,217.04) v3(206.03,219.84) v3(207.93,217.17) v3(210.35,219.84) v3(210.85,217.04) v3(211.09,215.18) v3(214.28,219.71) v3(214.26,215.05) v3(214.41,218.06) v3(215.93,217.3) v3(217.58,219.33) v3(217.58,217.3) v3(229.52,153.16) v3(229.52,152.15) v3(230.28,153.16) v3(230.28,152.15) v3(230.67,164.08) v3(230.92,152.65) v3(231.15,169.55) v3(231.17,167.51) v3(231.17,166.37) v3(231.43,164.08) v3(231.81,149.73) v3(231.81,148.72) v3(231.88,169.55) v3(231.94,167.51) v3(231.94,166.37) v3(232.19,164.08) v3(232.57,149.73) v3(232.57,148.72)
+12V_DUAL: length 18
  TOP w0.406: v1(129.19,31.62) 123.6,37.21 PR244.1
  TOP w0.508: CS213.1 146.11,62.74 v1(146.08,62.76)
  TOP w0.889: PCE33.1 64.96,34.21 ; PCE33.1 64.02,33.27 ; PCE33.1 65.9,33.27 ; PCE33.1 64.96,32.33
  BOTTOM w0.889: 64.02,33.27 PCE33.1 ; PCE33.1 64.96,34.21 ; PCE33.1 65.9,33.27 ; PCE33.1 64.96,32.33
  vias: v1(55.15,33.66) v1(55.15,32.89) v1(55.91,33.66) v1(55.91,32.89) v1(56.68,33.66) v1(56.68,32.89) v1(57.44,33.66) v1(57.44,32.89) v1(61.37,42.93) v1(61.37,42.29) v1(61.37,41.66) v1(61.37,41.02) v1(62.01,42.93) v1(62.01,42.29) v1(62.01,41.66) v1(62.64,42.93) v1(62.64,42.29) v1(63.28,42.93) v1(63.79,33.27) v1(64.93,34.42) v1(64.93,32.13) v1(66.07,33.27) v1(71.28,75.32) v1(71.28,74.68) v1(71.92,75.32) v1(71.92,74.68) v1(72.55,75.32) v1(72.55,74.68) v1(73.19,75.32) v1(73.19,74.68) v1(75.09,48.39) v1(76.11,48.39) v1(77,48.39) v1(78.01,48.39) v1(112.76,74) v1(112.74,73.26) v1(113.41,74.01) v1(113.42,73.26) v1(149.09,63.75) v1(149.42,63.2) v1(149.4,62.56) v1(149.43,64.29) v1(157.01,30.45) v1(157.01,29.76) v1(157.77,30.45) v1(157.77,29.76) v1(158.53,30.45) v1(158.53,29.76) v1(159.3,30.45) v1(159.3,29.76) v1(162.21,64.26) v1(162.21,63.5) v1(163.1,64.26) v1(163.1,63.5) v2(150.91,30.1)
+12V_DUAL_3V5V_VIN: length 7.5
  TOP w0.889: 42.07,42.09 PCE34.1 ; PCE34.1 43.01,43.03 ; PCE34.1 41.13,43.03 ; PCE34.1 42.07,43.96
  BOTTOM w0.889: 41.13,43.03 PCE34.1 ; PCE34.1 42.07,42.09 ; PCE34.1 42.07,43.96 ; PCE34.1 43.01,43.03
  vias: v1(29.5,44.07) v1(29.5,43.31) v1(29.5,42.54) v1(29.5,41.78) v1(30.64,44.83) v1(30.64,43.43) v1(30.64,41.78) v1(32.29,44.83) v1(32.29,43.41) v1(32.29,41.78) v1(33.94,44.83) v1(33.94,43.31) v1(33.94,41.78) v1(40.55,43.05) v1(41.18,43.94) v1(41.18,42.04) v1(42.2,41.53) v1(49.44,40.64) v1(50.33,40.64) v1(50.45,42.42) v1(51.21,42.42) v1(51.21,40.64) v1(52.1,40.64) v1(53.37,43.94) v1(53.37,42.54) v1(53.37,40.89) v1(55.02,43.94) v1(55.02,42.52) v1(55.02,40.89) v1(56.68,43.94) v1(56.68,42.42) v1(56.68,40.89)
+12V_MAIN: length 490.3
  TOP w0.381: v1(101.25,142.49) 101.25,143.26 101.76,143.76 PR214.1 ; v1(82.33,107.82) 82.33,111.32 86.96,115.95 86.96,123.57 85.76,124.78 85.76,131.67 86.16,132.08 86.16,132.82 86.62,133.27 v1(86.62,134.37)
  TOP w0.508: v1(4.54,209.51) 5.02,209.99 CS214.1 ; 68.89,237.74 ECK4.1 ; ECK4.1 69.78,236.85 ; ECK4.1 70.67,237.74 ; ECK4.1 69.78,238.63 ; CS216.1 v1(18.83,35.12) ; v1(223.26,221.4) 223.93,222.08 UF147.8 ; v1(17.31,34.29) 17.62,33.97 CS178.2 ; CS215.1 12.35,36.13 v1(12.35,36.83) ; ECX7.1 68.89,245.75 ; ECX7.1 69.78,244.86 ; ECX7.1 68.89,243.97 ; ECX7.1 68,244.86 ; CS162.1 v1(32.71,247.21) ; CS154.1 v1(84.23,242.44) ; CX19.1 v1(67.28,237.55) ; PR234.1 17.69,66.17 v1(18.07,65.79) 18.19,65.79 20.28,63.7 34.7,63.7 35.02,64.02 48.09,64.02 PR235.1 ; v1(31.66,97.28) 31.34,97.28 RF33.1 ; v1(77.81,56.83) 76.93,57.71 76.93,58.59 73.19,62.34 73.19,73.54 73.85,74.19 73.85,76.91 74.33,77.39 v1(74.33,80.99) ; v1(32.16,81.03) 32.15,81.01 25.95,81.01 25.52,81.44 21.84,81.44 20.76,82.52 20.76,83.79 18.85,85.7 15.73,85.7 15.22,85.19 15.22,83.52 13.24,81.53 v1(12.25,81.53)
  TOP w0.889: ECK7.1 30.28,244.22 ; ECK7.1 29.39,243.33 ; ECK7.1 31.17,243.33 ; ECK7.1 30.28,242.44 ; 17.69,42.78 PCE30.1 ; PCE30.1 18.58,43.67 ; PCE30.1 16.8,43.67 ; PCE30.1 17.69,44.56 ; 49.08,237.31 ECX10.1 ; ECX10.1 50.02,238.25 ; ECX10.1 49.08,239.19 ; ECX10.1 48.14,238.25
  TOP w1.27: ATX_SYS.6 28.68,35.4 ; ATX_SYS.6 29.88,34.19 ; ATX_SYS.6 29.88,36.61 ; ATX_SYS.6 31.09,35.4 ; ATX_SYS.5 32.88,35.4 ; ATX_SYS.5 34.08,36.61 ; ATX_SYS.5 34.08,34.19 ; ATX_SYS.5 35.29,35.4 ; SATA_PWR.4 106.03,46.57 106.08,46.61 ; SATA_PWR.4 104.36,45.36 ; SATA_PWR.4 104.36,47.77
  BOTTOM w0.381: v1(101.25,142.49) 101.25,140.48 102.49,139.24 102.49,138.65 102.01,138.18 101,138.18 100.89,138.28 96.15,138.28 93.17,135.31 90.79,135.31 90.46,134.98 90.08,134.98 89.88,134.78 88.39,134.78 87.98,134.37 v1(86.62,134.37)
  BOTTOM w0.508: v1(77.81,56.83) 78.74,55.9 81.53,55.9 84.05,53.38 85.95,53.38 92.34,46.99 98.46,46.99 99.55,48.08 101,48.08 101.61,47.47 102.75,47.47 v1(102.95,47.27) ; v1(31.66,97.28) 32.62,96.32 32.62,83 32.16,82.54 v1(32.16,81.03) ; v1(74.33,80.99) 74.33,82.68 75.27,83.62 84.23,83.62 86.75,86.13 86.75,89.08 85.4,90.42 82.89,90.42 76.97,96.34 76.97,102.46 v1(82.33,107.82)
  BOTTOM w1.016: 185.45,234.82 189.64,234.82 191.55,232.92 v2(203.87,232.92) 206.28,232.92 207.3,233.93 210.47,233.93 ; 229.27,133.45 229.27,135.57 232.21,138.51 233.1,138.51 234.98,140.4 234.98,141.55 236.76,143.33 236.76,205.33 235.24,206.85 235.24,209.23 223.26,221.21 v1(223.26,221.4) 222.85,221.4 221.34,222.91
  BOTTOM w2.032: 182.79,222.12 178.14,222.12 176.23,220.22 162.57,220.22 160.55,218.2 157.93,218.2 154.44,214.71 138.87,214.71 135.06,218.52 130.24,218.52 v2(129.84,218.11) 128.19,216.46 118.9,216.46 118.27,215.82 111.84,215.82 109.3,218.36 v2(98.76,218.36) 95.61,221.51
  vias: v1(5.24,210.95) v1(5.49,215.26) v1(5.49,214.63) v1(6.13,215.26) v1(6.13,214.63) v1(6.13,210.95) v1(6.76,215.26) v1(6.76,214.63) v1(7.02,210.95) v1(7.4,215.26) v1(7.4,214.63) v1(9.3,214.38) v1(10.07,214.38) v1(10.96,214.38) v1(12.23,233.3) v1(12.23,232.41) v1(12.48,224.16) v1(12.48,223.52) v1(12.48,222.88) v1(12.48,222.25) v1(13.11,224.16) v1(13.11,223.52) v1(13.11,222.88) v1(13.11,222.25) v1(14.51,234.7) v1(15.02,235.2) v1(28.86,37.08) v1(29.12,243.33) v1(29.88,37.08) v1(30.26,244.47) v1(30.26,242.32) v1(30.89,37.08) v1(31.4,243.33) v1(31.91,37.08) v1(31.91,36.07) v1(31.91,35.05) v1(33.05,37.08) v1(34.07,37.08) v1(35.09,37.08) v1(48.17,237.62) v1(49.06,237.11) v1(49.56,239.27) v1(50.2,238.38) v1(58.07,38.35) v1(58.07,37.72) v1(58.07,37.08) v1(58.07,36.45) v1(68.74,237.74) v1(68.87,245.87) v1(68.87,243.84) v1(69.76,238.76) v1(69.76,236.73) v1(69.88,245.36) v1(69.88,244.6) v1(70.9,237.74) v1(93.91,223.24) v1(93.91,222.61) v1(94.55,223.24) v1(94.55,222.61) v1(184.06,224.89) v1(184.06,224.26) v1(184.69,234.82) v1(184.69,234.06) v1(184.69,224.89) v1(184.69,224.26) v1(196.48,223.7) v1(196.48,223.06) v1(197.11,223.7) v1(197.11,223.06) v1(211.62,233.81) v1(212,233.3) v1(229.4,131.95) v1(229.4,131.32) v1(229.4,130.68) v2(184.18,223.39) v2(195.36,223.14)
+12V_SB: length 104.3
  TOP w0.762: 50.1,56.18 49.77,56.51 47.97,56.51 46.48,58.01 44.18,58.01 43.64,57.48 34.75,57.48 34.58,57.66 ; 30.01,32.51 25.56,32.51 24.04,34.04 24.04,35.31 21.95,37.39 17.69,37.39 14.74,40.34 14.74,44.03 13.58,45.19 11.06,45.19 6.54,49.71 v1(6.54,53.74) 6.54,67.14 6.99,67.59 9.4,67.59 9.94,67.06 18.18,67.06 18.74,66.5 v1(19.01,66.5)
  TOP w1.27: ATX_SYS.1 34.08,31.11 ; ATX_SYS.1 34.08,28.69 ; ATX_SYS.1 35.29,29.9 ; ATX_SYS.1 32.88,29.9
  BOTTOM w0.762: v1(19.01,66.5) 18.91,66.4 18.91,65.32 21.92,62.32 29.01,62.32 31.53,59.79 v2(31.53,59.06) 31.53,58.55 32.55,57.53
  vias: v1(6.64,68.83) v1(32.93,58.04) v1(33.43,57.53) v1(42.48,31.77) v1(42.49,31.04) v1(43.25,31.81) v1(43.25,31.04) v1(44.01,31.81) v1(44.01,31.04) v1(44.81,31.82) v1(44.81,31.06) v1(49.56,29.97) v1(49.94,31.88) v1(50.07,30.86) v1(50.2,29.97) v1(50.71,31.88) v1(53.37,31.75) v1(53.37,30.86) v1(53.37,29.97) v2(44.48,33.4) v2(47.91,34.29) v2(51.72,30.61)
+VCCGT: length 92.9
  TOP w0.203: v3(230.35,189.34) 230.35,189.23 PR158.1
  TOP w0.889: 206.68,143.08 PCE21.1 ; PCE21.1 205.74,144.02 ; PCE21.1 207.62,144.02 ; PCE21.1 206.68,144.96 ; 206.68,163.91 PCE22.1 ; PCE22.1 206.68,165.79 ; PCE22.1 207.62,164.85 ; PCE22.1 205.74,164.85 ; 206.68,150.19 PCE25.1 ; PCE25.1 205.74,151.13 ; PCE25.1 207.62,151.13 ; PCE25.1 206.68,152.07 ; 205.74,157.99 PCE24.1 ; PCE24.1 206.68,158.93 ; PCE24.1 206.68,157.05 ; PCE24.1 207.62,157.99 ; PCE23.1 207.62,171.7 ; PCE23.1 205.74,171.7 ; PCE23.1 206.68,170.76 ; PCE23.1 206.68,172.64
  TOP w1.27: PL9.2 215.08,171.44 ; PL9.2 215.83,169.2 ; PL9.2 213.49,168.93 ; PL9.2 212.74,171.16 ; 215.85,150.41 PL10.2 ; PL10.2 213.51,150.14 ; PL10.2 215.1,152.64 ; PL10.2 212.76,152.37
  BOTTOM w0.254: PL10.2 216.1,149.59 PJP18.1 ; PCE23.1 208.21,173.23 209.72,173.23 210.23,173.74 215.17,173.74 216.7,175.26 221.72,175.26 228.07,181.62 228.07,185.93 229.14,186.99 229.14,188.14 v3(230.35,189.34) ; PL9.2 216.08,168.39 PJP16.1
  BOTTOM w0.508: v3(197.26,171.58) 197.26,171.86
  BOTTOM w0.889: PCE23.1 207.62,171.7 ; PCE23.1 205.74,171.7 ; PCE23.1 206.68,170.76 ; PCE24.1 207.62,157.99 ; PCE24.1 205.74,157.99 ; PCE24.1 206.68,158.93 ; PCE24.1 206.68,157.05 ; 206.68,150.19 PCE25.1 ; PCE25.1 205.74,151.13 ; PCE25.1 206.68,152.07 ; PCE25.1 207.62,151.13 ; 205.74,164.85 PCE22.1 ; PCE22.1 206.68,163.91 ; PCE22.1 206.68,165.79 ; PCE22.1 207.62,164.85 ; 205.74,144.02 PCE21.1 ; PCE21.1 206.68,144.96 ; PCE21.1 206.68,143.08 ; PCE21.1 207.62,144.02
  vias: v1(173.77,152.65) v1(173.77,151.64) v1(173.77,148.97) v1(173.77,147.95) v1(173.77,145.54) v1(173.77,144.83) v1(175.67,152.65) v1(175.67,151.64) v1(175.8,148.97) v1(175.8,148.08) v1(175.8,145.54) v1(175.8,144.81) v1(178.71,146.48) v1(178.67,145.62) v1(180.55,148.31) v1(182.35,148.29) v1(183.29,147.5) v1(184.08,148.26) v1(209.79,168.68) v3(176.7,153.31) v3(178.68,154.71) v3(178.68,152.88) v3(178.68,151.05) v3(178.68,149.22) v3(178.68,147.4) v3(180.51,156.54) v3(180.51,154.71) v3(180.51,152.88) v3(180.51,151.05) v3(180.51,149.22) v3(181.42,158.39) v3(182.34,158.37) v3(182.34,156.55) v3(182.34,154.71) v3(182.34,152.88) v3(182.34,151.05) v3(182.34,149.22) v3(184.17,158.37) v3(184.17,156.54) v3(184.17,154.71) v3(184.17,152.88) v3(184.17,151.05) v3(184.18,150.14) v3(184.17,149.22) v3(185.08,158.37) v3(185.08,156.54) v3(185.08,154.71) v3(185.08,152.88) v3(185.08,151.05) v3(185.12,150.14) v3(185.17,149.38) v3(186.98,158.75) v3(187.23,154.18) v3(188.63,156.72) v3(188.76,151.76) v3(189.52,161.29) v3(190.66,149.86) v3(190.79,159.51) v3(190.79,154.31) v3(192.82,156.59) v3(192.82,151.76) v3(194.72,149.99) v3(194.85,169.67) v3(194.85,159.51) v3(194.85,154.43) v3(195.36,163.96) v3(197.52,167.39) v3(197.52,162.18) v3(197.52,156.72) v3(197.52,151.76) v3(199.8,149.99) v3(199.93,171.96) v3(199.93,169.67) v3(199.93,164.59) v3(199.93,159.51) v3(199.93,154.43) v3(201.58,162.05) v3(201.58,156.72) v3(201.58,151.64) v3(201.84,167.64) v3(201.96,171.32) v3(203.12,166.34) v3(203.14,164.59) v3(203.19,159.49) v3(203.17,157.73) v3(203.17,152.43) v3(203.19,150.62) v3(204.12,171.45) v3(205.39,165.23) v3(205.39,158.24) v3(205.39,151.13) v3(205.39,144.53) v3(206.54,163.07) v3(206.66,166.62) v3(206.66,159.64) v3(206.66,152.4) v3(206.66,149.86) v3(206.66,145.29) v3(206.92,156.46) v3(207.17,169.42) v3(207.55,143) v3(207.81,158.24) v3(207.81,144.02) v3(207.93,165.1) v3(207.93,151.13) v3(208.31,170.31) v3(211.87,170.05) v3(211.87,152.15) v3(212.25,171.83) v3(212.38,149.99) v3(212.89,168.27) v3(212.89,153.16) v3(213.9,172.47) v3(213.9,149.1) v3(214.41,167.89) v3(215.04,153.16) v3(215.3,171.83) v3(216.06,152.4) v3(216.31,171.2)
+VCCIO: length 268.3
  TOP w0.254: QO4.4 202.87,52.94 v1(202.61,53.2) ; v1(197.52,56.67) 197.83,56.67 199.08,57.91 201.71,57.91 210.72,66.92 211.14,66.92 216.86,66.92 218.94,68.99 219.55,68.99 220.04,68.5 228.56,68.5 231.22,71.17 231.22,85.69 230.26,86.65 229.11,86.65 226.68,89.09 226.68,92.55 224.46,94.77 224.46,103.25 227.79,106.59 227.79,116.76 222.11,122.45 222.11,125.25 218.45,128.91 218.45,133.57 R6579.1 v1(217.65,135.1)
  TOP w0.356: CPU.AK14 v1(160.39,138.26)
  TOP w0.381: RX21.1 125.71,193.02 126.32,192.41 126.78,192.41 128.1,191.09 129.83,191.09 130.09,190.83 131.37,190.83 v1(131.45,190.91)
  TOP w0.406: R48.2 121.86,194.17 v3(121.81,194.12) ; v3(124.88,193.04) RX21.1
  TOP w0.508: v1(115.22,136.75) 114.88,136.75 CS112.1 ; R6255.2 v1(140.22,175.51) ; CS218.1 v1(117.52,138.74) ; CS75.1 v1(115.62,130.6) ; v1(116.03,133.07) 115.56,133.07 CS73.1 ; v1(111.39,154.76) 111.97,155.35 111.97,156.44 118.88,163.35 118.88,175.08 122.97,179.17 129.18,179.17 129.59,179.58 130.16,179.58 131.17,180.59 135.8,180.59 v1(137.52,178.87)
  TOP w0.889: PCE28.1 118.72,146.05 ; PCE28.1 119.66,146.99 ; PCE28.1 120.6,146.05 ; PCE28.1 119.66,145.11
  BOTTOM w0.254: v1(197.52,56.67) 197.76,56.67 199.67,54.75 200.01,54.75 200.87,53.9 201.92,53.9 v1(202.61,53.2) ; PCE28.1 119.68,146.03 PJP20.1 ; v3(172.26,140.97) 172.26,142.3 172.91,142.95 172.91,143.87 173.31,144.27 176.18,144.27 176.56,144.65 178.8,144.65 178.89,144.75 180.35,146.2 181.47,146.2 181.82,146.56 183.12,146.56 185.5,148.95 187.21,148.95 187.76,148.39 198.99,148.39 212.28,135.1 v1(217.65,135.1)
  BOTTOM w0.381: v1(131.45,190.91) 131.45,190.77 134.87,187.36 134.87,181.74 137.52,179.08 v1(137.52,178.87) 140.22,176.17 v1(140.22,175.51)
  BOTTOM w0.406: v3(121.81,194.12) 122.38,193.54 123.96,193.54 124.46,193.04 v3(124.88,193.04)
  BOTTOM w0.508: v1(111.39,154.76) 111.39,154.08 v1(115.22,150.24)
  vias: v1(117.13,147.32) v1(117.13,146.69) v1(117.13,146.05) v1(117.13,145.41) v1(117.76,147.45) v1(117.76,146.81) v1(117.76,146.18) v1(117.76,145.54) v1(153.78,154.48) v1(153.98,151.74) v1(153.98,150.77) v1(154.44,151.26) v1(154.44,150.24) v1(154.85,153.42) v1(154.85,152.53) v1(154.85,151.76) v1(154.85,150.75) v1(154.85,149.73) v1(155.35,153.03) v1(155.35,152.15) v1(155.35,151.26) v1(155.35,150.24) v1(156.59,150.01) v1(157.49,139.35) v1(157.72,149.97) v1(157.71,140.09) v1(158.31,140.72) v1(158.81,149.94) v1(161.32,150.62) v1(161.32,149.61) v3(169.54,138.25) v3(170.15,139.93) v3(170.92,140.31) v3(171.49,140.97) v3(171.61,140.26)
+VCCIO_COMP_RC: length 1.5
  TOP w0.102: PR219.1 112.62,148.46 v1(111.92,148.46) 111.84,148.46 111.72,148.34 PC200.2
+VCCIO_DRV: length 19.7
  TOP w0.102: PR217.1 PR219.2 109.71,149.29 108.58,148.16 105.85,148.16 103.92,146.23 v1(103.92,145.67) ; v1(105.67,141.5) 106.81,141.5 107.22,141.1 PU14.5
  BOTTOM w0.102: v1(105.67,141.5) 105.06,141.5 v2(104.48,142.09) 104.1,142.09 103.39,142.8 103.39,145.14 v1(103.92,145.67)
+VCCIO_DRV_R: length 3.9
  TOP w0.508: PR217.2 113.76,148.34 PC199.1 v1(114.92,147.51) 114.92,146.93 PQ48.4
  BOTTOM w0.102: v1(114.92,147.51) v2(114,147.51)
+VCCIO_FB: length 19.8
  TOP w0.254: v1(107.79,139.26) 108.16,138.89 PU14.3 109.06,138.05 PR224.1 PR222.1 PR220.1 ; v1(105.04,146.66) 106.23,147.85 108.71,147.85 109.19,148.34 PC200.1
  BOTTOM w0.254: v1(105.04,146.66) 104.81,146.43 v2(104.81,145.44) 104.81,143.13 107.86,140.08 107.86,139.32 v1(107.79,139.26)
+VCCIO_FB_R: length 5.7
  TOP w0.102: PC206.2 111.08,138.04 v1(111.08,137.78)
  TOP w0.254: PC206.2 PR221.1 112.17,139.13 112.17,140.08 111.73,140.53 PR223.1 PR220.2
+VCCIO_FB_RC: length 1.6
  TOP w0.254: PR222.2 110.73,139.57 v1(111.13,139.98) 111.6,139.51 PC206.1
+VCCIO_FB_SENSE: length 9.6
  TOP w0.254: PR221.2 112.68,139.57 113.04,139.93 113.04,140 113.57,140.53 v1(113.57,141.73)
  BOTTOM w0.254: PJP20.2 118.39,144.91 116.97,143.48 115.15,143.48 v2(114.46,142.8) 114.46,142.75 113.57,141.86 v1(113.57,141.73)
+VCCIO_SS: length 5.2
  TOP w0.102: PC198.1 106.84,142.37 108.16,141.05 PU14.4 108.16,140.2 107.6,139.65 v1(107.29,139.65)
  BOTTOM w0.102: v2(106.71,140.23) 107.29,139.66 v1(107.29,139.65)
+VCCIO_VCC: length 6.5
  TOP w0.508: PR214.2 PC350.2 103.67,142.49 v1(105.57,140.59) PU14.6
  BOTTOM w0.102: v2(105.09,139.17) 105.09,140.11 v1(105.57,140.59)
+VCCRTC_SIO: length 67.4
  TOP w0.203: 216.36,35.23 216.82,35.69 217.84,35.69 218.49,36.34 SIO_5553.21
  TOP w0.381: v1(177.83,50.42) 175.42,48.01 D5.3 ; v1(187.99,50.42) 188.07,50.34 188.07,47.5 204.27,31.29 v1(204.27,30) ; 216.36,35.23 216.36,32.51 CO11.1 216.62,31.36 RO5.1 v1(216.38,30.23)
  BOTTOM w0.381: v1(204.27,30) 209.48,30 209.96,29.51 215.84,29.51 216.38,30.05 v1(216.38,30.23) ; v1(187.99,50.42) v1(177.83,50.42)
+VCCSA: length 42
  TOP w0.356: CS84.1 130.83,174.87 v1(131.58,174.87)
  TOP w0.457: CS78.1 121.45,157.99 v1(121.7,158.24) ; CS82.1 120.49,156.27 v1(120.56,156.21) ; CS83.1 v1(126.53,165.48)
  TOP w0.508: PR206.1 145.58,189.79 144.74,188.95 143.31,188.95 141.23,186.87 141.23,183.67 147.61,177.29 v1(150.66,177.29) ; CS208.1 131.16,173.04 131.86,172.34 v1(132.37,172.34) ; CS148.1 129.63,173.17 129.7,173.1 v1(129.7,172.97) ; CS211.1 124.43,154.09 v1(124.82,153.71) ; v1(130.13,160.28) 130.1,160.25 CS210.1 ; CS209.1 128.49,165.35 v1(128.83,165.02)
  TOP w0.889: PCE27.1 148.52,180.52 ; PCE27.1 147.58,179.58 ; PCE27.1 149.46,179.58 ; PCE27.1 148.52,178.64 ; 143.18,186.49 PCE26.1 ; PCE26.1 142.24,185.55 ; PCE26.1 143.18,184.61 ; PCE26.1 144.12,185.55
  BOTTOM w0.889: 148.52,180.52 PCE27.1 149.46,179.58 ; 143.18,186.49 PCE26.1 144.12,185.55
  vias: v1(143.75,184.58) v1(144.31,185.55) v1(144.36,186.51) v1(144.76,183.44) v1(146.03,182.17) v1(147.05,184.3) v1(147.23,183.01) v1(147.38,185.65) v1(147.68,180.52) v1(148.12,186.69) v1(148.5,180.85) v1(148.62,184.78) v1(149,186.61) v1(149.36,178.64) v1(149.77,179.58) v1(150.66,186.69) v1(151.04,181.48) v1(152.69,186.69) v1(152.69,177.29) v1(152.66,153.82) v1(152.66,152.91) v1(152.66,151.99) v1(152.69,151.08) v1(152.69,149.22) v1(152.69,148.34) v1(153.45,181.36) v1(154.59,185.55) v1(154.59,183.77) v1(154.59,181.36) v1(155.86,147.19) v1(157.64,147.19) v1(159.42,147.19) v1(161.45,147.19) v3(151.81,147.4) v3(151.81,146.47) v3(152.69,147.42) v3(152.71,146.49) v3(152.72,145.59) v3(153.69,147.52) v3(153.94,145.87) v3(153.94,145.16)
+VCCSA_BOOT_25: length 6.3
  TOP w0.254: 140.38,199.77 140.1,199.77 139.75,200.13
  TOP w0.635: v1(140.5,205.18) PR199.1 140.34,203.71 139.71,203.07 139.71,200.17 139.75,200.13
+VCCSA_BOOT_R25: length 3.2
  TOP w0.635: v1(142.88,204.7) 142.27,204.09 PR199.2 142.07,203.5 PC180.2
+VCCSA_CS: length 3.9
  TOP w0.254: PR204.2 139.23,194.4 v1(140.46,195.64) 140.88,196.06 PU13.2
  BOTTOM w0.102: v1(140.46,195.64) 140.46,195.02 v2(140.67,194.82)
+VCCSA_FB: length 6.6
  TOP w0.254: PU13.4 141.88,195.46 142.27,195.07 PR209.1 PR210.1 PR207.1 PC184.2 145.32,195.25 v1(145.22,195.35)
+VCCSA_FB_R: length 5.7
  TOP w0.254: v1(144.43,190.12) 144.43,190.94 PR208.2 PC185.1 145.51,192.02 PR206.2 145.58,193.23 PC184.1 PR207.2
+VCCSA_FB_VSS: length 3.1
  TOP w0.254: PJP19.1 141.31,191.96 PR211.2 142.7,192.39 v1(142.7,192.74) 142.7,193.05 PR209.2
+VCCSA_HG_25: length 5.6
  TOP w0.254: v1(140.52,200.63) 140.52,200.56 140.88,200.19 140.88,199.77
  TOP w0.635: v1(143.19,199.44) 143.72,199.44 PR200.1
  BOTTOM w0.635: v1(143.19,199.44) 141.36,199.44 140.52,200.28 v1(140.52,200.63)
+VCCSA_HG_R_25: length 4.3
  TOP w0.635: PQ44.1 145.77,198.5 PR201.1 144.62,198.56 PR200.2 144.18,197.97 144.81,197.33 v1(145.22,197.33)
+VCCSA_LG_25: length 13.1
  TOP w0.254: v1(143.08,200.58) 142.88,200.58 142.38,200.09 142.38,199.77
  TOP w0.635: v1(153.2,198.5) PQ45.8 PQ44.7
  BOTTOM w0.635: v1(143.08,200.58) 143.92,200.58 145.12,199.39 149.46,199.39 150.48,198.37 153.07,198.37 v1(153.2,198.5)
+VCCSA_PHASE_25: length 16.7
  TOP w0.254: 141.38,199.77 141.38,200.58
  TOP w0.635: 141.38,200.58 141.38,201.02 141.35,201.05 141.35,201.2 140.75,201.8 PC180.1 140.7,202.41 v1(140.93,202.64) ; PR201.2 v1(145.7,200.53)
  BOTTOM w0.635: v1(140.93,202.64) 142.68,202.64 v1(142.91,202.41) 143.82,202.41 v1(145.7,200.53) 149.94,200.53 150.96,199.52 v1(151.93,199.52)
  vias: v1(149.13,191.52) v1(149.13,190.25) v1(149.51,197.36) v1(149.51,196.34) v1(149.51,195.33) v1(150.15,196.85) v1(150.15,195.83) v1(150.15,188.98) v1(150.78,197.36) v1(150.78,196.34) v1(150.78,195.33) v1(151.42,188.98) v1(152.81,188.98) v1(153.83,191.01) v1(153.83,190.25)
+VCCSA_RF: length 2.3
  TOP w0.254: PR203.2 v1(143.35,195.96) 142.65,195.96 142.38,196.23 PU13.5
+VCCSA_SN_20: length 1.9
  TOP w0.508: PC182.2 152.97,193.04 v1(153.17,192.84) 153.63,193.29 PR205.1
+VCCSA_VCC_20: length 0.5
  TOP w0.254: 141.88,200.27 141.88,199.77
  vias: v1(145.7,202.31)
+VCCST_PWRGD: length 106.3
  TOP w0.102: v1(41.37,148.84) PR11.1 41.31,148.15 PR8.2 ; v1(105.06,136.22) 107.01,136.22 107.98,137.19 112.45,137.19 114.02,138.75 R6546.2 ; v1(45.35,154.47) 45.35,155.45 48.18,158.27 48.18,160.52 49,161.34 51.31,161.34 53.4,163.42 66.64,163.42 68.54,161.53 69.87,161.53 70.37,161.03 71.61,161.03 77.29,155.36 77.29,152.93 80.17,150.04 85.72,150.04 87.18,148.58 88.66,148.58 90.26,146.98 90.26,145.5 91.17,144.59 91.17,137.9 91.57,137.49 91.57,135.45 92.46,134.57 97.16,134.57 97.27,134.67 101.22,134.67 101.63,135.08 101.63,135.95 PR14.1 102.33,136.59 v1(102.9,136.02)
  BOTTOM w0.102: v1(105.06,136.22) 104.88,136.04 102.93,136.04 v1(102.9,136.02) ; v1(45.35,154.47) 44.48,153.59 v2(44.28,153.59) 44.23,153.59 41.46,150.83 41.46,148.93 v1(41.37,148.84)
+VCCST_PWRGD_R: length 1.7
  TOP w0.102: PQ3.D2 101,136.55 v1(101.58,137.13) 101.93,137.48 PR14.2
+VDDQ: length 368.8
  TOP w0.102: 189.93,86.04 189.93,86.62 190.79,87.48 DIMM1.40 ; 118.48,90.28 117.95,90.8 117.57,90.8 116.84,91.53 DIMM1.121 ; 107.49,87.82 DIMM1.132
  TOP w0.203: DIMM2.110 126.19,83.34 v1(125.16,84.38) ; 189.93,86.04 190.15,85.82 v1(190.15,84.84) ; v1(134.95,84.14) 135.59,84.78 135.59,86.66 136.36,87.44 136.36,88.64 135.54,89.46 DIMM1.99 ; DIMM2.29 200.14,86.61 200.96,87.43 200.96,88.62 200.14,89.44 DIMM1.29 ; DIMM1.7 218.84,89.53 219.69,88.69 219.69,87.51 218.79,86.61 218.79,85.81 v1(218.16,85.18) ; DIMM2.132 107.49,83.57 107.25,83.81 107.25,84.42 v1(107.22,84.45) 107.22,84.98 108.26,86.02 108.26,86.8 107.49,87.58 107.49,87.82 ; DIMM1.51 181.44,89.44 182.3,88.59 182.3,87.52 181.32,86.55 181.32,85.69 180.77,85.14 v1(180.77,84.09) ; 118.48,90.28 118.48,89.31 117.67,88.5 117.67,87.49 116.92,86.74 116.92,85.98 117.19,85.72 v1(117.19,85.09) ; DIMM1.110 126.19,87.5 125.48,86.78 125.48,85.95 v1(126.76,84.67) ; DIMM1.18 211.31,88.31 211.31,87.54 210.36,86.59 210.36,85.83 209.81,85.27 v1(208.33,85.27) ; PJP2.2 219.34,72.9 v1(219.74,73.3)
  TOP w0.254: PR361.2 233.78,64.39 220.24,64.39 218.88,65.75 218.88,68.2 v1(219.16,68.49) ; v1(200.44,46.1) 200.55,45.99 QO1.4 ; v1(163.15,130.02) 163.6,130.47 CPU.AV17
  TOP w0.305: v1(169.14,127.74) 169.08,127.79 CPU.AY23 ; v1(161.26,131.85) 161.3,131.85 CPU.AU15
  TOP w0.356: v1(164.62,127.87) 164.51,127.98 CPU.AY18 ; CPU.AW14 v1(160.39,129.12) ; v1(171.33,130.03) 171.33,129.99 CPU.AW25 ; v1(167.25,129.85) CPU.AV21 ; CD4.1 215.25,75.68 v1(215.67,75.68) 216.11,75.68 C71.1 216.98,75.22 217.11,75.22 R61.1 ; CPU.AY16 v1(162.68,127.9) ; CPU.AV11 157.83,130.49 v1(157.48,130.14) ; v1(167.68,131.87) 167.68,131.89 CPU.AT21 ; CPU.AY12 159.02,128.11 v1(158.91,128) ; v1(165.91,131.86) 165.45,131.4 CPU.AU19 ; v1(169.57,131.86) 169.56,131.86 CPU.AU23 ; CPU.AU13 v1(160.39,130.95) ; CPU.AT18 v1(164.08,131.86) ; U139.5 v1(145.34,75.71)
  TOP w0.508: C8.2 145.44,84.09 v1(145.13,84.39) ; v1(190.15,84.84) 189.64,84.84 C57.1 189.52,84.2 v1(190.15,84.2) ; v1(208.33,85.27) 208.76,84.84 C49.1 ; R6500.2 157.7,141.67 156.49,140.45 156.49,138.06 156.97,137.58 156.97,133.57 155.74,132.33 155.74,131.23 CPU.AW10 156.37,129.11 v1(156.37,127.53) ; C7.2 v1(147.35,93.09) ; v1(117.19,85.09) C6.2 116.84,84.11 DIMM2.121 ; v1(138.97,84.84) 139.56,84.84 C1767.1 139.53,84.2 v1(138.97,84.2) ; v1(175.04,94.36) 174.53,94.36 C60.1 174.66,93.47 v1(175.04,93.47) ; v1(172.88,84.2) 173.39,84.2 C61.1 173.39,84.96 v1(172.88,84.96) ; C9.2 v1(152.18,94.36) ; v1(129.83,84.2) 130.34,84.2 C1766.1 130.46,84.84 v1(129.83,84.84) ; v1(162.72,84.2) 163.23,84.2 C1769.1 163.23,84.96 v1(162.72,84.96) ; v1(180.77,84.09) C50.1 ; PR53.1 v1(158.53,68.83) ; v1(149.09,85.29) 149.32,85.05 C56.2 ; v1(144.05,94.62) 144.05,95.25 PC40.1 143.16,95.12 v1(143.16,94.62) ; RD5.1 142.53,74.8 v1(142.91,75.18) ; v1(159.49,93.44) 159.8,93.75 C54.2 ; C5.1 v1(148.41,84.09) ; C52.2 v1(167.43,93.8) ; RD3.1 150.78,74.68 v1(150.27,74.17) ; v1(214.66,84.2) 214.16,84.2 C58.1 214.03,84.84 v1(214.66,84.84) ; v1(175.04,96.14) 174.66,96.14 C59.1 174.66,95.12 v1(175.04,95.12) ; C3.1 v1(107.22,84.45) ; DIMM2.7 218.84,83.82 RD6.1 218.3,84.06 C51.1 218.03,85.05 v1(218.16,85.18) ; 168.31,84.07 v1(168.3,84.09) C2.1 ; CS217.1 93.92,116.08 v1(93.41,116.59) ; C1.1 v1(171.23,84.06) ; C53.2 v1(162.97,93.47) ; C48.1 161.11,84.04 v1(161.07,84.07) ; v1(144.31,75.18) 143.92,74.8 R60.1 ; C19.2 v1(149.13,93.09) ; v1(139.48,75.56) C1768.1
  TOP w0.889: PCE2.1 165.15,71.3 ; PCE2.1 164.21,70.36 ; PCE2.1 166.09,70.36 ; PCE2.1 165.15,69.42 ; 187.45,73.18 PL2.2 ; PL2.2 185.95,70.97 ; PL2.2 188.1,71.12 ; PCE3.1 172.14,71.42 ; PCE3.1 173.08,70.48 ; PCE3.1 172.14,69.55 ; PCE3.1 171.2,70.48 ; 179.25,69.55 PCE4.1 ; PCE4.1 178.31,70.48 ; PCE4.1 180.19,70.48 ; PCE4.1 179.25,71.42
  TOP w1.27: PL2.2 185.31,73.02
  BOTTOM w0.254: v1(161.96,73.2) 163.16,74.4 181.9,74.4 183.29,75.79 215.56,75.79 v1(215.67,75.68) ; v1(219.16,68.49) 219.41,68.49 221.21,70.29 221.21,71.83 v1(219.74,73.3) 219.74,73.43 218.02,75.16 215.43,75.16 215.2,75.39 183.47,75.39 182.07,73.99 164.27,73.99 v1(163.51,73.23) ; v1(200.44,46.1) 199.31,46.1 197.09,48.32 197.09,51.55 190.37,58.27 179.69,58.27 178.77,59.18 166.05,59.18 165.89,59.02 158.33,59.02 v1(157.86,58.56)
  BOTTOM w0.889: PCE2.1 165.15,71.3 ; PCE2.1 166.09,70.36 ; PCE2.1 165.15,69.42 ; PCE2.1 164.21,70.36 ; PCE3.1 173.08,70.48 ; PCE3.1 172.14,69.55 ; PCE3.1 171.2,70.48 ; PCE3.1 172.14,71.42 ; 178.31,70.48 PCE4.1 ; PCE4.1 179.25,71.42 ; PCE4.1 180.19,70.48 ; PCE4.1 179.25,69.55
  vias: v1(87.28,67.44) v1(87.41,68.83) v1(87.41,68.2) v1(87.79,66.93) v1(87.92,67.56) v1(88.3,66.42) v1(88.43,67.06) v1(88.81,65.91) v1(88.93,66.55) v1(89.44,66.04) v1(94.27,59.69) v1(94.9,59.69) v1(95.54,59.69) v1(107.73,145.31) v1(107.73,144.68) v1(107.73,144.04) v1(108.36,145.8) v1(108.36,145.16) v1(108.36,144.53) v1(108.36,143.89) v1(108.47,143.21) v1(109.63,146.43) v1(109.63,144.91) v1(109.63,143.38) v1(110.93,59.73) v1(111.29,146.43) v1(111.29,144.91) v1(111.29,143.38) v1(111.57,59.73) v1(112.2,59.73) v1(112.81,146.43) v1(112.81,144.91) v1(112.81,143.38) v1(128.81,57.28) v1(129.45,57.28) v1(130.08,57.28) v1(150.53,53.72) v1(151.29,53.72) v1(152.05,53.72) v1(152.81,53.72) v1(153.58,53.72) v1(160.94,69.85) v1(161.2,71.75) v1(162.59,69.98) v1(163.48,75.31) v1(163.74,70.36) v1(165.13,72.77) v1(165.13,71.63) v1(166.17,73.36) v1(166.4,70.36) v1(166.78,72.39) v1(168.59,73.36) v1(169.07,72.01) v1(169.2,69.6) v1(169.71,73.03) v1(170.72,72.52) v1(170.72,70.48) v1(172.09,73.28) v1(172.12,71.88) v1(173.31,72.87) v1(173.39,70.48) v1(174.4,72.39) v1(176.44,72.26) v1(176.56,69.47) v1(177.45,73.15) v1(177.96,70.61) v1(179.23,71.88) v1(179.48,75.06) v1(180.25,73.15) v1(180.37,70.48) v1(181.9,72.39) v1(183.01,73.43) v1(183.17,71.5) v1(183.55,68.05) v1(183.68,69.47) v1(184.44,71.5) v1(184.82,73.41) v1(185.71,68.05) v1(185.83,70.1) v1(186.34,74.04) v1(187.74,70.1) v1(187.87,68.05) v1(188.63,72.77) v1(188.76,71.12) v1(189.26,67.66) v1(190.53,74.68) v1(190.53,72.52) v1(190.53,70.23) v1(190.53,68.55)
-12V: length 178.2
  TOP w0.762: v1(92.04,234) 86.24,239.8 74.48,239.8 73.59,240.69 73.59,244.96 70.77,247.78 67.77,247.78 64.22,244.22 52.87,244.22 50.2,246.89 46.01,246.89 42.12,243 41.89,243 41.71,242.82 39.96,242.82 SLOT3.B1 38.24,244.54 CK34.1 34.13,244.54 31.66,247.01 v1(27.31,247.01)
  BOTTOM w0.762: 174.07,222.68 173.13,221.74 161.94,221.74 160.1,219.91 157.43,219.91 153.75,216.23 139.5,216.23 135.69,220.04 129.47,220.04 127.41,217.98 118.27,217.98 117.64,217.35 112.58,217.35 109.81,220.12 108.25,220.12 107.54,220.83 105.17,220.83 104.36,221.64 98.96,221.64 91.99,228.61 91.99,233.95 v1(92.04,234)
  BOTTOM w0.889: 9.92,236.75 PCE8.2 10.81,237.64
  vias: v1(12.58,237.46) v1(13.88,236.98) v1(14.26,237.62) v1(15.27,238.63) v1(174.79,223.39) v1(175.42,223.39)
-12V_COMP: length 0.8
  BOTTOM w0.102: v1(5.48,219.24) v2(5.48,218.43)
-12V_SWC:
  vias: v1(10.57,220.98)
-12V_SWE: length 0.9
  BOTTOM w0.102: v1(9.5,232.3) v2(9.5,233.15)
-12V_TCAP:
  vias: v1(7.65,222)
AVCC33:
  vias: v1(146.06,231.8)
AVDD2: length 3.1
  TOP w0.203: UA1.40 189.02,22.83 189.08,22.77
  TOP w0.254: CA102.1 191.07,22.41 190.72,22.77 189.08,22.77
  vias: v1(193.58,22.43)
DVCC_1P5V: length 69.5
  TOP w0.381: RC1.1 66.45,180.72 66.07,180.34 ; RC1.1 CK48.1 ; RC1.1 RK43.1 RK44.1 66.26,182.51 FBK1.1 66.63,184.33 CK5.1 68.14,184.53 68.41,184.26 UK2.4 68.99,183.26 v1(69.88,184.15) ; BRIDGE.G4 v1(62.39,196.2) ; CK49.1 CK52.1 54.77,184.98 v1(54.77,185.17) ; BRIDGE.F10 v1(56.8,195.4) ; BRIDGE.K7 v1(59.2,199.39) ; BRIDGE.D7 v1(59.2,193.8) ; BRIDGE.G10 v1(56.8,196.2) ; BRIDGE.H10 v1(56.8,197.79)
  TOP w0.508: v1(66.71,197.49) CK50.1 CK51.1 CK12.1
  BOTTOM w0.356: 55.96,194.56 v1(56.8,195.4)
  BOTTOM w0.381: v1(56.8,197.79) 57.38,197.79 57.95,197.23 57.95,196.85 ; v1(54.77,185.17) 53.89,186.04 53.89,187.57 54.66,188.33 54.66,190.22 53.89,190.98 53.89,192.54 55.91,194.56 55.96,194.56 ; 59.85,196.98 59.98,196.85 62.14,196.85 62.39,196.59 v1(62.39,196.2) 63.26,196.2 v2(65.18,198.12) 65.82,197.49 v1(66.71,197.49) 67.72,197.49 68.74,196.47 68.74,185.04 69.63,184.15 v1(69.88,184.15) ; 59.85,196.98 59.85,194.31 59.34,193.8 v1(59.2,193.8) ; 59.85,196.98 59.85,198.89 59.34,199.39 v1(59.2,199.39) ; 59.85,196.98 59.72,196.85 57.95,196.85 ; 57.95,196.85 57.29,196.2 v1(56.8,196.2) v1(56.8,195.4)
DVCC_1P5V_ADJ: length 4.3
  TOP w0.102: UK2.5 70.31,182.8 69.88,182.37 v1(69.44,182.37) RK45.1 RK43.2 RC1.2
GND: length 2216
  TOP w0.102: CPU.AF8 v1(153.62,141.92) ; v1(53.61,129.88) 53.6,129.88
  TOP w0.127: U4.BE14 45.98,129 v1(45.75,128.78) ; 67.89,132.63 68.27,132.63 68.5,132.86 68.5,132.96 v1(69.88,134.34)
  TOP w0.152: U4.AH1 55.03,135.74 v1(54.84,135.93) ; v1(57.06,135.89) 57.3,135.64 U4.AC1 ; v1(57.56,113.16) 57.32,113.4 U4.AC45 ; U4.P45 61.86,112.93 v1(61.95,112.84) ; U4.BE23 v1(45.95,124.45) ; v1(50.2,113.16) 50.47,113.43 U4.AU45 ; v1(45.92,119.72) 46.31,119.72 U4.BE32 ; v1(68.74,126.87) 68.61,126.74 U4.A18 ; U4.T2 U4.T1 60.57,135.27 60.29,135.55 v1(60.29,135.79) ; v1(54.64,113.16) 55.04,113.56 U4.AH45 ; U4.AM45 52.77,113.51 v1(53.12,113.16) ; U4.BE28 46.13,122.18 v1(46.01,122.3) ; v1(50.03,136.21) 50.3,135.94 50.3,135.43 U4.AU1 ; U4.BE18 45.86,126.73 v1(45.67,126.53) ; U4.V45 59.85,113.39 v1(59.85,113.16)
  TOP w0.203: U4.BE9 46.03,131.3 v1(45.88,131.44) ; 48.76,122.89 48.76,122.53 ; SIO_5553.59 223.3,48.89 v1(223.17,48.77) ; SIO_5553.117 210.04,42.89 v1(210.47,43.32) ; SIO_5553.66 222.49,53.33 v1(222.33,53.49) ; SIO_5553.35 v1(223.05,39.29) ; v1(212.38,38.33) 212.15,38.1 211.59,38.1 211.29,37.81 SIO_5553.3 ; PR146.1 214.24,186.03 v3(214.24,185.81) ; SIO_5553.40 v1(223.06,41.29) ; U4.BE40 46.34,116 v1(46.01,116.33) ; SIO_5553.90 212.89,51.09 v1(212.89,51.08) ; CPU.AV2 147.95,131.4 148.4,131.86 v1(149.05,131.86) 149.05,131.23 148.59,130.77 CPU.AW3 ; CPU.AV38 182.8,130.77 182.34,131.22 v1(182.34,131.84) ; 160.39,134.6 v1(159.48,134.6) ; SIO_5553.18 217.29,38.14 v1(217.2,38.23) 216.89,37.92 SIO_5553.17 ; SIO_5553.83 215.69,51.36 v1(215.92,51.13) 216.09,51.3 SIO_5553.82 ; v1(48.67,113.16) 48.85,113.33 U4.AY45 ; SIO_5553.86 v1(214.49,51.14) ; SIO_5553.1 210.23,37.08 v1(209.96,37.34) ; v1(46.12,117.23) U4.BE37 ; SIO_5553.88 v1(213.69,51.15)
  TOP w0.254: PU5.4 66.45,77.22 v1(66.58,77.09) ; 181.14,247.01 183.04,247.01 183.29,246.76 183.29,245.49 181.77,243.97 171.33,243.97 168.82,241.46 168.82,236.65 CG8.2 167.88,235.71 v3(167.55,235.71) ; 181.14,247.01 179.48,247.01 177.96,245.49 170.69,245.49 167.29,242.09 167.29,238.2 166.45,237.36 164.99,237.36 164.23,236.6 163.18,236.6 CG12.2 162.27,235.69 v3(161.96,235.69) ; 181.14,247.01 181.14,245.45 180.41,244.73 171.01,244.73 168.05,241.77 168.05,237.89 166.77,236.6 165.97,236.6 CG10.2 165.06,235.69 v3(164.78,235.69) ; v1(127,200.96) 126.66,200.62 XDP_CPU.31 ; v3(124.12,197.35) 123.66,197.81 XDP_CPU.19 ; v1(18.7,156.72) 18.94,156.96 UF2.11 ; M.2_SSD.27 106.89,124.74 v1(107.25,125.09) ; XDP_CPU.14 122.15,203.5 122.19,203.47 122.46,203.19 v1(122.52,203.14) ; v1(44.23,133.1) 44.12,133.21 41.3,133.21 40.52,133.99 39.53,133.99 37.68,135.84 Y5.3 ; RTK_VGA.14 154.55,225.67 155.51,226.63 RG16.2 156.05,226.63 156.5,227.08 v1(156.62,227.08) ; v1(215.43,209.55) 215.56,209.42 PU8.6 ; v1(42.83,100.84) 43.55,100.84 43.93,100.46 XDP_PCH.59 ; v1(49.66,129.06) 49.66,129.2 U4.AW13 ; v1(58.58,115.82) 58.36,115.6 U4.AA42 ; M.2_SSD.39 v1(103.89,125.07) 103.92,125.09 105.14,125.09 105.39,124.84 M.2_SSD.33 ; v1(77.25,134.11) 77,134.37 75.98,134.37 75.6,133.99 C1643.2 74.84,133.99 74.3,134.52 73.9,134.52 72.04,136.37 70.37,136.37 v1(70.14,136.14) 69.53,136.14 69.25,135.86 ; XDP_PCH.7 56.94,100.71 57.2,100.97 v1(57.95,100.97) 58.19,100.97 58.44,100.71 XDP_PCH.1 ; CPU.D39 v1(184.17,162.04) ; PU12.6 226.99,142.62 v1(226.86,142.75) ; v1(49.18,100.97) 49.44,100.71 XDP_PCH.37 ; v1(185.25,162.33) 185.25,162.2 CPU.D40 ; v1(166.4,229.11) 165.85,229.11 DG3.1 ; CF109.2 25.5,149.16 v1(25.56,149.1) ; M.2_SSD.45 v1(102.39,125.09) ; UF3.4 24.87,149.05 v1(24.93,149.1) ; v1(118.47,204.91) 118.72,204.66 XDP_CPU.2 ; v1(110.93,122.63) 110.15,122.63 109.89,122.89 M.2_SSD.15 ; v1(227.36,160.02) 227.49,159.89 PU11.6 ; v1(45.98,91.23) 44.52,91.23 43.93,91.82 XDP_PCH.60 ; Y5.2 39.03,130.81 C1639.1 39.86,131.57 41.51,131.57 41.69,131.39 43.8,131.39 v1(44.1,131.7) ; v1(134.15,200.66) 133.66,200.18 XDP_CPU.59 ; CPU.F40 185.91,159.75 v3(186.41,160.25) ; XDP_CPU.38 v1(128.16,203.14) ; UF2.16 v1(18.6,154.46) ; CPU.AA3 148.04,146.95 v1(147.98,146.89) ; CPU.AC3 148.6,145.12 v1(149.05,144.66) ; M.2_SSD.76 114.49,124.81 113.83,125.48 v1(113.32,125.48) ; v1(55.38,92.1) 55.44,92.16 XDP_PCH.14 ; XDP_CPU.20 123.66,203.52 124.11,203.07 v1(124.11,202.97) ; v1(52.56,92.1) 52.44,92.22 XDP_PCH.26 ; v1(50.33,100.97) 50.45,100.97 50.94,100.48 XDP_PCH.31 ; v1(63.28,81.03) 63.67,80.63 PU5.19 ; v3(146.15,151.36) 146.31,151.52 CPU.T1 ; Y1.4 78.98,132.43 78.98,130.63 78.39,130.05 77.38,130.05 v1(77.25,130.18) ; DG1.1 v1(161.07,228.73) ; U4.T42 60.63,115.46 v1(60.84,115.67) ; CPU.V1 146.73,149.73 145.89,149.73 v3(145.71,149.55) ; XDP_CPU.26 125.16,203.46 125.52,203.1 125.52,203.07 v1(125.49,203.07) ; U4.AT15 v1(51.19,129.06) ; U4.AE42 56.08,115.64 v1(56.14,115.7) ; M.2_SSD.3 112.89,122.87 v1(112.68,122.66) ; XDP_CPU.37 128.16,200.48 v3(128.62,200.94) ; v1(127.21,202.98) 126.66,203.53 XDP_CPU.32 ; v3(165.85,232.92) CG9.2 ; XDP_PCH.38 49.44,92.46 v1(49.06,92.07) ; UF1.32 36.33,91.54 v1(36.76,91.11) ; CPU.AR16 CPU.AT15 ; UV7.3 v1(221.73,245.75) ; v1(121,197.26) 120.65,197.6 XDP_CPU.7 ; PU5.3 65.95,77.22 v1(65.82,77.09) 65.82,76.52 PR74.2 ; v1(133.26,208.53) 133,208.28 R6595.2 ; PU10.6 172.66,206.24 172.37,206.53 172.02,206.53 v1(171.76,206.78) ; XDP_CPU.50 131.16,206.15 v1(131.23,206.22) ; M.2_SSD.21 v1(108.39,125.12) ; 99.5,125.02 99.39,124.91 M.2_SSD.57 ; v1(53.63,115.95) 53.81,115.77 U4.AK42 ; XDP_PCH.13 55.44,100.42 55.63,100.61 v1(55.63,100.97) ; v1(36.23,97.79) 36.33,97.69 UF1.9 ; v1(48.85,130.1) 48.78,130.02 48.19,130.02 U4.BB11 ; M.2_SSD.1 v1(113.39,122.66) ; CG11.2 v3(163.05,232.92) ; v1(156.62,228.54) RG17.2 154.12,226.67 RTK_VGA.16 ; v3(149.05,151.06) CPU.T4 ; RTK_VGA.11 155.43,224.17 RG15.2 156.05,224.73 v1(156.5,225.17) ; M.2_SSD.51 100.89,125.07 v1(100.87,125.09) ; UF2.32 25.03,157.96 v1(25.31,157.68) ; v1(45.75,97.66) 46.01,97.66 46.44,98.09 XDP_PCH.49 ; v1(33.43,97.66) 33.18,97.66 32.83,97.31 UF1.16 ; UF2.26 25.29,154.96 v1(25.31,154.94) 25.5,155.13 CF106.2 ; U4.BB34 48.17,118.68 48.73,118.68 v1(48.79,118.62) ; XDP_CPU.13 v1(122.15,197.14) ; v1(129.32,200.96) 130.42,200.96 131.16,200.22 XDP_CPU.49 ; v1(69.88,134.34) 70.51,134.34 70.62,134.23 72.16,134.23 74.12,132.27 C1642.2 76.06,131.11 Y1.2 ; v1(51.21,92.07) 50.94,92.35 XDP_PCH.32 ; RNK4.4 48.67,245.75 v1(48.93,245.49) 48.67,245.24 RNK4.3 ; XDP_CPU.8 v1(120.65,203.07) ; RNX4.4 88.17,231.65 88.55,232.03 v1(88.68,232.03) ; RTK_VGA.13 154.84,225.17 v1(155.1,225.43) ; XDP_PCH.25 52.44,100.41 52.99,100.97 v1(53.25,100.97) 53.5,100.97 53.94,100.52 XDP_PCH.19 ; v1(56.94,92.07) XDP_PCH.8 ; v3(148.14,149.23) CPU.W3 148.59,148.82 v3(149.03,149.25) ; CPU.AD1 v1(146.13,144.2) ; v1(58.83,92.2) 58.44,92.59 XDP_PCH.2 ; v1(86.01,231.39) 86.14,231.52 RNX4.1 ; v1(111.69,122.66) 111.39,122.95 M.2_SSD.9 ; RNK7.4 28.13,241.94 v1(28.38,241.68) 28.13,241.43 RNK7.3 ; v1(31.15,92.33) 31.15,92.48 31.78,93.11 UF1.23 ; U4.AR42 51.72,115.32 v1(51.72,115.82) ; XDP_PCH.20 53.94,92.13 v1(53.69,91.87) ; v1(188.81,209.83) 189.49,209.83 189.72,210.05 PU9.6 ; v1(168.64,232.92) CG7.2 ; CPU.AB39 184.08,145.49 v1(184.08,146.46) ; v1(45.96,91.93) 46.12,91.93 46.44,92.25 XDP_PCH.50 ; v3(125.16,197.37) XDP_CPU.25
  TOP w0.305: CPU.AR17 CPU.AR16 ; CPU.K33 v3(178.68,156.54) CPU.J34 ; U4.AL11 v1(53.61,129.88) ; v3(165.34,165.35) 165.34,164.54 165.97,163.9 CPU.C22 ; v3(153.9,152.43) CPU.R8 ; CPU.N8 153.54,154.03 v3(153.9,153.8) ; CPU.AT12 159.11,132.23 159.85,132.23 CPU.AT13 ; v3(153.83,149.69) CPU.V8 ; CPU.J3 v3(148.14,158.38) ; v1(153.61,164.77) 153.61,163.85 CPU.C8 ; CPU.AD8 v1(153.62,143.75) ; v3(146.13,153.32) 146.74,153.32 CPU.P1 ; v1(177.77,139.18) CPU.AJ32 ; CPU.G22 v3(166.42,160.21) ; CPU.AE8 v1(153.62,142.83) ; CPU.AC34 v1(178.68,143.75) CPU.AC33 v1(177.77,143.75) ; CPU.AL21 167.25,136.89 ; 166.8,137.34 v1(166.8,137.35) ; v1(154.52,139.16) CPU.AK9 ; CPU.L32 v3(176.85,154.72) ; CPU.AA8 v3(154.08,146.95) ; v3(179.59,157.46) CPU.H35
  TOP w0.33: CPU.AH39 CPU.AH40
  TOP w0.356: v1(151.79,138.26) CPU.AK6 v1(150.88,139.18) ; v1(185.29,135.98) CPU.AM40 ; CPU.AM36 180.97,135.95 v1(181.43,135.49) CPU.AN36 ; CPU.G15 v3(160.04,160.22) ; BRIDGE.H12 55.6,197.4 56,197 ; CPU.AR3 v1(148.14,133.69) CPU.AR2 ; v1(157.65,137.35) CPU.AL11 v1(157.65,136.43) ; 213.79,59.82 v1(213.79,58.8) ; CPU.AF1 145.99,142.38 v1(145.94,142.43) ; v1(182.34,139.2) 182.32,139.22 CPU.AH37 ; v1(154.54,135.49) CPU.AN9 ; CPU.AT10 v1(155.43,133.69) ; v1(160.39,137.35) CPU.AL14 v1(160.39,136.43) CPU.AM14 ; CPU.F1 v3(145.79,160.66) ; CPU.AR30 v1(175.03,133.71) 175.51,134.15 CPU.AP30 ; CPU.AK16 v1(162.22,138.26) ; v1(185.29,132.32) CPU.AT40 ; CPU.AT36 180.97,132.29 v1(181.43,131.84) 181.88,132.29 ; U139.3 v1(148.04,73.58) ; v1(154.08,128.85) CPU.AY9 ; 181.88,132.29 CPU.AT37 ; 181.88,132.29 v1(182.34,131.84) 182.8,132.29 CPU.AT38 182.8,132.34 v1(183.25,131.89) 183.69,132.32 CPU.AT39 ; v1(162.22,135.52) CPU.AN16 v1(162.22,134.6) ; CPU.AL3 148.57,137.8 v1(148.14,137.37) 147.71,137.8 CPU.AL2 ; v1(61.37,142.75) 61.76,143.13 C1668.2 ; v1(177.41,128.91) 177.31,129.02 CPU.AW32 ; v1(176.86,132.77) 176.4,132.32 CPU.AT31 ; v1(176.86,132.77) CPU.AR32 ; v1(176.86,132.77) CPU.AR31 ; CPU.AP14 160.39,134.6 CPU.AN14 ; CPU.AT12 159.02,132.34 v1(158.57,132.77) CPU.AT11 ; CPU.E21 v3(165.51,162.04) ; CPU.AU30 175.48,131.38 v1(175.91,130.95) 175.48,130.51 CPU.AV30 CPU.AW30 CPU.AY30 v1(175.48,128) ; CPU.L13 v3(158.2,155.63) ; CPU.F22 v3(166.42,160.21) ; CPU.AU25 170.91,131.38 v1(171.33,130.95) 171.37,130.95 CPU.AV26 ; CPU.AT13 CPU.AT14 160.85,132.34 v1(161.3,132.77) CPU.AR14 ; CPU.AL30 v3(175.94,137.35) CPU.AK30 ; CPU.AT17 v1(164.08,132.77) ; v1(164.08,132.77) CPU.AR18 ; v1(164.08,132.77) 164.05,132.77 CPU.AR17 ; CPU.AE33 v1(178.68,142.83) CPU.AD33 ; v1(180.91,128.79) 180.97,128.85 CPU.AW36 ; v1(185.29,134.15) CPU.AP40 ; v1(219.11,70.99) 219.17,71.06 PC42.2 ; CPU.E13 158.18,162.02 v3(158.2,162.02) ; v1(178.68,140.09) CPU.AH33 ; v1(182.34,133.69) CPU.AP37 ; v1(157.28,157.53) 156.89,157.92 CPU.J12 ; CPU.AR11 v1(157.65,133.69) CPU.AP11 ; CPU.A15 v1(159.57,165.87) ; CPU.AT30 CPU.AT29 174.57,132.31 v1(174.11,131.86) ; v1(183.25,139.2) 183.24,139.22 CPU.AH38 ; CPU.AF36 v1(181.43,141) CPU.AG36 ; CPU.AM31 v1(175.94,136.43) ; v1(126.53,207.52) 126.97,207.96 R27.1 ; 149.08,162.92 149.08,162.95 149.06,162.95 149.06,162.94 149.05,162.94 v3(149.05,162.92) ; v1(152.71,141.92) CPU.AG8 ; CPU.AC35 180.1,144.2 v1(180.5,144.6) ; 167.25,136.89 166.8,137.34 ; v1(170.45,137.35) CPU.AL24 ; v1(150.4,128.92) 150.42,128.94 CPU.AY5 ; CPU.AG5 v1(149.97,141.92) ; CPU.AR22 168.13,133.23 v1(167.68,132.78) 167.25,133.21 CPU.AR21 ; CPU.AD39 183.71,143.29 183.29,142.87 v1(183.25,142.83) 183.21,142.88 182.8,143.29 CPU.AD38 ; v1(137.78,237.62) UU6.3 v1(137.78,240.16) ; v1(175.03,134.6) 175.51,135.06 CPU.AN30 ; v1(145.72,18.4) UU26.3 v1(145.72,20.94) ; CPU.AN11 v1(157.65,135.52) CPU.AM11 ; v3(151.79,164.78) CPU.A7 ; PQ19.S2 222.92,71.37 v1(223.17,71.12) ; PQ20.4 152.11,63.07 v1(152.11,64.13) ; v1(141.02,20.94) UU10.3 v1(141.02,18.41) ; CPU.AJ36 v1(181.43,139.2) 181.41,139.22 CPU.AH36 ; v3(149.05,156.55) CPU.K4 ; RD10.2 229.53,84.09 v1(229.65,84.2) ; v3(146.08,156.96) 146.13,157.01 CPU.K1 ; CPU.AV5 v1(149.97,130.95) CPU.AW5 ; 101.38,63.23 100.35,63.23 v1(100.24,63.12) ; v3(161.85,160.21) CPU.G17 ; CPU.AE36 v1(181.43,142.83) CPU.AD36 ; CPU.AK13 v1(159.48,138.26) ; PC339.2 42.01,48.9 v1(42.32,48.9) ; CPU.C16 v3(160.03,163.86) ; v1(180.51,139.18) CPU.AJ35 ; v3(149.97,163.84) 150,163.84 150.24,163.6 ; CPU.AL4 149.48,137.8 v1(149.05,137.37) ; v1(154.54,136.41) 154.98,135.98 CPU.AN10 154.99,135.95 v1(155.45,135.49) ; CPU.J10 v3(154.53,158.39) CPU.H9 ; QO5.1 212.49,58.45 212.84,58.8 v1(212.89,58.8) ; CPU.M12 v3(157.28,154.72) ; CPU.AR20 v1(165.9,133.73) CPU.AR19 ; CPU.R3 148.44,152.59 v3(148.14,152.89) ; v1(177.78,131.87) CPU.AT32 177.34,132.32 v1(177.77,132.75) 178.23,133.21 CPU.AR33 ; CPU.J6 v3(151.79,158.38) ; CPU.AK29 v1(175.01,138.24) ; v1(173.2,137.35) CPU.AL27 ; CPU.J18 v3(161.84,158.39) ; v3(153.62,159.3) CPU.G8 153.14,159.75 v3(152.69,160.2) ; U4.BB16 48.46,127.96 v1(48.55,128.04) ; CPU.AK20 v1(165.88,138.26) ; v1(146.1,139.63) CPU.AJ1 ; v1(149.97,140.09) CPU.AH5 ; CPU.E9 v1(153.63,162.03) ; v1(145.28,141.54) 145.36,141.46 CPU.AG1 ; CPU.M4 v3(149.05,154.72) ; CPU.AT28 v1(173.22,131.87) 172.74,132.29 CPU.AT27 172.65,132.41 172.65,133.14 CPU.AR27 172.74,133.23 172.64,133.33 172.64,134.05 CPU.AP27 v1(173.22,134.61) 172.95,134.87 172.75,135.06 CPU.AN27 172.64,135.16 172.64,135.87 CPU.AM27 v1(173.2,136.43) ; v1(128.51,237.62) UU7.3 v1(128.51,240.16) ; CPU.AN23 v1(168.62,135.52) CPU.AN22 ; CPU.AT9 154.08,133.22 v1(153.63,132.77) CPU.AT8 ; v1(237.89,120.25) U122.1 ; CPU.AR24 v1(170.45,133.69) CPU.AP24 v1(170.45,134.6) CPU.AN24 ; CPU.AD7 v1(151.79,143.75) CPU.AD6 ; CPU.A11 155.91,165.41 v1(155.56,165.76) ; CPU.AK23 v1(168.62,138.26) ; CPU.A13 157.74,165.6 v1(158,165.86) ; CPU.AN19 165.42,135.09 v1(164.99,135.52) 165.42,135.95 CPU.AM19 v1(165.88,136.43) ; CPU.AL1 v1(146.05,137.8) ; CPU.P4 v3(149.05,152.89) ; CPU.AK36 v1(181.43,137.37) 180.97,136.92 CPU.AL36 ; v1(185.29,137.8) CPU.AK40 ; v1(182.34,141) CPU.AF37 ; CPU.AK18 v1(164.05,138.26) ; v1(179.6,138.26) CPU.AJ34 v1(179.6,139.18) ; v1(176.85,139.18) CPU.AJ31 ; CPU.AM39 v1(183.26,135.49) CPU.AM38 ; CPU.G6 v3(151.78,160.19) CPU.F7 ; CPU.W6 CPU.Y5 v3(150.88,147.4) ; v1(185.29,141.46) CPU.AF40 ; v1(152.81,64.13) 153.34,64.66 PQ20.1 ; v1(170.45,136.43) CPU.AM24 ; CPU.U6 v3(151.78,151.05) ; CPU.L3 v3(148.14,156.55) ; CPU.AU5 v1(149.97,131.86) CPU.AU4 ; CPU.AK12 v1(158.57,138.26) ; v1(176.85,135.49) CPU.AM32 ; CPU.AW9 v1(153.62,130.95) CPU.AV9 ; CPU.AH40 v1(185.29,139.63) ; 155.45,160.21 CPU.F10 ; BRIDGE.E10 57.2,194.99 v1(56.8,194.59) 56.4,194.99 BRIDGE.E11 ; v1(152.25,128.91) CPU.AY7 ; R39.1 123.26,191.94 v3(123.26,191.74) ; CPU.AV28 173.84,130.68 v1(174.09,130.95) ; CPU.AK15 v1(161.31,138.26) ; CPU.AP36 v1(181.43,133.69) CPU.AR36 ; v1(146.1,135.98) CPU.AN1 ; v1(153.62,139.18) CPU.AJ8 ; v1(152.71,141) CPU.AH8 ; CPU.AD4 149.33,144.38 149.33,144.38 149.05,144.66 v1(149.05,144.66) ; CPU.AJ5 v1(149.97,139.18) CPU.AK5 ; v1(178.96,128.65) 179.14,128.83 CPU.AW34 CPU.AV34 179.14,130.51 v1(179.57,130.95) 179.14,131.38 CPU.AU34 CPU.AT34 ; v1(180.51,135.49) CPU.AM35 ; v1(230.54,59.96) 231.05,59.45 PQ72.1 ; CPU.AR34 v1(179.6,133.69) CPU.AR35 ; CPU.AL5 v1(149.97,137.37) CPU.AM5 ; CPU.AP5 v1(149.97,135.49) CPU.AN5 ; v1(151.79,131.86) CPU.AU7 ; v1(182.34,137.37) CPU.AK37 ; QO12.4 v1(220.08,16.3) ; v1(151.79,139.18) CPU.AK7 ; v1(149.05,139.18) CPU.AJ4 ; CPU.AT5 v1(149.97,133.69) CPU.AR5 ; v1(179.6,135.49) CPU.AM34 ; CPU.AY27 v1(172.74,128) ; CPU.AK19 v1(164.97,138.26) ; CPU.AK25 v1(171.35,138.24) ; CPU.AT25 170.81,132.22 170.1,132.22 CPU.AT24 ; v1(154.52,139.16) 154.96,138.72 CPU.AK10 v1(155.45,138.26) ; v1(185.29,143.29) CPU.AD40 ; CPU.AR4 v1(149.05,133.69) ; v1(56,196.2) BRIDGE.F12 ; v3(161.85,163.86) CPU.C18 ; CPU.H1 v3(146.09,158.84) ; v1(152.7,133.7) 152.25,133.25 CPU.AT7 ; CPU.K15 v3(160.02,157.46) ; PQ79.1 107.97,62.85 v1(108.24,63.12) ; CPU.AG4 v1(149.03,141) ; v1(151.79,135.49) CPU.AN6 ; v3(163.96,164.15) 164.14,163.97 CPU.C20 ; CPU.N3 v3(148.14,154.72) ; CPU.AM17 v1(163.14,136.43) ; CPU.A17 161.4,165.68 v3(161.22,165.85) ; CPU.AN4 149.48,135.98 v1(149.05,135.49) ; CPU.AK26 v1(172.27,138.25) ; CPU.AK28 v1(174.1,138.25) ; BRIDGE.F11 56.39,195.8 v1(55.99,195.4) ; v1(178.68,141.92) CPU.AF33 ; v1(177.77,135.49) CPU.AM33 ; CPU.M1 v3(146.12,155.18) ; v1(146.1,134.15) CPU.AR1 ; v1(182.35,135.49) CPU.AM37 ; v1(167.71,137.35) CPU.AL21 ; v1(178.68,139.18) CPU.AJ33 ; CPU.AK17 v1(163.14,138.26) ; CPU.G3 v3(148.14,160.21) ; v1(178.68,141) CPU.AG33 ; v1(182.34,142.83) CPU.AD37 ; v1(153.62,135.49) CPU.AN8 ; v1(175.03,136.43) CPU.AM30 ; CPU.AG2 v1(148.14,141) CPU.AG3 ; v1(152.71,135.49) CPU.AN7 ; v3(163.68,162.04) CPU.E19 ; CPU.AK8 v1(152.71,139.18) ; CPU.L6 v3(151.79,156.55) ; CPU.U3 v3(148.14,151.06)
  TOP w0.381: 56,197 56.4,196.6 BRIDGE.G11 v1(56,196.2) ; CPU.M27 v3(170.08,154.72) ; BRIDGE.E5 v1(61.59,194.6) ; CPU.R33 v3(177.59,151.52) ; v1(161.3,132.77) 161.75,132.32 CPU.AT15 ; v1(25.47,150.75) 25.81,151.09 CF105.2 ; v1(61.59,199.39) 61.59,199.39 61.59,199.39 BRIDGE.K5 ; v3(163.68,160.21) CPU.G19 ; v1(111.39,132.97) 111.39,133.35 111.63,133.59 111.79,133.59 ; CPU.K22 v3(165.51,156.55) ; CPU.K35 v3(179.6,155.63) ; C1666.2 70.96,107.78 70.47,107.29 v1(70.47,107.06) ; CPU.H24 v3(167.34,158.38) ; v3(168.25,163.86) CPU.C24 ; v1(68.99,180.34) 68.36,179.7 CK48.2 ; CPU.C5 150.24,163.6 ; CPU.C31 v3(175.94,162.04) ; CPU.H28 v3(171,158.38) ; BRIDGE.E6 v1(60.79,194.6) ; CPU.B30 v3(172.83,163.86) ; CPU.E31 v3(175.94,160.21) ; v3(181.43,151.98) CPU.P37 ; CPU.E37 v3(182.34,161.12) ; CPU.F26 v3(169.17,160.21) ; CPU.F30 v3(172.83,160.21) ; BRIDGE.H9 58,197.4 v1(58.4,197.79) BRIDGE.H8 ; 62.26,74.44 62.26,74.68 v1(61.76,75.18) ; CPU.M19 v3(162.77,154.72) ; v3(149.05,158.38) CPU.H4 ; v1(55.53,185.17) 55.41,185.29 RK41.1 ; CK42.2 v1(62.77,206.88) ; v1(65.16,72.96) 64.47,72.96 64.3,73.14 ; BRIDGE.H5 61.58,197.78 61.58,197.79 v1(61.59,197.79) ; CB1.2 13.94,158.43 v1(13.62,158.75) ; CPU.C35 v3(179.6,162.04) ; BRIDGE.G5 v1(61.59,196.2) ; CPU.D26 v3(169.17,162.04) ; v3(161.85,162.04) CPU.E17 ; CK45.2 59.53,181.55 v1(59.34,181.36) ; CPU.U33 v3(177.59,149.69) ; BRIDGE.H7 v1(59.2,197.79) ; CK54.2 65.69,206.5 v1(66.07,206.88) ; CPU.K24 v3(167.34,156.55) ; v3(151.79,156.55) 151.89,156.65 CPU.K7 ; v1(68.99,180.97) 69.57,180.97 RK45.2 ; CPU.D24 v3(168.25,162.95) ; BRIDGE.H4 62.38,197.78 62.38,197.79 v1(62.39,197.79) ; CPU.E35 v3(179.6,160.21) ; CPU.AC6 150.89,145.57 v1(150.83,145.57) ; BRIDGE.D4 v1(62.39,193.8) ; CPU.D4 149.08,162.92 ; CPU.C14 v3(158.2,163.86) ; CX25.2 v1(65.37,227.77) ; BRIDGE.F8 v1(58.4,195.4) ; CPU.AU7 CPU.AT6 ; CPU.N33 177.88,153.35 v3(177.59,153.06) ; v1(55.66,182.75) 55.66,183.2 CK52.2 CK49.2 ; 155.45,160.21 155.64,160.02 CPU.G11 ; QM2.4 109.41,134.89 109.02,135.27 v1(109.02,135.38) ; BRIDGE.F12 v1(55.2,195.4) ; BRIDGE.F4 v1(62.39,195.4) ; v3(148.16,162.03) 148.59,161.59 CPU.E3 ; v3(179.6,153.81) CPU.M35 ; v1(71.13,107.06) 71.64,107.06 C1667.2 ; CPU.G31 v3(175.94,158.38) ; v3(183.25,151.98) CPU.P39 ; v3(168.25,154.72) CPU.M25 ; CPU.E33 v3(177.77,160.21) ; CPU.H30 v3(172.83,158.38) ; v1(56.93,181.86) 56.93,182.18 CK46.2 56.55,182.56 RK11.1 ; CPU.M15 v3(159.11,154.72) ; BRIDGE.D6 v1(60.79,193.8) ; CPU.E23 CPU.F22 ; CPU.W33 v3(177.59,147.86) ; CPU.Y35 v3(180.51,147.41) ; PQ4.S1 v1(99.84,139.08) ; CPU.AA33 v1(177.59,146.03) ; CPU.K30 v3(172.83,156.55) ; CPU.L9 154.08,156.1 v1(154.52,156.54) ; v3(165.5,159.28) CPU.H21 CPU.J20 ; CPU.T35 v3(179.6,150.15) ; v1(60.79,198.59) 60.79,198.59 60.79,198.59 BRIDGE.J6 ; v1(65.18,180.97) 65.37,181.17 RK44.2 ; v1(98.08,137.69) 97.57,137.19 PC2.2 97.86,136.54 PQ3.S2 ; BRIDGE.J9 v1(57.6,198.59) ; CPU.M21 v3(164.6,154.72) ; C74.1 130,195.07 130,194.87 129.95,194.82 129.95,194.82 129.75,194.61 129.75,194.53 129.63,194.4 v3(129.63,194.36) ; CK53.2 v1(69.69,190.12) ; CPU.D28 v3(171,162.04) ; CPU.AR23 CPU.AR22 ; v1(62.39,199.39) 62.39,199.39 62.39,199.39 BRIDGE.K4 ; v3(150.88,162.04) CPU.E6 ; CPU.M17 v3(160.94,154.72) ; CPU.M10 v3(155.47,155.65) 155.49,155.65 155.49,155.67 CPU.L11 ; CPU.F28 v3(171,160.21) ; BRIDGE.D10 v1(56.8,193.8) ; v1(60.36,181.99) 60.61,182.25 CK39.2 ; CF108.2 18.51,145.61 v1(18.19,145.92) ; v3(183.25,153.81) CPU.M39 ; QO6.1 v1(199.4,14.83) ; BRIDGE.E9 v1(57.6,194.6) ; v1(56,193) 56.4,193.39 BRIDGE.C11 ; BRIDGE.G7 v1(59.2,196.2) ; CK34.2 v1(35.72,246.25) ; CPU.C37 v3(181.44,162.05) ; CPU.C12 v3(156.37,163.86) ; v3(155.45,162.04) CPU.E11 CPU.F10 ; CPU.K28 v3(171,156.55) ; RK34.1 55.15,206.44 v1(55.15,207.01) 55.15,207.64 55.41,207.9 ; v1(47.02,48.01) 47.09,48.07 PR274.2 ; CPU.V39 v3(183.25,148.32) ; CPU.K14 v1(158.19,157.47) ; v3(179.6,151.98) CPU.P35 ; CPU.Y37 v3(182.34,147.41) ; BRIDGE.F6 v1(60.79,195.4) ; CPU.D37 v3(181.44,161.14) ; v1(60.79,199.39) 60.79,199.39 60.79,199.39 BRIDGE.K6 ; v3(168.25,165.69) CPU.A24 ; BRIDGE.L11 v1(56,200.19) ; CPU.B28 v3(171,163.86) ; BRIDGE.G6 v1(60.79,196.2) ; v3(160.02,157.46) CPU.J16 ; CPU.J32 v3(176.85,156.55) ; v1(61.65,207.26) 61.76,207.16 RK25.1 ; BRIDGE.G8 v1(58.4,196.2) 58,196.6 BRIDGE.G9 ; BRIDGE.F9 v1(57.6,195.4) ; RK39.1 54.52,206.31 v1(54.52,207.21) 54.52,207.77 54.39,207.9 ; v3(168.25,164.78) CPU.B24 ; BRIDGE.F7 v1(59.2,195.4) ; CPU.C10 154.54,163.86 154.54,163.87 v3(154.54,163.89) ; v3(151.79,158.38) CPU.H7 ; CPU.K26 v3(169.17,156.55) ; PQ3.S1 100.25,135.24 v1(100.13,135.36) ; CPU.H26 v3(169.17,158.38) ; CPU.T37 v3(181.43,150.15) ; CPU.D7 v3(151.79,162.95) ; RK33.1 v1(58.58,185.17) ; CPU.M29 v3(171.91,154.72) ; CPU.K37 v3(181.43,155.63) ; v3(183.25,157.46) CPU.H39 ; v3(150.89,164.76) 150.89,164.76 CPU.B6 ; v1(60.79,197.79) 60.78,197.79 60.78,197.78 BRIDGE.H6 ; BRIDGE.E7 v1(59.2,194.6) ; BRIDGE.J5 61.59,198.59 61.59,198.59 v1(61.59,198.59) ; CF107.2 18.51,149.16 v1(18.32,148.97) ; v1(100.11,137.69) 100.53,137.69 100.62,137.78 PQ4.S2 ; CPU.V35 v3(179.6,148.32) ; BRIDGE.J10 v1(56.8,198.59) ; v1(203,13.06) 203,13.19 202.66,13.53 QO6.4 ; CPU.V37 v3(181.43,148.32) ; v3(181.43,153.81) CPU.M37 ; v1(150.88,141) CPU.AG5 ; BRIDGE.J8 v1(58.4,198.59) ; BRIDGE.K8 v1(58.4,199.39) ; CPU.N6 v3(151.78,154.71) CPU.M7 ; CA76.2 v1(222.54,14.3) ; v1(69.88,184.91) 69.38,185.42 UK2.2 ; CPU.T39 v3(183.25,150.15) ; CPU.M23 v3(166.42,154.72) ; CPU.K39 v3(183.25,155.63) ; v1(63.41,208.03) 64.17,207.26 CK7.2 ; BRIDGE.D8 v1(58.4,193.8) ; BRIDGE.J7 v1(59.2,198.59) ; v3(181.43,157.46) CPU.H37 ; v3(149.05,160.21) CPU.F4 ; CPU.C33 v3(177.77,162.04) ; CPU.B26 v3(169.17,163.86) ; BRIDGE.E8 v1(58.4,194.6) ; CPU.E15 v3(160.03,162.04) ; CPU.D30 v3(172.83,162.04) ; CPU.G33 v3(177.77,158.38) ; BRIDGE.K10 v1(56.79,199.4) ; CK56.2 64.36,180.4 65.08,180.4 65.18,180.3 v1(65.18,180.28) ; CPU.K19 v3(162.77,156.55) ; CPU.K17 v3(160.94,156.55) ; BRIDGE.F5 v1(61.59,195.4)
  TOP w0.406: v1(63.41,142.49) 62.96,142.49 C1646.1 ; v1(40.76,59.98) 40.76,60.09 PQ52.S1 ; v1(7.4,66.8) 7.4,66.55 7.53,66.42 PR240.2 ; CS126.2 v1(10.32,65.98) ; v1(30.02,116.46) BH1.1 30.45,117.47 C1629.2 ; PU21.3 v1(5.99,44.21) ; v1(216.82,59.11) 216.74,59.11 216.33,59.51 216.33,59.82 ; CA21.2 187.79,29.54 v1(187.28,29.04) ; 123.94,235.33 123.94,235.03 v1(124.42,234.54) ; UU1.2 101.08,246.81 v1(100.59,247.29) ; CPU.AT25 171.33,132.74 v1(171.37,132.74) 171.79,132.32 CPU.AT26 ; v1(153.62,131.86) CPU.AV9 ; UU3.2 131.9,239.61 132.32,239.61 v1(132.54,239.83) ; v3(153.63,158.41) 153.2,158.84 CPU.H8 ; v3(155.86,222.12) 155.86,222.43 CG20.1 ; v1(188.63,32.34) 188.69,32.4 CA23.2 ; PU21.1 6.36,42.91 5.95,43.32 v1(5.95,43.43) ; QO14.1 220.2,21.5 v1(220.63,21.07) ; UU4.2 165.39,19.87 v1(165.87,20.36) ; QO3.1 v1(8.78,69.72) ; RA42.2 190.42,18.17 v1(190.33,18.09) ; v1(51.85,141.99) 52.29,142.43 R6582.2 ; v1(41.69,120.14) 41.75,120.08 C1645.2 ; PC295.2 123.15,151.05 v1(122.72,150.62) ; QO12.1 v1(218.78,16.05) ; C66.2 101.89,84.07 v1(102.4,84.58) 102.01,84.96 C67.2 ; BH1.3 28.72,116.87 29.13,116.46 v1(29.37,116.46) ; CD4.2 215.29,74.99 v1(215.63,74.65) ; v1(219.3,20.62) 218.9,20.23 QO14.4 ; RF29.1 33.62,89.47 v1(34.2,90.04) ; PQ52.S2 39.01,62.12 v1(39.24,61.89) ; R121.2 136.05,208.79 v1(135.75,209.09) ; CPU.AE5 149.98,142.85 v1(149.98,142.82) CPU.AF5 ; v1(214.92,58.8) 215.03,58.69 QS11.S1 ; R65.2 218.28,74.99 v1(217.84,74.55) ; v1(147.72,20.33) 148.21,20.81 UU9.2 ; v1(45.37,253.11) 45.1,252.84 U1.3 ; v3(151.79,152.88) CPU.R6 ; PR284.2 108.11,67.06 v1(107.6,66.55) ; C64.2 98.86,84.96 v1(99.32,84.51) 98.89,84.07 C65.2 ; v1(98.81,229.51) 99.3,230 UU17.2 ; CPU.AB5 150.83,145.62 v1(150.83,145.57) ; PR241.2 v1(8.54,66.8) ; PC49.2 150.91,64.8 151.47,64.24 v1(151.47,64.13) ; v1(41.71,113.36) 41.91,113.16 RA59.1 ; PQ22.S2 99.35,65.15 v1(99.22,65.28) ; v1(33.14,159.55) 32.42,160.27 CS177.2 ; CPU.AE3 v1(148.14,143.74) ; v1(41.05,120.14) 40.99,120.08 C1678.2 ; v1(6.76,72.9) 7.08,72.58 RO53.2 ; v1(103.26,138.79) 103.4,138.65 PQ49.S1 ; CA77.2 v1(193.79,10.67) ; QO3.4 v1(10.08,73.53) ; C71.2 216.38,74.99 v1(216.82,74.55) ; CA107.2 v1(225.2,254.25) ; v1(231.68,241.81) 231.68,241.62 CA108.2 ; CPU.G13 v3(158.2,159.29) ; v1(104.94,64.77) 105.32,64.39 PQ79.4
  TOP w0.457: v1(119.5,157.48) 119.6,157.38 CS82.2 ; C1688.2 39.02,109.22 v1(38.77,108.97) ; C1688.2 C1649.1 C1648.1 39.4,111.19 v1(39.4,111.96) ; C1688.2 39.59,108.9 v1(39.28,108.59) ; CS78.2 119.98,158.81 v1(119.92,158.88)
  TOP w0.508: RG12.2 v1(147.1,231.39) ; v1(224.09,83.82) 224.62,83.82 CD5.2 ; RST_SWH.2 v1(9.56,111.63) ; v1(172.5,32) 172.94,31.56 CS69.2 ; v1(181.52,174.88) 181.01,174.88 PC131.2 181.01,174.12 v1(181.52,174.12) ; v1(106.97,139.06) 107.22,138.81 PU14.2 ; v1(223.5,178.36) 224.06,178.92 PC93.2 ; CK50.2 v1(69.88,197.49) ; v1(72.68,251.59) 73.19,252.09 CL59.2 ; RG8.2 v1(142.61,229.66) ; PC63.1 60.03,81.64 v1(59.62,81.64) ; CA109.2 v1(230.79,235.08) ; C6.1 v1(118.78,84.45) ; PR90.2 v1(4.99,217.04) ; v1(118.75,229.9) 118.4,230.25 CL5.2 ; CA29.2 v1(185.71,32.08) ; CO10.1 220.98,33.11 v1(220.98,32.47) ; CS201.2 v1(69.65,234.12) ; v1(228.02,50.8) 227.64,51.18 CO6.1 ; DA7.2 197.14,17.39 v1(196.29,17.39) ; CO12.1 v1(223.3,32.51) ; RF13.2 218.47,225.74 v1(218.47,225.23) ; v1(166.4,174.88) 165.77,174.88 PC128.2 165.77,174.12 v1(166.4,174.12) ; v3(169.97,235.71) 170.29,235.71 CG13.2 ; CS171.2 v1(89.7,140.59) ; CS84.2 130.56,175.86 v1(130.56,175.96) ; CU3.2 130.46,229.87 v1(130.08,229.49) ; C412.2 146.65,234.76 v1(147.23,234.19) ; CS188.2 18.73,124.22 v1(18.85,124.22) ; v1(16.09,149.81) 16.33,150.05 CS187.2 ; R78.2 v1(43.98,115.82) ; PQ76.E v1(235.82,60.96) ; PC94.2 220.84,182.9 220.84,183.61 v3(220.84,183.62) ; PC33.2 v1(205.01,65.02) ; PQ49.S2 105.49,139.95 v1(105.72,139.73) ; PC241.2 v1(107.6,71.12) ; PC46.2 154.47,64.31 154.47,63.5 153.96,62.99 v1(153.96,62.61) ; v1(118.91,224.79) CL32.2 ; DA6.3 v1(231.17,244.42) ; CK2.2 v1(49.56,196.98) ; CA25.2 v1(179.48,32.08) ; v3(218,199.15) 218.04,199.15 PC89.2 ; v1(195.74,16.21) 195.3,15.77 CA74.2 ; v1(219.41,227.91) 219.17,228.16 CF7.2 ; C49.2 v1(207.87,83.69) ; v1(111.03,138.94) 110.84,138.94 PR224.2 ; CS184.2 22.37,143.18 v1(22.28,143.18) ; v1(13.5,43.94) PC302.2 ; CK14.2 52.42,208.85 v1(53.5,209.93) ; CF103.2 17.62,157.29 v1(17.56,157.23) ; CS211.2 125.21,155.41 v1(125.21,156) ; RO169.2 207.42,34.86 207.42,34.6 v1(207.66,34.37) ; v1(118.91,225.81) CL34.1 ; v1(64.68,105.79) 65.12,105.35 CS97.2 ; CO13.1 204.74,42.16 204.61,42.29 v1(204.47,42.29) ; R6681.2 v1(118.59,197.42) ; v1(223.3,241.17) 223.62,240.86 RV79.2 v1(224.82,240.86) CV40.2 RV80.2 ; v1(143.34,84.79) 143.34,84.71 142.83,84.2 141.97,84.2 C1767.2 141.94,84.84 v1(142.53,84.84) ; v3(147.13,163.88) 147.23,163.88 147.68,163.43 CPU.C2 ; CA125.2 v1(237.78,62.99) ; PC350.1 102.09,141.73 v1(101.91,141.55) ; v1(14.79,38.61) PQ71.S ; R6518.2 41.86,117.86 v1(41.68,117.68) ; CS176.2 v1(51.47,233.04) ; PC92.2 215.09,195.82 215.21,195.82 v3(215.23,195.8) ; C25.2 110.9,75.82 v1(111.03,75.69) ; v1(15.91,241.17) 15.27,240.53 PC82.2 15.05,240.22 14.26,239.43 PR88.2 14.16,239.2 13.53,238.57 CK64.2 12.97,238.57 v1(12.5,238.1) ; v3(122.73,194.16) 122.75,194.18 R40.1 ; v1(176.44,84.96) 175.93,84.96 C61.2 176.06,84.07 176.94,84.07 v1(177.43,84.56) ; v1(177.2,29.54) 177.2,30.24 CA92.2 ; C1644.2 43.91,120.08 v1(43.98,120.14) ; CO4.1 v3(206.92,48.9) ; RX18.1 v1(67.75,231.14) ; RX17.1 v1(67.75,232.16) ; PR204.1 PC181.2 v1(140.24,192.66) ; v1(176.82,94.36) 176.31,94.36 C60.2 176.31,93.6 v1(176.82,93.6) ; CB2.2 v1(14.64,153.03) ; v1(203.36,53.21) 203.55,53.02 RO54.2 ; PC24.2 13.29,206.96 v1(13.75,206.5) ; v1(144.33,220.09) 143.73,220.09 RG29.2 ; v1(46.64,195.49) 46.97,195.16 CS199.2 ; v1(145.32,75.06) 144.81,74.55 RD1.2 ; v3(153.8,220.93) 153.65,220.78 CG19.1 ; 34.66,173.19 34.54,173.19 v1(33.92,172.57) ; v1(210.07,84.79) 210.66,84.2 211.62,84.2 C58.2 211.62,84.96 v1(211.11,84.96) ; QA3.S 174.29,35.7 v1(174.79,36.19) ; PC57.1 97.19,66.23 v1(97.19,65.66) ; v1(66.96,169.49) 66.54,169.91 CS200.2 ; RO48.2 200.63,49.78 v1(200.95,49.78) ; v1(25.89,131.85) 26.68,131.85 26.7,131.83 C1763.2 ; CK44.2 v1(69.5,188.15) ; CA84.1 165.73,47.99 v1(165.34,47.6) ; PC198.2 104.81,142.37 v1(104.3,142.88) ; RO171.2 199.74,44.51 v1(199.42,44.2) ; v1(216.72,85.12) 217.14,84.7 C51.2 ; PC86.2 213.48,195.24 v3(213.01,195.71) ; v1(210.07,34.39) 210.54,34.86 CO3.1 ; v1(193.33,23.7) 193.01,24.02 CA79.1 ; PQ24.S1 99.42,100.71 v1(100.01,101.3) ; Y1.4 77.29,134.11 v1(77.25,134.11) ; CS203.2 47.96,225.41 47.86,225.31 v1(47.77,225.31) ; CS204.2 28.1,153.62 v1(27.71,153.23) ; v1(189.26,226.19) 188.88,226.19 188.24,226.83 UO2.11 ; PC39.2 v1(177.45,75.06) ; PC98.2 230.28,197.17 v1(230.28,197.74) ; CS145.2 239.11,114.16 v1(238.7,114.57) ; v1(219.83,241.05) 219.83,241.26 C558.2 ; C3.2 v1(108.81,85.09) ; v1(23.21,133.58) 23.21,133.22 CS180.2 ; CS120.2 70.46,168.84 v1(71.15,168.15) ; CS154.2 86.52,242.44 v1(86.9,242.82) ; CS162.2 v1(32.76,248.09) ; PR52.2 v1(217.46,71.12) ; v1(202.6,232.03) CF14.2 ; CL54.2 63.66,250.19 v1(63.28,250.57) ; v1(52.98,232.56) 54.09,232.56 CS202.2 ; PC83.2 223.49,197.55 v3(223.3,197.74) ; PC336.2 42.76,55.27 v1(42.06,55.27) ; DA5.3 170.72,24.11 v1(171.05,23.78) ; CO7.1 v1(218.98,56.13) ; PC26.2 15.68,233.32 v1(16.06,233.32) ; PC26.2 14.37,233.73 PR32.2 ; PC26.2 15.27,233.93 v1(15.78,234.44) ; PC35.2 v1(212.86,68.14) ; PR27.2 v1(22.98,71.97) ; R6628.2 v1(222.28,30.1) ; CS143.2 228.32,117.71 v1(227.82,118.21) ; CS182.2 31.87,144.03 v1(31.45,143.61) ; C1684.1 v1(44.86,105.16) ; C413.2 146.59,236.79 147.1,236.28 v1(147.1,235.97) ; CV41.2 223.06,247.08 v1(223,247.14) ; v1(142.91,191.39) 142.59,191.07 PR211.1 ; v1(42.37,35.29) 43.04,35.29 CS179.2 ; v1(120.18,230.95) RL44.1 ; v1(204.38,251.33) CG15.1 ; v1(221.75,83.44) 222.08,83.77 CD3.2 ; RA22.2 v1(190.6,28.97) ; v1(175.42,232.79) 175.48,232.85 CNO1.1 ; v1(98.2,48.9) 98.71,49.4 PC303.2 ; CK28.2 v1(33.56,212.22) ; v1(224.19,55.25) 224.44,54.99 CO5.1 ; RO28.1 205.44,37.08 v1(205.39,37.13) ; v1(20.61,75.18) PC21.2 ; C1682.2 C1683.2 v1(43.98,121.35) ; C1640.2 v1(38.9,132.21) ; PR345.2 v1(92.62,254.76) ; v1(46.39,57.02) 46.77,56.64 PC325.1 ; CO51.2 v1(52.36,140.59) ; DG8.1 172.25,227.73 171.76,228.25 v3(171.76,228.73) ; PC308.2 v1(16.16,45.34) ; v1(46.16,45.29) 45.88,45.29 PC338.2 ; C531.2 v1(226.68,253.11) ; PQ46.S 116.49,154.81 v1(115.86,154.18) ; v1(229.81,185) 229.22,185.6 PC84.1 ; CX19.2 v1(67.18,236.66) ; CL51.1 111.48,222.29 v1(111.56,222.2) ; v1(96.68,99.33) 97.47,99.33 PQ24.S2 ; RB12.2 v1(14.64,156.08) ; v1(73.97,109.45) 74.61,110.08 C1655.2 ; PC293.2 175.04,141.99 v1(175.42,142.37) ; v1(31.78,102.23) 31.78,102.68 CF10.2 CF9.2 ; v3(230.13,185.65) 230.13,186.03 229.62,186.54 229.23,186.54 PR122.1 ; v1(176.82,96.14) 176.44,96.14 C59.2 176.31,95.25 v1(176.82,95.25) ; v1(70.9,177.93) 70.58,177.61 CS118.2 ; R75.2 v1(36.48,115.19) ; CS192.2 45.57,83.23 v1(45.23,83.56) ; v1(144.05,98.3) 144.05,97.79 PC40.2 143.29,97.79 v1(143.29,98.3) ; v1(171.36,174.88) 170.72,174.88 PC129.2 170.72,174.12 v1(171.36,174.12) ; v1(120.17,38.36) 120.17,37.85 119.64,37.32 PQ55.S2 ; v1(42.43,137.21) 42.07,136.86 C1681.1 ; R6607.2 v1(56.17,108.08) R6603.1 ; PQ9.S v1(13.69,75.29) ; v1(159.55,237.82) C409.2 ; v1(103.98,219.9) 105.1,219.9 105.95,220.75 RL35.2 ; CB3.2 v1(14.64,149.99) ; C1.2 v1(171.23,84.95) ; v1(119.46,138.61) 118.97,139.1 CS218.2 ; CX14.2 75,232.66 v1(74.5,233.17) ; PC50.2 v1(153.45,75.31) ; PC30.2 v1(7.27,207.26) ; v1(95.61,96.04) 95.61,96.32 PC312.2 ; CF13.1 v1(40.6,99.9) ; CF21.2 v1(35.72,89.41) ; PR109.1 v3(216.12,181.04) ; C5.2 147.24,84.98 v1(146.62,84.36) ; v3(232.49,192.2) 231.55,192.2 231.44,192.32 PC102.2 ; v1(198.15,16.84) 198.79,16.84 CA88.2 198.79,17.61 v1(198.15,17.61) ; RD7.2 220.1,83.92 v1(219.49,83.31) ; v1(182.28,32.08) 181.69,31.5 CA28.2 ; RB13.2 v1(14.64,151) ; v1(30.46,155.96) 30.96,155.96 CS207.2 ; UA2.2 v1(200.06,24.21) ; C1677.2 62.52,145.52 v1(62.56,145.55) ; Y1.2 76.4,130.85 77.08,130.18 v1(77.25,130.18) ; v1(64.68,185.55) 65.06,185.17 CK5.2 ; PC229.2 v1(100.11,74.29) ; C411.2 150.4,236.28 v1(150.4,235.97) ; CK61.2 v1(27.97,169.04) ; v1(25.63,79.74) 25.37,79.48 CS195.2 ; v1(11.46,36.83) 11.46,36.13 CS215.2 ; v1(220.99,223.98) 220.12,223.11 UF147.5 ; v1(166.28,84.2) 165.77,84.2 C1769.2 165.77,84.96 v1(166.28,84.96) ; C1654.2 73.97,112.6 v1(73.74,112.6) ; v1(41.05,47.5) 41.05,47.82 PR273.2 ; v1(221.54,74.14) 220.86,74.14 C72.2 ; CL46.2 113.83,231.39 v1(114.31,231.88) ; CK68.2 v1(27.77,217.53) ; v1(183.04,224.54) 182.79,224.28 C383.2 ; CD2.2 v1(223.05,83.31) ; RP5.2 v1(45.5,140.72) ; R1.1 126.96,194.97 v3(126.96,193.95) 127.26,193.95 128.21,194.9 R12.1 ; CL45.2 116.17,228.51 v1(116.29,228.63) ; PC261.2 68.36,73.41 v1(69.12,74.17) ; v1(106.59,231.39) 107.16,230.82 CL47.2 ; CS144.2 231.11,236.28 v1(230.79,235.97) ; C70.2 119.3,193.93 v3(119.04,194.18) ; PC1.2 42.41,147.13 42.86,146.69 v1(42.96,146.69) ; DIMM1.139 101.73,91.91 101.73,94.11 v1(102.15,94.52) 102.61,94.99 102.72,95.09 PR49.2 103.09,94.82 103.46,94.82 v1(104.55,95.91) v1(104.55,98.48) v1(104.55,101.35) 104.55,105.26 103.79,106.02 103.79,111.51 104.17,111.89 v1(104.17,114.26) 104.2,114.26 v1(106.04,116.11) v1(110.47,120.54) 112.19,120.54 113.39,121.74 115.6,121.74 117.12,123.26 v1(117.12,124.08) v1(118.92,125.87) v1(121.79,128.74) v1(123.35,130.3) v1(125,131.95) v1(126.82,133.77) v1(128.35,135.31) v1(130.55,137.5) v1(131.73,138.68) ; PC195.2 104.3,144.4 v1(104.05,144.4) ; R45.1 R46.1 124.63,194.78 v3(124.63,194.06) ; v1(107.6,67.94) 107.48,68.07 PC240.1 ; CO14.2 v1(224.32,32.51) ; v1(119.79,227.84) CL35.2 ; PC106.2 230.12,187.77 v3(230.64,187.25) ; SPI1.4 v1(36.48,111.63) ; v1(236.13,136.27) 236.06,136.21 CF2.2 ; v1(113.06,225.22) 113.56,224.73 CL41.2 ; CF9.2 CF8.2 v1(33.56,102.23) ; CF9.2 v1(32.55,102.23) ; PC25.2 v1(13.05,205.36) ; RS169.2 115.79,197.68 115.48,197.99 v1(115.48,198.07) ; CK40.2 65.25,186.31 v1(64.68,186.31) ; CK35.2 v1(49.56,197.87) ; CO54.2 v1(218.54,18.46) ; R6636.2 145.27,220.68 v1(145.83,221.23) ; RA43.2 195.96,18.65 196.15,18.65 v1(196.38,18.88) ; CG16.2 192.44,234.06 v1(192.57,233.93) ; CL53.2 62.45,250.63 v1(62.64,250.82) ; v1(118.52,143.13) 118.84,142.81 R6298.2 ; v3(172.37,235.71) 172.75,236.09 CG14.2 ; CS156.2 v1(232.82,141.35) ; v1(40.67,150.24) 41.05,150.62 CO55.2 41.37,150.63 CS175.2 ; v1(173.01,74.94) 172.32,74.94 C55.1 ; PR56.2 C21.2 v1(159.74,71.95) ; CS190.2 54.2,84.96 v1(53.53,84.96) ; v1(175.44,232.05) CNO1.3 ; v1(214.16,199.42) 213.77,199.03 PR159.2 ; v1(25.74,143.38) 26.13,143.78 CS183.2 ; C69.2 v1(223.37,74.41) ; v1(31.15,90.68) 30.83,90.68 CF20.2 ; v1(203.11,64.39) 203.11,65.02 PC32.2 203.87,65.02 v1(203.87,64.39) ; v1(114.16,230.84) 114.29,230.7 CL6.2 ; CV42.2 222.16,241.24 v1(222.16,241.05) ; C1768.2 v1(141.64,74.68) ; v3(94.01,64.82) 94.01,64.58 95.03,63.56 ; CK59.2 v1(27.96,237.82) ; R82.2 v1(43.98,116.84) ; R6602.2 v1(56.04,140.72) ; v1(225.59,200.15) PR166.1 ; v1(198.41,232.03) 198.92,231.52 CF5.2 ; v1(160.57,237.82) C415.1 ; RG32.1 154.78,229.3 v1(154.85,229.36) ; v1(66.58,250.19) 66.96,250.57 CL56.2 ; CX83.2 86.39,234.5 86.39,233.78 v1(86.55,233.63) ; PC304.2 v1(23.25,45.19) ; UF147.4 220.12,227.67 219.62,227.16 v1(219.45,227.16) ; PC297.2 v1(122,149.3) ; CK51.2 v1(69.88,198.37) ; v1(17.48,82.35) 17.46,82.33 17.46,81.31 CS196.2 ; CF19.2 36.67,100.52 v1(36.23,100.97) ; v1(40.29,94.74) 39.66,94.11 RF26.2 ; CA124.2 v1(238.48,111.19) ; PC22.2 16.99,76.39 16.21,77.17 v1(16.21,77.57) ; C53.1 v1(162.97,95.76) ; RA34.2 v1(199.8,16.27) ; CS209.2 129.6,165.52 v1(129.6,164.97) ; R80.2 35.79,118.23 v1(35.79,119.02) ; CA16.1 v1(191.8,27.39) ; v1(205.77,53.97) 206.15,54.36 CA89.2 ; CS165.2 v1(235.8,68.73) ; RU68.2 v1(54.46,75.69) ; RF34.2 33.24,98.49 v1(32.93,98.17) ; RA12.1 35.91,116.08 v1(36.48,116.08) ; 63.34,251.59 v1(62.58,252.35) ; CK25.2 v1(55.41,234.7) ; R72.2 v1(47.4,108.08) R70.2 ; v1(200.82,42.29) 200.06,41.53 DO1.1 ; C1660.2 v1(57.56,148.74) ; CO56.2 v1(215.87,19.48) ; R98.1 v1(50.83,107.82) R90.1 ; 59.91,251.59 v1(59.15,252.35) ; v1(61.09,75.29) 61.09,75.53 PC62.2 ; v1(35.72,90.17) 36.16,90.17 CF12.2 ; v1(52.56,224.79) 52.17,224.4 CS198.2 ; v1(158.78,235.59) 158.78,234.63 DG5.1 ; PR203.1 v1(145.58,196.47) ; RS123.2 v1(63.79,106.04) ; v1(31.91,118.3) C1629.2 ; CL52.2 v1(57.82,250.19) ; CK66.2 v1(27.53,225.49) ; CL33.2 v1(100.74,234.06) ; PC310.2 93.87,92.7 v1(93.87,92.34) ; CS142.2 v1(152.31,13.29) ; CK26.2 v1(47.59,215.96) ; v1(11.46,35.43) 11.03,35 AUX_PWR1.2 ; CPU.AU1 146.69,132.39 v1(146.13,132.39) ; v1(62.19,138.46) 62.58,138.85 RP35.2 RP34.2 62.58,140.04 v1(62.14,140.49) 62.58,140.93 C1807.1 ; v3(216.06,199.52) 216.31,199.26 PR162.2 ; v3(213.14,190.75) 213.2,190.75 PC88.2 ; PU20.2 v1(93,249.56) ; PC258.2 v1(94.85,245.06) ; v1(43.98,114.88) 43.92,114.94 R83.2 RS236.2 ; CK16.2 v1(50.96,205.87) ; CO33.2 v1(183.04,225.3) ; v1(49.36,251.89) 48.42,251.89 UX1.3 ; RO21.2 v1(228.13,44.45) ; CNO2.3 v1(175.55,228.24) ; R21.1 R37.1 v1(121.71,208.66) ; v1(177.45,233.55) 177.71,233.55 178.02,233.87 C386.2 ; PC72.2 60.56,78.09 60.56,78.51 v1(60.41,78.66) 60.87,79.12 PC61.2 ; QV72.S 211.04,58.1 v1(211.74,58.8) ; v1(33.84,193.45) 33.57,193.45 33.2,193.07 CK9.2 ; CL15.2 105.63,229.93 v1(105.38,230.19) ; v1(28.74,92.33) 29.31,92.33 CF23.2 ; v1(175.42,230.5) 175.48,230.45 CNO1.7 ; R38.1 R47.1 125.34,194.81 v3(125.34,194.06) ; PR111.1 v3(217.27,180.97) ; v1(109.76,38.54) 109.89,38.42 PR249.2 PR248.2 ; CPU.B38 v3(183.45,164.06) ; v1(37.71,59.12) 37.97,58.87 CS189.2 ; v1(100.92,94.11) C23.2 ; CA90.1 189.81,17.69 189.52,17.99 v1(189.52,18.22) ; R6331.2 v1(57.06,140.72) R6466.1 ; R101.1 v1(51.98,107.82) R109.1 ; PR270.2 v1(42.45,45.47) ; v1(185.45,232.79) 185.45,233.87 C379.2 ; v1(227.39,71.22) 227.16,70.99 PQ16.S ; v1(186.6,175.01) 186.09,175.01 PC132.2 185.96,174.12 v1(186.6,174.12) ; v1(160.43,84.96) 160.18,84.71 C63.2 ; C20.2 v1(153.96,73.66) ; CU14.2 v1(54,74.1) ; CK43.2 34.39,204.03 v1(34.22,203.86) ; v1(118.78,223.39) 118.59,223.39 CL31.2 ; C56.1 v1(150.21,85.09) ; CS194.2 29.18,76.9 v1(29.5,77.22) ; v1(76.92,236.55) 76.78,236.41 CX18.2 ; C24.2 v1(106.71,75.82) ; RG27.2 145.19,225.93 v3(144.69,225.43) ; v1(66.84,212.47) 66.14,213.17 CS131.2 ; v1(231.43,188.09) 231.43,187.39 PR157.1 ; v1(136.3,44.7) 136.3,45.15 135.8,45.66 RS166.2 ; v1(112.81,38.61) 113.25,38.16 CS140.2 CS141.2 ; PC44.2 v1(166.66,75.31) ; CS216.2 v1(18.83,36) ; v1(47.48,32.83) PQ57.S ; v1(102.9,48.9) 102.4,49.4 CS132.2 ; CA2.2 189.69,20.4 v3(189.52,20.4) ; v1(34.25,201.93) 34.39,202.07 CK29.2 ; R22.1 R33.1 122.6,208.6 v1(122.54,208.66) ; CA24.2 v1(180.5,32.08) ; PC323.2 36.55,44.77 PC326.2 ; PC81.1 11.97,236.09 v1(11.59,235.71) ; CK60.2 v1(28.74,222.88) ; R103.1 v1(49.56,107.95) R108.1 ; CL17.2 v1(105.95,230.89) ; C54.1 v1(159.8,95.76) ; v1(106.25,38.56) 105.44,37.75 PC300.2 ; v1(64.68,188.47) 65.06,188.09 CK58.2 ; CK41.2 v1(69.76,196.6) ; C68.2 v1(222.32,74.45) ; v1(132.54,174.14) 132.05,173.65 CS208.2 ; CU13.2 54.85,76.2 v1(54.41,76.63) ; R152.1 v1(135.03,196.85) ; v1(161.58,237.82) R381.2 ; PC185.2 v1(143.61,192.79) ; PC349.2 106.97,69.09 v1(107.48,69.6) ; v1(102.27,101.17) 102.2,101.1 C1728.2 ; CO2.1 v1(225.33,32.51) ; CU5.2 v1(93.63,254.76) ; v1(224.63,200.15) PC90.2 ; v1(128.05,174.75) 128.5,174.3 CS148.2 ; CK8.2 v1(51.21,201.17) ; RP8.2 v1(48.17,145.16) ; v1(125.61,208.61) 125.61,208.25 R26.1 R25.1 ; v1(118.91,228.85) RL33.1 ; v1(215.78,33.32) 215.78,33.87 R3.2 ; v1(116.09,134.29) 115.46,134.29 CS73.2 ; PC48.2 v1(149.26,72.64) ; v1(158.53,237.79) C414.2 ; C1808.2 v1(39.02,143.38) ; v1(184.73,32.07) 184.73,31.78 184.31,31.36 CA18.1 ; v1(113.71,220.03) CL43.2 ; RU47.2 v1(138.08,20.97) ; CS166.2 107.73,38.1 v1(108.24,38.61) ; v1(123.22,152.17) 122.49,152.91 PQ47.E ; v1(231.05,197.74) 231.05,196.91 PR165.2 ; CK47.2 v1(69.88,200.28) ; v3(171.99,226.31) CG17.1 ; v1(113.04,220.7) 112.68,220.34 CL50.1 ; PC47.2 154.54,66.6 v1(153.96,66.6) ; DG7.1 171.63,232.93 v1(171.36,232.66) ; v1(226.22,34.67) 226.73,34.16 RO36.1 ; C1630.2 v1(41.56,130.56) ; CA87.2 162.81,47.87 v1(163.13,47.55) ; CO8.1 v1(228.13,47.62) ; v1(176.18,174.24) 175.55,174.24 175.29,174.5 175.8,175.01 v1(176.18,175.01) ; PC337.2 45.32,56.69 v1(44.86,57.15) ; CS197.2 15.46,69.35 v1(15.39,69.28) ; CA27.1 182.79,31.56 183.04,31.81 v1(183.04,32.08) ; v1(174.73,231.11) 174.87,231.25 CNO1.5 ; CS185.2 27.97,146.28 v1(28.3,145.95) ; v1(237.07,134.85) 237.33,135.12 CF1.2 ; CF24.1 35.02,99.82 v1(35.09,99.82) ; v1(63.61,77.06) 63.09,76.54 PC262.2 ; v3(168.31,224.41) EEPROM_G.2 ; PC327.2 49.25,43.69 v1(48.67,43.69) ; PC343.2 17.81,65.15 v1(18.07,64.9) ; PR22.2 v1(232.51,62.24) ; v1(51.93,206.78) 52.41,206.3 CK15.2 RK35.1 ; CG21.2 156.64,222.09 v1(157.16,222.61) ; v1(144.88,85.2) 145.5,85.2 C8.1 ; v1(185.66,84.71) 186.16,84.2 187.23,84.2 C57.2 187.1,84.84 v1(186.6,84.84) ; C7.1 v1(147.35,95.38) ; C1641.2 v1(38.9,133.22) ; CS129.2 v1(48.55,194.44) ; RG10.2 v1(149.27,232.41) ; PC301.2 v1(8.29,39.88) ; RO117.1 v1(232.32,49.66) ; RA9.1 v1(34.83,118.87) ; v1(45.5,105.23) 45.5,104.2 46.01,103.7 RS234.2 ; PR46.1 212,73.91 v1(211.87,73.79) ; C1679.2 54.2,149.54 v1(54.01,149.73) ; v1(20.61,72.14) 20.77,71.97 PR28.2 ; C52.1 v1(167.93,95.88) ; 56.48,251.59 v1(55.72,252.35) ; C1661.2 57.56,145.41 v1(56.93,144.78) ; PC178.2 v1(143.8,203.96) ; CS210.2 128.3,160.25 v1(127.95,160.6) ; CA22.1 v1(187.1,28.4) ; v1(35.06,140.67) 34.9,140.5 CS133.2 ; CK32.2 v1(74.16,227.58) ; RG14.2 v1(148.12,231.39) ; C1722.2 102.27,99.44 v1(102.27,99.82) ; v1(99.98,101.98) PC73.2 ; CG22.1 144.96,227.58 v3(144.7,227.84) ; v1(134.58,84.79) 133.99,84.2 132.88,84.2 C1766.2 132.75,84.84 v1(133.38,84.84) ; CA11.1 192.18,23.42 v1(192.23,23.47) ; 46.39,74.55 46.39,74.84 v1(46.86,75.31) ; CB4.2 v1(14.64,154.94) ; CK63.2 v1(27.15,202.78) ; CX56.2 v1(55.41,233.43) ; DA4.3 v1(193.58,11.76) ; v1(192.56,27.64) CA82.2 ; v1(143.42,231.44) CG23.2 ; CO52.2 v1(221.21,15.41) ; CK31.2 v1(27.97,168.02) ; v1(124.75,167.26) CS83.2 ; CX84.2 v1(35.15,240.35) ; CS214.2 5.07,209.11 v1(4.74,208.77) ; PU3.2 v1(157.77,69.22) ; v1(50.2,34.54) 50.2,34.16 50.52,33.85 PC321.2 ; v1(168.18,226.44) 167.67,226.95 EEPROM_G.4 ; CK11.2 v1(49.18,201.17) ; v3(149.02,165.73) CPU.A4 ; CS193.2 26.98,85.22 v1(27.36,84.84) ; PC34.2 209.15,74.47 209.71,73.91 v1(209.71,73.79) ; RA44.2 v1(230.79,234.06) ; CO53.2 v1(198.41,12.4) ; v1(144.2,229.57) 144.62,229.15 CG24.1 ; CX57.2 v1(54.71,229.81) ; v1(119.79,226.82) CL36.2 ; v1(114.71,132.84) 114.71,132.4 CS75.2 ; v1(40.29,95.76) 39.66,95.12 RF30.2 ; C766.2 R6591.2 172.56,55 v1(173.18,55.63) ; CS186.2 17.39,145.96 v1(16.77,146.58) ; CS181.2 17.11,134.31 17.76,134.96 v1(17.93,134.96) ; v1(148.09,76.1) 148.41,76.1 CD1.2 ; PR107.1 v3(214.98,181.04) ; v1(131.23,206.22) 131.23,206.59 C75.1 ; CK20.2 v1(48.93,205.87) ; PC347.2 50.83,62.29 v1(50.83,61.98) ; CS217.2 95.22,116.08 v1(95.57,116.43) ; v1(170.47,57.15) 170.72,57.15 171.41,56.46 C228.2 ; PC305.2 v1(23.25,44.17) ; C1764.1 v1(30.77,115.25) ; CK10.2 v1(50.2,201.17) ; EEPROM_G.7 v1(162.72,224.41) ; CS212.2 133.44,33.99 v1(133.05,34.38) ; v1(178.02,235.92) CO32.2 ; CA110.2 v1(209.14,15.76) ; CG18.1 v1(158.08,235.52) ; PR272.2 39.71,51.82 v1(39.2,52.32) ; RA6.2 v1(176.44,29.54) 176.25,29.35 CA75.2 ; v1(198.28,48.01) 198.71,47.57 RO45.2 ; C1689.1 42.39,124.65 v1(42.83,125.09) ; v3(218.41,180.97) PR113.1 ; CO18.2 v1(209.33,34.42) ; CK13.2 52.36,207.31 v1(51.87,207.8) ; v1(100.9,93.34) 100.43,93.34 C22.2 ; CF18.2 v1(35.72,102.11) ; C48.2 v1(161.07,84.92) ; v1(38.34,159.69) 38.48,159.55 CS206.2 ; CNO2.1 v1(175.55,229.04) ; CL57.2 v1(65.82,250.19) ; CX1.1 v1(52.23,252.6) ; PC197.2 106.71,136.65 v1(107.09,137.03) ; CO42.2 v1(108.87,38.61) ; PC100.2 211.74,185.93 v3(211.81,185.86) ; UU27.2 148.75,236.73 148.37,236.35 v1(148.37,235.97) ; CF104.2 v1(21.05,151.57) ; v1(217.46,69.16) 216.96,69.16 PR48.2 ; PC315.2 v1(111.49,29.59) ; PC43.2 v1(162.72,74.93) ; CU79.2 v1(156.47,11.57) ; PR92.2 v3(222.47,197.7) ; R17.1 119.8,208.14 v1(119.29,208.66) 118.79,208.16 R16.1 R15.1 R30.1 116.88,208.4 v1(116.49,208.79) 115.99,208.29 R31.1 ; CS112.2 v1(114.46,134.75) ; v1(55.93,80.71) CS191.2 ; v1(103.07,236.28) 103.04,236.25 CL23.2 ; PC341.2 v1(7.78,41.78) ; RO52.2 v1(12.86,70.89) ; R6531.2 v1(228.13,50.16) ; QV22.S v1(217.47,247.01) ; RU29.2 v1(131.48,227.01) ; CPU.AY3 148.39,129.37 v1(148.39,128.91) ; CK12.2 v1(69.88,199.39) ; CK62.2 v1(26.89,246.32) ; C50.2 v1(182.14,84.98) ; v1(104.05,145.03) 104.43,145.03 PC196.2 ; RS124.2 v1(58.96,105.66) ; PR34.2 v1(230.54,56.45) ; CK19.2 v1(49.94,205.87) ; CF22.1 v1(37.5,99.38) ; v1(160.82,50.8) CA111.2 ; PR267.2 v1(48.29,45.34) ; C2.2 v1(168.3,84.98) ; CO9.1 v1(228.13,43.18) ; CU2.2 v1(143.92,249.43) ; RO176.2 v1(228.13,45.47) ; CA126.2 v1(237.78,41.53) ; DG6.1 v1(158.59,231.71) ; C410.2 v1(151.04,234.19) ; C19.1 v1(149.13,95.38) ; CK33.2 v1(47.47,166.94) ; PC322.2 v1(46.52,31.12) ; RH3.1 v1(137.19,177.55) ; CO1.1 v1(217.01,33.97) ; v1(147.57,63.42) 147.57,62.84 CS213.2 ; RA35.2 201.58,16.21 v1(201.07,15.7) ; PC45.2 v1(161.2,74.93) ; QM1.E v1(99.63,140.53) ; v3(164.75,223.14) EEPROM_G.1 ; CK27.2 v1(27.97,167) ; CK67.2 v1(28.74,223.9) ; PR11.2 v1(42.97,147.5) ; CK23.1 v1(60.74,209.8) ; PR115.1 v3(219.55,180.97) ; C62.2 v1(155.25,84.56) ; CF6.2 v1(222.07,231.78) ; R6605.1 v1(57.44,105.66) ; PC340.2 v1(8.29,40.64) ; v1(169.83,228.73) DG2.1 ; PR233.2 v1(23.25,43.15) ; RO57.2 v1(211.68,62.04) ; CF11.1 v1(40.6,98.48) ; v1(152.59,25.58) RU135.2 ; CX54.2 v1(67.75,228.85) ; PC38.2 v1(168.05,75.18) ; PR55.2 v1(159.55,68.83) ; C1647.2 40.48,121.98 v1(40.74,122.24) ; CL58.2 v1(72.04,251.59) ; R106.2 v1(227.13,74.99) ; v1(215.49,30.16) RO5.2 215.25,31.36 CO11.2 ; CB5.2 v1(7.53,118.36) ; CX55.2 v1(67.75,230.12) ; CK30.2 v1(34.96,164.4) ; C9.1 v1(152.18,96.65) ; 27.47,209.93 v1(27.47,209.17) ; PQ55.S1 v1(117.13,39.24)
  L3_GND w0.102: 63.53,173.48 63.79,173.48 ; 63.53,173.48 63.15,173.48 ; 63.53,173.48 63.41,173.35
  L3_GND w0.508: LPC_DEBUG.14 9.91,144.92 ; LPC_DEBUG.14 10.75,144.08 ; LPC_DEBUG.14 9.07,144.08 ; LPC_DEBUG.14 9.91,143.24 ; WF_BT_USB.7 52.24,81.37 ; WF_BT_USB.7 51.29,80.43 ; WF_BT_USB.7 53.18,80.43 ; WF_BT_USB.7 52.24,79.49 ; 139.21,68.91 SATA1.4 ; SATA1.4 140.59,68.91 ; SATA1.4 139.9,69.6 ; SATA1.4 139.9,68.22 ; ECU13.2 99.28,252.15 ; ECU13.2 99.28,250.52 ; ECU13.2 100.09,251.33 ; 109,243.33 NIC_USB.8 ; NIC_USB.8 109.86,244.19 ; NIC_USB.8 109,245.06 ; NIC_USB.8 108.13,244.19 ; NIC_USB.24 105.95,245.49 ; NIC_USB.24 105.95,242.19 ; NIC_USB.24 104.3,243.84 ; NIC_USB.24 107.6,243.84 ; 117.4,243.84 NIC_USB.28 ; NIC_USB.28 119.06,245.49 ; NIC_USB.28 120.71,243.84 ; NIC_USB.28 119.06,242.19 ; 195.1,49.32 BATTERY.2 ; BATTERY.2 196.19,50.41 ; BATTERY.2 194.01,50.41 ; BATTERY.2 195.1,51.5 ; NIC_USB.27 123.5,241.2 ; NIC_USB.27 120.2,241.2 ; NIC_USB.27 121.85,242.85 ; NIC_USB.27 121.85,239.54 ; 145.05,68.91 SATA1.8 ; SATA1.8 146.17,67.79 ; SATA1.8 147.29,68.91 ; SATA1.8 146.17,70.03 ; LPC_DEBUG.12 10.75,146.08 ; LPC_DEBUG.12 9.91,145.24 ; LPC_DEBUG.12 9.91,146.92 ; LPC_DEBUG.12 9.07,146.08 ; 6.76,195.96 7.65,195.96 ; 7.65,195.96 7.65,196.85 ; 7.65,195.96 8.54,195.96 ; 7.65,195.96 7.65,195.07 ; SATA1.7 136.78,68.91 ; SATA1.7 135.4,68.91 ; SATA1.7 136.09,69.6 ; SATA1.7 136.09,68.22 ; 7.65,198.5 7.65,199.39 ; 7.65,198.5 7.65,197.61 ; 7.65,198.5 6.76,198.5 ; 7.65,198.5 8.54,198.5 ; 108.13,246.81 NIC_USB.4 ; NIC_USB.4 109,245.95 ; NIC_USB.4 109.86,246.81 ; NIC_USB.4 109,247.68 ; 103.16,237.82 NIC_USB.23 ; NIC_USB.23 104.81,239.47 ; NIC_USB.23 103.16,241.12 ; NIC_USB.23 101.5,239.47 ; 7.65,193.42 7.65,194.31 ; 7.65,193.42 8.54,193.42 ; 7.65,193.42 7.65,192.53 ; 7.65,193.42 6.76,193.42 ; 138.72,230.76 ECU2.2 ; ECU2.2 139.54,231.57 ; ECU2.2 140.35,230.76 ; ECU2.2 139.54,229.95 ; NIC_USB.29 120.71,249.53 ; NIC_USB.29 119.06,247.88 ; NIC_USB.29 119.06,251.18 ; NIC_USB.29 117.4,249.53 ; 7.65,200.15 7.65,201.04 ; 7.65,201.04 7.65,201.93 ; 7.65,201.04 6.76,201.04 ; 7.65,201.04 8.54,201.04 ; 133.34,68.79 SATA1.9 ; SATA1.9 133.34,71.03 ; SATA1.9 132.22,69.91 ; SATA1.9 134.46,69.91 ; 103.16,250.49 NIC_USB.26 ; NIC_USB.26 103.16,253.79 ; NIC_USB.26 101.5,252.14 ; NIC_USB.26 104.81,252.14 ; NIC_USB.25 107.6,249.53 ; NIC_USB.25 104.3,249.53 ; NIC_USB.25 105.95,251.18 ; NIC_USB.25 105.95,247.88 ; SATA1.1 143.71,69.6 ; SATA1.1 143.71,68.22 ; SATA1.1 144.4,68.91 ; SATA1.1 143.02,68.91 ; 159.47,53.29 INT_SPKR.4 ; INT_SPKR.4 161.05,53.29 ; INT_SPKR.4 160.26,52.5 ; 48.75,80.43 WF_BT_USB.8 ; WF_BT_USB.8 50.64,80.43 ; WF_BT_USB.8 49.7,79.49 ; WF_BT_USB.8 49.7,81.37 ; 120.2,252.14 NIC_USB.30 ; NIC_USB.30 121.85,250.49 ; NIC_USB.30 123.5,252.14 ; NIC_USB.30 121.85,253.79
  L3_GND w0.762: 151.92,205.99 PC179.2 ; PC179.2 152.79,205.13 ; PC179.2 152.79,206.86 ; PC179.2 153.65,205.99 ; 177.07,213.74 PCE13.2 ; PCE13.2 177.93,214.61 ; PCE13.2 178.8,213.74 ; PCE13.2 177.93,212.88
  L3_GND w0.889: PCE27.2 151.88,179.58 ; PCE27.2 151.02,178.71 ; PCE27.2 151.02,180.44 ; PCE17.2 176.52,179.32 ; PCE17.2 175.65,178.46 ; PCE17.2 175.65,180.19 ; 209.18,163.98 PCE22.2 ; PCE22.2 210.05,164.85 ; PCE22.2 209.18,165.71 ; 188.1,182.52 PCE15.2 ; PCE15.2 188.1,184.25 ; PCE15.2 188.96,183.39 ; PCE25.2 210.05,151.13 ; PCE25.2 209.18,150.27 ; PCE25.2 209.18,151.99 ; 41.21,39.52 PCE34.2 ; PCE34.2 42.07,40.39 ; PCE34.2 42.07,38.66 ; PCE34.2 42.93,39.52 ; PCE16.2 166.1,179.32 ; PCE16.2 165.24,180.19 ; PCE16.2 165.24,178.46 ; PCE2.2 168.52,70.36 ; PCE2.2 167.65,71.22 ; PCE2.2 167.65,69.49 ; 173.77,62.74 PCE1.2 ; PCE1.2 175.49,62.74 ; PCE1.2 174.63,63.6 ; PCE1.2 174.63,61.87 ; PCE12.2 192.39,216.92 ; PCE12.2 191.52,217.78 ; PCE12.2 191.52,216.05 ; PCE12.2 190.66,216.92 ; PCE19.2 183.38,179.32 ; PCE19.2 182.51,178.46 ; PCE19.2 182.51,180.19 ; PCE23.2 209.18,172.57 ; PCE23.2 208.32,171.7 ; PCE23.2 210.05,171.7 ; PCE23.2 209.18,170.84 ; PCE14.2 231.78,177.27 ; PCE14.2 232.64,176.4 ; PCE14.2 230.92,176.4 ; PCE14.2 231.78,175.54 ; PCE3.2 175.5,70.48 ; PCE3.2 174.64,69.62 ; PCE3.2 174.64,71.35 ; PCE26.2 146.55,185.55 ; PCE26.2 145.68,184.68 ; PCE26.2 145.68,186.41 ; PCE21.2 210.05,144.02 ; PCE21.2 209.18,144.88 ; PCE21.2 209.18,143.15 ; PCE18.2 170.57,184.76 ; PCE18.2 171.44,183.9 ; PCE18.2 170.57,183.03 ; 209.18,157.12 PCE24.2 ; PCE24.2 209.18,158.85 ; PCE24.2 210.05,157.99 ; PCE4.2 182.61,70.48 ; PCE4.2 181.75,71.35 ; PCE4.2 181.75,69.62 ; 17.69,40.35 PCE30.2 ; PCE30.2 16.87,41.17 ; PCE30.2 18.5,41.17 ; PCE30.2 17.69,41.98
  L3_GND w1.27: 24.55,35.4 ATX_SYS.7 ; ATX_SYS.7 26.81,35.4 ; ATX_SYS.7 25.68,36.53 ; ATX_SYS.7 25.68,34.27 ; ATX_SYS.3 26.81,29.9 ; ATX_SYS.3 25.68,31.03 ; ATX_SYS.3 25.68,28.77 ; ATX_SYS.3 24.55,29.9 ; 223.83,203 ATX_CPU.1 ; ATX_CPU.1 222.68,204.15 ; ATX_CPU.1 224.97,204.15 ; ATX_CPU.1 223.83,205.29 ; ATX_SYS.2 29.88,31.03 ; ATX_SYS.2 28.75,29.9 ; ATX_SYS.2 29.88,28.77 ; ATX_SYS.2 31.01,29.9 ; SATA_PWR.3 95.96,42.2 ; SATA_PWR.3 97.09,41.07 ; SATA_PWR.3 94.83,41.07 ; SATA_PWR.3 95.96,39.93 ; 222.68,208.35 ATX_CPU.2 ; ATX_CPU.2 223.83,207.2 ; ATX_CPU.2 223.83,209.49 ; ATX_CPU.2 224.97,208.35 ; SATA_PWR.1 105.49,41.07 ; SATA_PWR.1 103.23,41.07 ; SATA_PWR.1 104.36,42.2 ; SATA_PWR.1 104.36,39.93
  BOTTOM w0.102: v1(70.52,83.57) v2(69.63,83.57) ; v2(100.97,248.03) 100.59,247.65 v1(100.59,247.29) ; v2(65.23,82.45) 65.46,82.68 v1(66.2,82.68) ; v2(230.46,170.79) 230.67,170.59 v1(231.3,170.59) ; v1(154.47,177.29) v2(155.02,177.85) ; v2(217.58,155.85) 217.58,155.19 v1(217.71,155.07) ; v1(115.86,209.98) 115.5,209.63 v2(115.12,209.63) ; v1(139.72,198.06) 140.58,198.06 v2(140.67,197.97) ; v2(238.16,121.18) 238.16,120.52 v1(237.89,120.25) ; v2(47.23,167.84) 47.23,167.18 v1(47.47,166.94) ; v2(38.79,134.11) 38.9,134.01 v1(38.9,133.22) ; v2(210.68,199.11) 210.9,198.88 v1(211.74,198.88) ; v2(202.32,72.67) 202.6,72.39 v1(203.49,72.39) ; v1(98.81,229.51) 99.07,229.26 v2(99.07,228.78) ; v1(231.17,244.42) 230.92,244.68 v2(230.92,245.36) ; v2(54.52,234.59) 55.3,234.59 v1(55.41,234.7) ; v2(117.05,191.9) 117.38,191.57 v3(117.86,191.57) ; v2(48.78,246.28) 48.93,246.13 v1(48.93,245.49) ; v2(23.02,156.29) v1(23.02,157.23) ; v2(70.14,92.46) 70.65,92.46 70.87,92.23 v1(71.33,92.23) ; v2(229.17,162.03) 229.27,161.93 v1(229.27,160.91) ; v1(131.48,227.01) 131.34,227.15 v2(130.59,227.15)
  BOTTOM w0.254: 165.9,233.55 168.69,233.55 ; 165.9,233.55 165.85,233.5 v3(165.85,232.92) 164.7,231.78 164.24,231.78 162.97,230.5 160.34,230.5 156.91,227.08 v1(156.62,227.08) 156.5,227.08 ; 165.9,233.55 163.35,233.55 163.05,233.25 v3(163.05,232.92) 163.05,232.11 162.21,231.27 160.02,231.27 157.29,228.54 v1(156.62,228.54) 156.12,228.03 156.12,227.46 156.5,227.08 ; 168.69,233.55 168.64,233.5 v1(168.64,232.92) 166.23,230.5 164.34,230.5 163.58,229.74 160.82,229.74 156.5,225.43 v1(156.5,225.17) ; 168.69,233.55 170.09,233.55 170.34,233.3 v3(170.34,232.92) 170.34,232.66 166.78,229.11 v1(166.4,229.11) 166.02,228.73 v3(162.97,228.73) v1(161.07,228.73) 157.77,225.43 v1(157.77,225.17) 157.77,224.84 157.41,224.49 156.8,224.49 156.5,224.79 v1(156.5,225.17) ; v1(156.5,225.17) 155.99,225.68 155.99,226.57 156.5,227.08
  BOTTOM w0.406: v3(175.18,155.57) 174.62,155.02 R6638.1 ; v1(176.06,142.37) 176.23,142.19 R6641.1 ; R6639.2 v3(176.27,141.4)
  BOTTOM w0.508: 121.94,87.19 DIMM1.259 ; DIMM1.259 121.21,87.92 ; DIMM1.259 121.94,88.66 ; DIMM1.259 122.68,87.92 ; 219.69,80.38 DIMM2.6 ; DIMM2.6 220.43,81.12 ; DIMM2.6 218.96,81.12 ; DIMM2.6 219.69,81.85 ; 107.61,82.72 DIMM2.131 ; DIMM2.131 108.34,81.98 ; DIMM2.131 108.34,83.45 ; DIMM2.131 109.08,82.72 ; DIMM2.156 214.59,78.05 ; DIMM2.156 213.86,77.32 ; DIMM2.156 215.33,77.32 ; 195.16,77.32 DIMM2.178 ; DIMM2.178 196.63,77.32 ; DIMM2.178 195.89,78.05 ; 183.26,90.12 DIMM1.48 ; DIMM1.48 183.99,89.39 ; DIMM1.48 184.73,90.12 ; DIMM1.48 183.99,90.86 ; DIMM1.165 207.68,87.92 ; DIMM1.165 206.94,88.66 ; DIMM1.165 206.21,87.92 ; DIMM1.165 206.94,87.19 ; DIMM1.147 222.24,88.66 ; DIMM1.147 221.51,87.92 ; DIMM1.147 222.98,87.92 ; DIMM1.147 222.24,87.19 ; 122.06,90.12 DIMM1.114 ; DIMM1.114 122.79,89.39 ; DIMM1.114 123.53,90.12 ; DIMM1.114 122.79,90.86 ; 204.51,87.92 DIMM1.167 ; DIMM1.167 205.24,87.19 ; DIMM1.167 205.24,88.66 ; DIMM1.167 205.98,87.92 ; DIMM2.46 185.69,81.85 ; DIMM2.46 186.43,81.12 ; DIMM2.46 184.96,81.12 ; DIMM2.46 185.69,80.38 ; 128.01,91.72 DIMM1.107 ; DIMM1.107 128.74,92.46 ; DIMM1.107 128.74,90.99 ; DIMM1.107 129.48,91.72 ; DIMM2.149 221.28,78.92 ; DIMM2.149 219.81,78.92 ; DIMM2.149 220.54,78.18 ; DIMM2.149 220.54,79.65 ; DIMM2.171 201.84,79.65 ; DIMM2.171 201.11,78.92 ; DIMM2.171 201.84,78.18 ; DIMM2.171 202.58,78.92 ; 203.66,81.12 DIMM2.24 ; DIMM2.24 204.39,80.38 ; DIMM2.24 205.13,81.12 ; DIMM2.24 204.39,81.85 ; DIMM1.96 138.09,90.86 ; DIMM1.96 137.36,90.12 ; DIMM1.96 138.09,89.39 ; DIMM1.96 138.83,90.12 ; DIMM1.156 215.33,86.32 ; DIMM1.156 213.86,86.32 ; DIMM1.156 214.59,85.59 ; DIMM1.156 214.59,87.06 ; DIMM1.191 184.84,88.66 ; DIMM1.191 184.84,87.19 ; DIMM1.191 184.11,87.92 ; DIMM1.191 185.58,87.92 ; 213.74,90.99 DIMM1.13 ; DIMM1.13 214.48,91.72 ; DIMM1.13 213.74,92.46 ; DIMM1.13 213.01,91.72 ; 221.39,80.38 DIMM2.4 ; DIMM2.4 220.66,81.12 ; DIMM2.4 222.13,81.12 ; DIMM2.4 221.39,81.85 ; DIMM2.50 182.29,81.85 ; DIMM2.50 183.03,81.12 ; DIMM2.50 182.29,80.38 ; DIMM2.50 181.56,81.12 ; DIMM2.94 140.53,81.12 ; DIMM2.94 139.79,81.85 ; DIMM2.94 139.06,81.12 ; DIMM2.94 139.79,80.38 ; 195.89,85.59 DIMM1.178 ; DIMM1.178 196.63,86.32 ; DIMM1.178 195.89,87.06 ; DIMM1.178 195.16,86.32 ; DIMM1.4 221.39,90.86 ; DIMM1.4 220.66,90.12 ; DIMM1.4 222.13,90.12 ; DIMM1.4 221.39,89.39 ; DIMM1.26 203.43,90.12 ; DIMM1.26 202.69,90.86 ; DIMM1.26 202.69,89.39 ; DIMM1.26 201.96,90.12 ; 186.54,87.19 DIMM1.189 ; DIMM1.189 185.81,87.92 ; DIMM1.189 186.54,88.66 ; DIMM1.189 187.28,87.92 ; 197.71,91.72 DIMM1.31 ; DIMM1.31 199.18,91.72 ; DIMM1.31 198.44,90.99 ; DIMM1.31 198.44,92.46 ; DIMM2.279 104.94,79.65 ; DIMM2.279 104.94,78.18 ; DIMM2.279 104.21,78.92 ; DIMM2.279 105.68,78.92 ; 205.36,90.12 DIMM1.22 ; DIMM1.22 206.83,90.12 ; DIMM1.22 206.09,89.39 ; DIMM1.22 206.09,90.86 ; 191.64,81.98 DIMM2.39 ; DIMM2.39 190.91,82.72 ; DIMM2.39 191.64,83.45 ; DIMM2.39 192.38,82.72 ; DIMM2.109 127.04,83.45 ; DIMM2.109 126.31,82.72 ; DIMM2.109 127.78,82.72 ; DIMM2.109 127.04,81.98 ; DIMM1.268 114.29,87.06 ; DIMM1.268 113.56,86.32 ; DIMM1.268 115.03,86.32 ; DIMM1.268 114.29,85.59 ; 116.96,81.12 DIMM2.120 ; DIMM2.120 117.69,80.38 ; DIMM2.120 118.43,81.12 ; DIMM2.120 117.69,81.85 ; DIMM2.53 180.48,82.72 ; DIMM2.53 179.74,81.98 ; DIMM2.53 179.01,82.72 ; DIMM2.53 179.74,83.45 ; DIMM1.151 218.84,88.66 ; DIMM1.151 218.11,87.92 ; DIMM1.151 218.84,87.19 ; DIMM1.151 219.58,87.92 ; DIMM2.37 193.34,83.45 ; DIMM2.37 192.61,82.72 ; DIMM2.37 193.34,81.98 ; DIMM2.37 194.08,82.72 ; 210.46,86.32 DIMM1.160 ; DIMM1.160 211.19,85.59 ; DIMM1.160 211.93,86.32 ; DIMM1.160 211.19,87.06 ; 212.89,85.59 DIMM1.158 ; DIMM1.158 213.63,86.32 ; DIMM1.158 212.89,87.06 ; DIMM1.158 212.16,86.32 ; 200.26,81.12 DIMM2.28 ; DIMM2.28 200.99,80.38 ; DIMM2.28 201.73,81.12 ; DIMM2.28 200.99,81.85 ; DIMM1.281 103.98,87.92 ; DIMM1.281 103.24,88.66 ; DIMM1.281 102.51,87.92 ; DIMM1.281 103.24,87.19 ; DIMM1.127 112.48,91.72 ; DIMM1.127 111.74,90.99 ; DIMM1.127 111.01,91.72 ; DIMM1.127 111.74,92.46 ; DIMM1.44 187.39,90.86 ; DIMM1.44 187.39,89.39 ; DIMM1.44 188.13,90.12 ; DIMM1.44 186.66,90.12 ; DIMM1.198 179.63,86.32 ; DIMM1.198 178.89,87.06 ; DIMM1.198 178.16,86.32 ; DIMM1.198 178.89,85.59 ; 193.46,86.32 DIMM1.180 ; DIMM1.180 194.19,87.06 ; DIMM1.180 194.19,85.59 ; DIMM1.180 194.93,86.32 ; DIMM1.274 109.93,86.32 ; DIMM1.274 108.46,86.32 ; DIMM1.274 109.19,85.59 ; DIMM1.274 109.19,87.06 ; 204.39,89.39 DIMM1.24 ; DIMM1.24 205.13,90.12 ; DIMM1.24 203.66,90.12 ; DIMM1.24 204.39,90.86 ; 191.64,90.99 DIMM1.39 ; DIMM1.39 192.38,91.72 ; DIMM1.39 190.91,91.72 ; DIMM1.39 191.64,92.46 ; 219.81,87.92 DIMM1.149 ; DIMM1.149 220.54,87.19 ; DIMM1.149 220.54,88.66 ; DIMM1.149 221.28,87.92 ; DIMM1.248 132.03,86.32 ; DIMM1.248 131.29,85.59 ; DIMM1.248 130.56,86.32 ; DIMM1.248 131.29,87.06 ; 175.61,82.72 DIMM2.57 ; DIMM2.57 176.34,81.98 ; DIMM2.57 177.08,82.72 ; DIMM2.57 176.34,83.45 ; 134.81,78.92 DIMM2.243 ; DIMM2.243 136.28,78.92 ; DIMM2.243 135.54,78.18 ; DIMM2.243 135.54,79.65 ; 212.04,90.99 DIMM1.15 ; DIMM1.15 211.31,91.72 ; DIMM1.15 212.04,92.46 ; DIMM1.15 212.78,91.72 ; 218.11,78.92 DIMM2.151 ; DIMM2.151 219.58,78.92 ; DIMM2.151 218.84,78.18 ; DIMM2.151 218.84,79.65 ; DIMM1.246 132.99,87.06 ; DIMM1.246 133.73,86.32 ; DIMM1.246 132.99,85.59 ; DIMM1.246 132.26,86.32 ; 185.69,89.39 DIMM1.46 ; DIMM1.46 185.69,90.86 ; DIMM1.46 184.96,90.12 ; DIMM1.46 186.43,90.12 ; 181.44,78.18 DIMM2.195 ; DIMM2.195 180.71,78.92 ; DIMM2.195 182.18,78.92 ; DIMM2.195 181.44,79.65 ; DIMM1.20 208.53,90.12 ; DIMM1.20 207.06,90.12 ; DIMM1.20 207.79,90.86 ; DIMM1.20 207.79,89.39 ; DIMM2.254 126.19,78.05 ; DIMM2.254 125.46,77.32 ; DIMM2.254 126.19,76.58 ; DIMM2.254 126.93,77.32 ; DIMM1.53 179.74,92.46 ; DIMM1.53 179.74,90.99 ; DIMM1.53 180.48,91.72 ; DIMM1.53 179.01,91.72 ; 137.24,78.18 DIMM2.241 ; DIMM2.241 137.98,78.92 ; DIMM2.241 136.51,78.92 ; DIMM2.241 137.24,79.65 ; 116.84,78.18 DIMM2.265 ; DIMM2.265 117.58,78.92 ; DIMM2.265 116.84,79.65 ; DIMM2.265 116.11,78.92 ; 118.66,90.12 DIMM1.118 ; DIMM1.118 119.39,90.86 ; DIMM1.118 120.13,90.12 ; DIMM1.118 119.39,89.39 ; DIMM2.239 139.68,78.92 ; DIMM2.239 138.94,79.65 ; DIMM2.239 138.94,78.18 ; DIMM2.239 138.21,78.92 ; DIMM2.129 110.78,82.72 ; DIMM2.129 110.04,83.45 ; DIMM2.129 109.31,82.72 ; DIMM2.129 110.04,81.98 ; 101.43,90.12 DIMM1.140 100.69,89.39 ; DIMM2.176 197.59,78.05 ; DIMM2.176 196.86,77.32 ; DIMM2.176 198.33,77.32 ; DIMM2.257 124.38,78.92 ; DIMM2.257 123.64,79.65 ; DIMM2.257 122.91,78.92 ; DIMM2.257 123.64,78.18 ; 108.46,77.32 DIMM2.274 ; DIMM2.274 109.19,78.05 ; DIMM2.274 109.93,77.32 ; 174.76,86.32 DIMM1.202 ; DIMM1.202 175.49,85.59 ; DIMM1.202 175.49,87.06 ; DIMM1.202 176.23,86.32 ; DIMM2.180 194.19,78.05 ; DIMM2.180 194.93,77.32 ; DIMM2.180 193.46,77.32 ; DIMM2.187 188.98,78.92 ; DIMM2.187 188.24,78.18 ; DIMM2.187 187.51,78.92 ; DIMM2.187 188.24,79.65 ; 215.44,90.99 DIMM1.11 ; DIMM1.11 216.18,91.72 ; DIMM1.11 215.44,92.46 ; DIMM1.11 214.71,91.72 ; DIMM1.250 129.59,87.06 ; DIMM1.250 130.33,86.32 ; DIMM1.250 129.59,85.59 ; DIMM1.250 128.86,86.32 ; 205.24,78.18 DIMM2.167 ; DIMM2.167 205.24,79.65 ; DIMM2.167 204.51,78.92 ; DIMM2.167 205.98,78.92 ; 189.09,80.38 DIMM2.42 ; DIMM2.42 189.09,81.85 ; DIMM2.42 188.36,81.12 ; DIMM2.42 189.83,81.12 ; 178.16,77.32 DIMM2.198 ; DIMM2.198 178.89,78.05 ; DIMM2.198 179.63,77.32 ; 133.11,82.72 DIMM2.101 ; DIMM2.101 134.58,82.72 ; DIMM2.101 133.84,83.45 ; DIMM2.101 133.84,81.98 ; 127.04,90.99 DIMM1.109 ; DIMM1.109 127.04,92.46 ; DIMM1.109 126.31,91.72 ; DIMM1.109 127.78,91.72 ; DIMM1.252 127.89,87.06 ; DIMM1.252 127.16,86.32 ; DIMM1.252 128.63,86.32 ; DIMM1.252 127.89,85.59 ; 187.39,80.38 DIMM2.44 ; DIMM2.44 188.13,81.12 ; DIMM2.44 186.66,81.12 ; DIMM2.44 187.39,81.85 ; DIMM1.261 120.98,87.92 ; DIMM1.261 120.24,87.19 ; DIMM1.261 120.24,88.66 ; DIMM1.261 119.51,87.92 ; DIMM1.101 133.84,92.46 ; DIMM1.101 134.58,91.72 ; DIMM1.101 133.11,91.72 ; DIMM1.101 133.84,90.99 ; 190.79,85.59 DIMM1.184 ; DIMM1.184 190.79,87.06 ; DIMM1.184 191.53,86.32 ; DIMM1.184 190.06,86.32 ; DIMM1.243 136.28,87.92 ; DIMM1.243 135.54,88.66 ; DIMM1.243 134.81,87.92 ; DIMM1.243 135.54,87.19 ; 184.11,78.92 DIMM2.191 ; DIMM2.191 184.84,78.18 ; DIMM2.191 185.58,78.92 ; DIMM2.191 184.84,79.65 ; 120.24,78.18 DIMM2.261 ; DIMM2.261 120.98,78.92 ; DIMM2.261 119.51,78.92 ; DIMM2.261 120.24,79.65 ; 115.14,81.98 DIMM2.123 ; DIMM2.123 114.41,82.72 ; DIMM2.123 115.88,82.72 ; DIMM2.123 115.14,83.45 ; 185.81,78.92 DIMM2.189 ; DIMM2.189 186.54,78.18 ; DIMM2.189 187.28,78.92 ; DIMM2.189 186.54,79.65 ; 107.61,91.72 DIMM1.131 ; DIMM1.131 108.34,90.99 ; DIMM1.131 108.34,92.46 ; DIMM1.131 109.08,91.72 ; DIMM2.33 196.74,83.45 ; DIMM2.33 197.48,82.72 ; DIMM2.33 196.01,82.72 ; DIMM2.33 196.74,81.98 ; DIMM2.96 138.09,81.85 ; DIMM2.96 138.09,80.38 ; DIMM2.96 138.83,81.12 ; DIMM2.96 137.36,81.12 ; 135.66,81.12 DIMM2.98 ; DIMM2.98 136.39,81.85 ; DIMM2.98 136.39,80.38 ; DIMM2.98 137.13,81.12 ; 201.84,87.19 DIMM1.171 ; DIMM1.171 201.11,87.92 ; DIMM1.171 201.84,88.66 ; DIMM1.171 202.58,87.92 ; 104.09,80.38 DIMM2.136 ; DIMM2.136 104.83,81.12 ; DIMM2.136 104.09,81.85 ; DIMM2.136 103.36,81.12 ; DIMM1.125 113.44,92.46 ; DIMM1.125 112.71,91.72 ; DIMM1.125 113.44,90.99 ; DIMM1.125 114.18,91.72 ; DIMM2.11 216.18,82.72 ; DIMM2.11 215.44,81.98 ; DIMM2.11 215.44,83.45 ; DIMM2.11 214.71,82.72 ; 118.54,87.19 DIMM1.263 ; DIMM1.263 119.28,87.92 ; DIMM1.263 117.81,87.92 ; DIMM1.263 118.54,88.66 ; 110.16,86.32 DIMM1.272 ; DIMM1.272 111.63,86.32 ; DIMM1.272 110.89,85.59 ; DIMM1.272 110.89,87.06 ; DIMM1.154 217.03,86.32 ; DIMM1.154 216.29,87.06 ; DIMM1.154 215.56,86.32 ; DIMM1.154 216.29,85.59 ; 200.99,89.39 DIMM1.28 ; DIMM1.28 200.26,90.12 ; DIMM1.28 200.99,90.86 ; DIMM1.28 201.73,90.12 ; 111.86,77.32 DIMM2.270 ; DIMM2.270 112.59,78.05 ; DIMM2.270 113.33,77.32 ; 209.61,91.72 DIMM1.17 ; DIMM1.17 211.08,91.72 ; DIMM1.17 210.34,92.46 ; DIMM1.17 210.34,90.99 ; 208.76,77.32 DIMM2.162 ; DIMM2.162 210.23,77.32 ; DIMM2.162 209.49,78.05 ; DIMM1.254 126.93,86.32 ; DIMM1.254 126.19,85.59 ; DIMM1.254 126.19,87.06 ; DIMM1.254 125.46,86.32 ; DIMM2.20 208.53,81.12 ; DIMM2.20 207.06,81.12 ; DIMM2.20 207.79,81.85 ; DIMM2.20 207.79,80.38 ; DIMM2.281 103.24,79.65 ; DIMM2.281 103.24,78.18 ; DIMM2.281 102.51,78.92 ; DIMM2.281 103.98,78.92 ; DIMM2.118 120.13,81.12 ; DIMM2.118 119.39,81.85 ; DIMM2.118 119.39,80.38 ; DIMM2.118 118.66,81.12 ; DIMM2.35 195.78,82.72 ; DIMM2.35 195.04,81.98 ; DIMM2.35 195.04,83.45 ; DIMM2.35 194.31,82.72 ; DIMM2.200 177.19,78.05 ; DIMM2.200 176.46,77.32 ; DIMM2.200 177.93,77.32 ; DIMM2.105 131.18,82.72 ; DIMM2.105 130.44,81.98 ; DIMM2.105 130.44,83.45 ; DIMM2.105 129.71,82.72 ; 217.14,90.99 DIMM1.9 ; DIMM1.9 216.41,91.72 ; DIMM1.9 217.88,91.72 ; DIMM1.9 217.14,92.46 ; 101.54,81.98 DIMM2.139 ; DIMM2.139 101.54,83.45 ; DIMM2.139 102.28,82.72 ; 222.24,78.18 DIMM2.147 ; DIMM2.147 222.24,79.65 ; DIMM2.147 222.98,78.92 ; DIMM2.147 221.51,78.92 ; DIMM1.279 105.68,87.92 ; DIMM1.279 104.21,87.92 ; DIMM1.279 104.94,88.66 ; DIMM1.279 104.94,87.19 ; DIMM2.248 131.29,78.05 ; DIMM2.248 130.56,77.32 ; DIMM2.248 132.03,77.32 ; DIMM2.248 131.29,76.58 ; DIMM2.259 122.68,78.92 ; DIMM2.259 121.94,78.18 ; DIMM2.259 121.21,78.92 ; DIMM2.259 121.94,79.65 ; 131.41,82.72 DIMM2.103 ; DIMM2.103 132.88,82.72 ; DIMM2.103 132.14,81.98 ; DIMM2.103 132.14,83.45 ; 121.09,89.39 DIMM1.116 ; DIMM1.116 120.36,90.12 ; DIMM1.116 121.83,90.12 ; DIMM1.116 121.09,90.86 ; DIMM2.238 140.53,77.32 ; DIMM2.238 139.79,76.58 ; DIMM2.238 139.79,78.05 ; DIMM2.238 139.06,77.32 ; DIMM2.158 213.63,77.32 ; DIMM2.158 212.16,77.32 ; DIMM2.158 212.89,78.05 ; DIMM1.187 188.98,87.92 ; DIMM1.187 188.24,88.66 ; DIMM1.187 188.24,87.19 ; DIMM1.187 187.51,87.92 ; DIMM2.15 212.04,83.45 ; DIMM2.15 212.04,81.98 ; DIMM2.15 211.31,82.72 ; DIMM2.15 212.78,82.72 ; 102.28,91.72 DIMM1.139 101.54,90.99 ; 131.41,91.72 DIMM1.103 ; DIMM1.103 132.88,91.72 ; DIMM1.103 132.14,92.46 ; DIMM1.103 132.14,90.99 ; DIMM1.42 189.83,90.12 ; DIMM1.42 189.09,89.39 ; DIMM1.42 188.36,90.12 ; DIMM1.42 189.09,90.86 ; DIMM1.37 194.08,91.72 ; DIMM1.37 192.61,91.72 ; DIMM1.37 193.34,90.99 ; DIMM1.37 193.34,92.46 ; 124.49,89.39 DIMM1.112 ; DIMM1.112 125.23,90.12 ; DIMM1.112 123.76,90.12 ; DIMM1.112 124.49,90.86 ; DIMM1.182 193.23,86.32 ; DIMM1.182 192.49,85.59 ; DIMM1.182 191.76,86.32 ; DIMM1.182 192.49,87.06 ; DIMM2.127 112.48,82.72 ; DIMM2.127 111.74,83.45 ; DIMM2.127 111.74,81.98 ; DIMM2.127 111.01,82.72 ; 109.31,91.72 DIMM1.129 ; DIMM1.129 110.04,90.99 ; DIMM1.129 110.04,92.46 ; DIMM1.129 110.78,91.72 ; DIMM1.193 183.88,87.92 ; DIMM1.193 182.41,87.92 ; DIMM1.193 183.14,87.19 ; DIMM1.193 183.14,88.66 ; DIMM2.272 110.89,78.05 ; DIMM2.272 110.16,77.32 ; DIMM2.272 111.63,77.32 ; DIMM1.241 137.98,87.92 ; DIMM1.241 137.24,87.19 ; DIMM1.241 137.24,88.66 ; DIMM1.241 136.51,87.92 ; 215.56,77.32 DIMM2.154 ; DIMM2.154 217.03,77.32 ; DIMM2.154 216.29,78.05 ; 116.96,90.12 DIMM1.120 ; DIMM1.120 118.43,90.12 ; DIMM1.120 117.69,89.39 ; DIMM1.120 117.69,90.86 ; 222.36,90.12 DIMM1.2 ; DIMM1.2 223.09,90.86 ; DIMM1.2 223.09,89.39 ; DIMM2.48 184.73,81.12 ; DIMM2.48 183.26,81.12 ; DIMM2.48 183.99,81.85 ; DIMM2.48 183.99,80.38 ; 194.31,91.72 DIMM1.35 ; DIMM1.35 195.78,91.72 ; DIMM1.35 195.04,92.46 ; DIMM1.35 195.04,90.99 ; DIMM2.134 105.79,81.85 ; DIMM2.134 105.79,80.38 ; DIMM2.134 105.06,81.12 ; DIMM2.134 106.53,81.12 ; DIMM1.162 210.23,86.32 ; DIMM1.162 209.49,85.59 ; DIMM1.162 209.49,87.06 ; DIMM1.162 208.76,86.32 ; DIMM1.55 178.78,91.72 ; DIMM1.55 177.31,91.72 ; DIMM1.55 178.04,92.46 ; DIMM1.55 178.04,90.99 ; DIMM1.123 115.14,92.46 ; DIMM1.123 115.88,91.72 ; DIMM1.123 114.41,91.72 ; DIMM1.123 115.14,90.99 ; 116.11,87.92 DIMM1.265 ; DIMM1.265 116.84,88.66 ; DIMM1.265 117.58,87.92 ; DIMM1.265 116.84,87.19 ; DIMM2.252 127.89,78.05 ; DIMM2.252 127.89,76.58 ; DIMM2.252 128.63,77.32 ; DIMM2.252 127.16,77.32 ; 106.76,77.32 DIMM2.276 ; DIMM2.276 107.49,78.05 ; DIMM2.276 108.23,77.32 ; DIMM2.169 203.54,79.65 ; DIMM2.169 204.28,78.92 ; DIMM2.169 202.81,78.92 ; DIMM2.169 203.54,78.18 ; DIMM2.112 124.49,81.85 ; DIMM2.112 123.76,81.12 ; DIMM2.112 125.23,81.12 ; DIMM2.112 124.49,80.38 ; 101.66,90.12 DIMM1.138 ; DIMM1.138 103.13,90.12 ; DIMM1.138 102.39,90.86 ; DIMM1.138 102.39,89.39 ; DIMM2.184 190.79,78.05 ; DIMM2.184 190.06,77.32 ; DIMM2.184 191.53,77.32 ; 178.04,81.98 DIMM2.55 ; DIMM2.55 177.31,82.72 ; DIMM2.55 178.04,83.45 ; DIMM2.55 178.78,82.72 ; 139.79,85.59 DIMM1.238 ; DIMM1.238 140.53,86.32 ; DIMM1.238 139.06,86.32 ; DIMM1.238 139.79,87.06 ; 177.19,85.59 DIMM1.200 ; DIMM1.200 176.46,86.32 ; DIMM1.200 177.93,86.32 ; DIMM1.200 177.19,87.06 ; 138.94,87.19 DIMM1.239 ; DIMM1.239 138.21,87.92 ; DIMM1.239 138.94,88.66 ; DIMM1.239 139.68,87.92 ; DIMM1.195 182.18,87.92 ; DIMM1.195 180.71,87.92 ; DIMM1.195 181.44,88.66 ; DIMM1.195 181.44,87.19 ; 103.36,90.12 DIMM1.136 ; DIMM1.136 104.09,89.39 ; DIMM1.136 104.09,90.86 ; DIMM1.136 104.83,90.12 ; DIMM1.283 101.54,88.66 ; DIMM1.283 102.28,87.92 ; DIMM1.283 101.54,87.19 ; 222.36,81.12 DIMM2.2 ; DIMM2.2 223.09,80.38 ; DIMM2.2 223.09,81.85 ; 196.01,91.72 DIMM1.33 ; DIMM1.33 197.48,91.72 ; DIMM1.33 196.74,92.46 ; DIMM1.33 196.74,90.99 ; 175.61,91.72 DIMM1.57 ; DIMM1.57 176.34,90.99 ; DIMM1.57 176.34,92.46 ; DIMM1.57 177.08,91.72 ; DIMM1.105 130.44,92.46 ; DIMM1.105 130.44,90.99 ; DIMM1.105 129.71,91.72 ; DIMM1.105 131.18,91.72 ; 113.44,81.98 DIMM2.125 ; DIMM2.125 114.18,82.72 ; DIMM2.125 113.44,83.45 ; DIMM2.125 112.71,82.72 ; DIMM1.98 137.13,90.12 ; DIMM1.98 136.39,89.39 ; DIMM1.98 135.66,90.12 ; DIMM1.98 136.39,90.86 ; DIMM2.202 175.49,78.05 ; DIMM2.202 176.23,77.32 ; DIMM2.202 174.76,77.32 ; DIMM2.268 114.29,78.05 ; DIMM2.268 115.03,77.32 ; DIMM2.268 113.56,77.32 ; 182.41,78.92 DIMM2.193 ; DIMM2.193 183.88,78.92 ; DIMM2.193 183.14,79.65 ; DIMM2.193 183.14,78.18 ; 198.44,81.98 DIMM2.31 ; DIMM2.31 198.44,83.45 ; DIMM2.31 197.71,82.72 ; DIMM2.31 199.18,82.72 ; DIMM1.6 219.69,90.86 ; DIMM1.6 220.43,90.12 ; DIMM1.6 219.69,89.39 ; DIMM1.6 218.96,90.12 ; 102.28,78.92 DIMM2.283 101.54,79.65 ; DIMM2.160 211.93,77.32 ; DIMM2.160 211.19,78.05 ; DIMM2.160 210.46,77.32 ; 205.36,81.12 DIMM2.22 ; DIMM2.22 206.83,81.12 ; DIMM2.22 206.09,81.85 ; DIMM2.22 206.09,80.38 ; DIMM2.107 129.48,82.72 ; DIMM2.107 128.74,81.98 ; DIMM2.107 128.74,83.45 ; DIMM2.107 128.01,82.72 ; 200.14,87.19 DIMM1.173 ; DIMM1.173 199.41,87.92 ; DIMM1.173 200.88,87.92 ; DIMM1.173 200.14,88.66 ; DIMM2.182 193.23,77.32 ; DIMM2.182 191.76,77.32 ; DIMM2.182 192.49,78.05 ; DIMM1.257 124.38,87.92 ; DIMM1.257 122.91,87.92 ; DIMM1.257 123.64,87.19 ; DIMM1.257 123.64,88.66 ; DIMM2.26 203.43,81.12 ; DIMM2.26 201.96,81.12 ; DIMM2.26 202.69,81.85 ; DIMM2.26 202.69,80.38 ; 202.81,87.92 DIMM1.169 ; DIMM1.169 204.28,87.92 ; DIMM1.169 203.54,87.19 ; DIMM1.169 203.54,88.66 ; DIMM2.246 132.99,78.05 ; DIMM2.246 132.99,76.58 ; DIMM2.246 132.26,77.32 ; DIMM2.246 133.73,77.32 ; 107.49,85.59 DIMM1.276 ; DIMM1.276 107.49,87.06 ; DIMM1.276 106.76,86.32 ; DIMM1.276 108.23,86.32 ; 120.36,81.12 DIMM2.116 ; DIMM2.116 121.09,80.38 ; DIMM2.116 121.09,81.85 ; DIMM2.116 121.83,81.12 ; 209.61,82.72 DIMM2.17 ; DIMM2.17 211.08,82.72 ; DIMM2.17 210.34,81.98 ; DIMM2.17 210.34,83.45 ; DIMM2.250 129.59,78.05 ; DIMM2.250 129.59,76.58 ; DIMM2.250 128.86,77.32 ; DIMM2.250 130.33,77.32 ; DIMM2.138 103.13,81.12 ; DIMM2.138 102.39,81.85 ; DIMM2.138 102.39,80.38 ; DIMM2.138 101.66,81.12 ; DIMM2.263 118.54,79.65 ; DIMM2.263 119.28,78.92 ; DIMM2.263 118.54,78.18 ; DIMM2.263 117.81,78.92 ; 112.59,85.59 DIMM1.270 ; DIMM1.270 113.33,86.32 ; DIMM1.270 112.59,87.06 ; DIMM1.270 111.86,86.32 ; DIMM2.114 122.79,81.85 ; DIMM2.114 123.53,81.12 ; DIMM2.114 122.79,80.38 ; DIMM2.114 122.06,81.12 ; DIMM2.165 207.68,78.92 ; DIMM2.165 206.21,78.92 ; DIMM2.165 206.94,79.65 ; DIMM2.165 206.94,78.18 ; 197.59,85.59 DIMM1.176 ; DIMM1.176 197.59,87.06 ; DIMM1.176 198.33,86.32 ; DIMM1.176 196.86,86.32 ; 213.74,81.98 DIMM2.13 ; DIMM2.13 213.74,83.45 ; DIMM2.13 214.48,82.72 ; DIMM2.13 213.01,82.72 ; 200.14,78.18 DIMM2.173 ; DIMM2.173 200.14,79.65 ; DIMM2.173 199.41,78.92 ; DIMM2.173 200.88,78.92 ; 216.41,82.72 DIMM2.9 ; DIMM2.9 217.14,83.45 ; DIMM2.9 217.14,81.98 ; DIMM2.9 217.88,82.72 ; 105.79,89.39 DIMM1.134 ; DIMM1.134 105.06,90.12 ; DIMM1.134 105.79,90.86 ; DIMM1.134 106.53,90.12 ; DIMM1.94 140.53,90.12 ; DIMM1.94 139.79,90.86 ; DIMM1.94 139.06,90.12 ; DIMM1.94 139.79,89.39 ; 181.56,90.12 DIMM1.50 ; DIMM1.50 182.29,89.39 ; DIMM1.50 182.29,90.86 ; DIMM1.50 183.03,90.12
  vias: v1(0.77,253.75) v1(0.77,248.67) v1(0.77,243.59) v1(0.77,238.51) v1(0.77,233.43) v1(0.77,228.35) v1(0.77,223.27) v1(0.77,218.19) v1(0.77,213.11) v1(0.77,208.03) v1(0.77,202.95) v1(0.77,197.87) v1(0.77,192.79) v1(0.77,187.71) v1(0.77,182.63) v1(0.77,177.55) v1(0.77,172.47) v1(0.77,167.39) v1(0.77,162.31) v1(0.77,157.23) v1(0.77,152.15) v1(0.77,147.07) v1(0.77,141.99) v1(0.77,136.91) v1(0.78,131.83) v1(0.77,126.75) v1(0.77,121.67) v1(0.77,116.59) v1(0.77,111.51) v1(0.77,106.43) v1(0.78,101.35) v1(0.77,96.27) v1(0.77,91.19) v1(0.77,86.11) v1(0.77,81.03) v1(0.77,75.95) v1(0.78,70.87) v1(0.77,65.79) v1(0.77,60.71) v1(0.77,55.63) v1(0.77,50.55) v1(0.77,45.47) v1(0.78,40.39) v1(0.77,35.31) v1(0.77,30.23) v1(3.97,258.06) v1(3.97,25.59) v1(5.88,212.22) v1(6.51,212.22) v1(7.02,231.39) v1(7.02,230.63) v1(7.02,229.87) v1(7.02,229.11) v1(7.02,228.35) v1(7.02,227.58) v1(7.02,226.82) v1(7.15,212.22) v1(7.53,182.37) v1(7.53,54.86) v1(8.29,54.86) v1(9.05,258.06) v1(9.05,25.59) v1(10.35,232.56) v1(11.97,76.84) v1(12.1,48.01) v1(12.1,47.12) v1(12.25,80.57) v1(12.23,79.25) v1(12.23,78.23) v1(13.06,136.27) v1(13.62,159.38) v1(14.13,258.06) v1(14.13,25.59) v1(15.47,123.21) v1(15.73,68.3) v1(15.91,141.73) v1(15.91,124.59) v1(16.54,82.22) v1(16.97,127.23) v1(17.31,85.06) v1(17.43,143.89) v1(17.56,62.74) v1(17.91,136.68) v1(19.21,258.06) v1(19.21,25.59) v1(19.49,83.52) v1(19.74,153.37) v1(19.74,65.58) v1(20.23,65.15) v1(20.51,143.41) v1(20.43,124.59) v1(20.86,146.81) v1(20.99,157.23) v1(20.99,155.19) v1(21.37,118.97) v1(22,156.21) v1(22.11,147.62) v1(22.18,149.02) v1(22.36,83.46) v1(22.64,152.17) v1(23.02,155.19) v1(23.4,147.57) v1(23.4,78.99) v1(24.29,258.06) v1(24.29,25.59) v1(24.54,89) v1(24.67,80.77) v1(25.43,145.16) v1(25.81,112.27) v1(25.92,77.37) v1(25.94,156.01) v1(25.99,109.96) v1(26.65,146.56) v1(27.08,108.59) v1(27.47,90.53) v1(27.67,87.83) v1(28.48,136.78) v1(28.86,148.84) v1(28.99,46.23) v1(29.12,134.87) v1(29.22,146.94) v1(29.29,129.44) v1(29.37,258.06) v1(29.37,25.59) v1(30.13,118.72) v1(30.36,84.24) v1(30.49,148.36) v1(31.33,111.43) v1(31.78,122.43) v1(32.27,112.65) v1(33.03,82.37) v1(33.43,126.16) v1(33.43,95.5) v1(33.43,93.22) v1(33.84,191.34) v1(34.04,124.87) v1(34.45,258.06) v1(34.45,25.59) v1(34.58,94.36) v1(34.63,82.65) v1(34.96,143.51) v1(34.96,85.22) v1(35.44,161.06) v1(35.52,159.69) v1(35.72,95.5) v1(35.72,93.22) v1(35.97,43.69) v1(36.48,52.32) v1(36.48,51.56) v1(36.48,50.8) v1(36.48,49.66) v1(36.74,43.69) v1(36.99,50.16) v1(37.24,52.32) v1(37.24,51.56) v1(37.9,73.58) v1(37.88,51.56) v1(38.06,86.69) v1(38.51,55.37) v1(38.77,106.3) v1(39.53,258.06) v1(39.53,25.59) v1(39.71,75.36) v1(40.18,160.08) v1(40.29,139.95) v1(40.27,77.36) v1(40.55,146.74) v1(41.1,73.58) v1(41.54,154.86) v1(41.82,143) v1(41.87,141.15) v1(42.32,107.57) v1(43.09,107.57) v1(43.95,149.82) v1(44.1,250.82) v1(44.09,79.57) v1(44.36,107.82) v1(44.61,258.06) v1(44.61,25.59) v1(45.12,107.82) v1(45.13,52.32) v1(45.13,51.32) v1(45.25,249.3) v1(45.5,149.86) v1(45.63,51.82) v1(45.84,160.17) v1(46.13,52.32) v1(46.13,51.32) v1(46.24,152.7) v1(46.38,86.25) v1(46.46,223.06) v1(46.46,113.28) v1(47.2,135.81) v1(47.45,223.42) v1(47.51,114.71) v1(47.91,232.54) v1(47.91,231.9) v1(47.84,135.81) v1(47.94,112.09) v1(48.12,111.05) v1(48.17,168.17) v1(48.75,160.3) v1(48.84,119.88) v1(48.98,121.99) v1(49.49,126.82) v1(49.51,57.73) v1(49.56,193.42) v1(49.56,192.66) v1(49.56,191.9) v1(49.69,258.06) v1(49.64,121.9) v1(49.69,25.59) v1(49.84,117.83) v1(49.84,117.2) v1(50.16,115.93) v1(50.3,122.26) v1(50.45,118.87) v1(50.48,117.2) v1(50.45,43.69) v1(50.58,248.03) v1(50.71,116.59) v1(50.63,57.73) v1(50.83,132) v1(50.83,118.36) v1(51.21,43.69) v1(51.47,118.36) v1(51.49,46.91) v1(51.57,132.03) v1(51.63,123.27) v1(51.72,124.59) v1(51.85,129.79) v1(51.85,119) v1(51.98,119.76) v1(52.38,82.12) v1(52.61,129.03) v1(52.61,125.6) v1(52.6,123.12) v1(52.61,122.17) v1(52.61,119.76) v1(52.79,130.56) v1(52.74,116.84) v1(53.09,120.78) v1(53.25,187.83) v1(53.25,187.2) v1(53.25,186.56) v1(53.66,130.65) v1(53.81,129.23) v1(53.8,128.55) v1(53.75,117.86) v1(54.06,224.08) v1(54.06,223.42) v1(54.59,225.17) v1(54.54,150.52) v1(54.6,127.17) v1(54.6,126.4) v1(54.6,123.3) v1(54.6,122.52) v1(54.6,121.75) v1(54.64,54.74) v1(54.77,258.06) v1(54.74,117.4) v1(54.77,25.59) v1(54.97,204.34) v1(55.06,133.68) v1(55.02,120.27) v1(55.13,225.96) v1(55.15,55.25) v1(55.15,54.36) v1(55.37,121.77) v1(55.66,54.74) v1(55.91,203.81) v1(56.05,151.98) v1(56.07,116.82) v1(56.04,55.25) v1(56.15,121.75) v1(56.17,119.63) v1(56.17,118.11) v1(56.24,150.14) v1(56.29,54.36) v1(56.34,180.29) v1(56.92,121.75) v1(57.18,119.63) v1(57.18,118.87) v1(57.18,118.11) v1(57.18,117.35) v1(57.28,54.1) v1(57.36,202.79) v1(57.7,125.62) v1(57.7,124.85) v1(57.7,124.07) v1(57.77,152.86) v1(57.82,55.22) v1(57.82,54.58) v1(58.2,144.91) v1(58.45,178.69) v1(58.48,133.02) v1(58.48,132.27) v1(58.47,126.4) v1(58.47,125.62) v1(58.47,124.85) v1(58.47,122.52) v1(58.47,121.75) v1(58.45,119.76) v1(58.53,120.51) v1(58.91,150.9) v1(58.83,148.84) v1(58.94,208.86) v1(58.99,150.19) v1(58.93,146.74) v1(59.29,145.69) v1(59.25,125.62) v1(59.25,124.85) v1(59.25,124.07) v1(59.25,123.3) v1(59.47,57.02) v1(59.47,56.38) v1(59.7,131.55) v1(59.7,120.37) v1(59.85,258.06) v1(59.88,101.83) v1(59.85,25.59) v1(60.02,127.17) v1(60.02,126.4) v1(60.02,121.75) v1(60.43,147.3) v1(60.55,35.35) v1(60.87,132.59) v1(60.87,131.95) v1(60.87,131.32) v1(60.95,117.45) v1(61.22,204.72) v1(61.63,148.34) v1(61.63,146.3) v1(61.63,145.16) v1(61.63,138.13) v1(61.81,115.33) v1(61.88,132.21) v1(61.88,130.56) v1(61.96,129.92) v1(62.39,204.72) v1(62.44,150.42) v1(62.64,129.97) v1(62.8,132.84) v1(62.9,35.31) v1(62.95,148.29) v1(63.03,131.32) v1(63.04,130.64) v1(63.41,141.73) v1(63.41,140.97) v1(63.41,140.21) v1(63.41,139.45) v1(63.41,138.18) v1(63.63,151.51) v1(63.74,148.29) v1(63.77,130.55) v1(64.63,131.67) v1(64.8,132.97) v1(64.93,258.06) v1(64.93,25.59) v1(65.08,118.85) v1(65.34,116.69) v1(66.56,112.49) v1(66.84,82.68) v1(67.04,114.67) v1(67.44,235.89) v1(67.47,82.68) v1(67.6,135.81) v1(67.85,110.74) v1(67.85,110.11) v1(67.85,109.35) v1(67.85,108.59) v1(67.85,107.82) v1(68.11,82.68) v1(68.11,82.04) v1(68.23,119.33) v1(68.23,51.56) v1(68.61,163.83) v1(68.59,123.44) v1(68.61,100.46) v1(68.61,98.93) v1(68.69,135.81) v1(68.69,135.18) v1(68.69,118.87) v1(68.68,115.13) v1(68.74,117.62) v1(69.04,161.06) v1(69.06,129.03) v1(69.12,146.3) v1(69.38,117.42) v1(69.68,124) v1(69.88,81.79) v1(70.01,258.06) v1(70.01,25.59) v1(70.13,145.94) v1(70.26,100.46) v1(70.26,98.93) v1(70.39,163.83) v1(70.39,113.39) v1(70.49,133.17) v1(70.52,81.79) v1(70.65,165.99) v1(70.74,143.96) v1(70.73,114.95) v1(71.03,96.39) v1(71.03,94.74) v1(71.03,92.79) v1(71.2,123.22) v1(71.15,81.79) v1(71.31,83.54) v1(71.38,130.15) v1(71.51,170.79) v1(71.43,132.46) v1(71.46,125.68) v1(71.51,119.33) v1(71.53,162.43) v1(71.56,143.98) v1(71.53,129.03) v1(71.66,92.79) v1(71.74,172.75) v1(71.79,123.9) v1(71.94,116.13) v1(71.94,115.06) v1(71.99,92.23) v1(72.04,83.57) v1(72.04,81.79) v1(72.3,94.74) v1(72.3,92.79) v1(72.65,92.23) v1(72.68,83.57) v1(72.68,81.79) v1(73.06,172.59) v1(73.21,113.03) v1(73.31,83.57) v1(73.31,81.79) v1(73.34,126.34) v1(73.74,120.7) v1(74.07,219.2) v1(74.83,123.29) v1(75.09,258.06) v1(75.32,167.23) v1(75.37,119.08) v1(75.6,81.15) v1(75.95,120.42) v1(76.21,117.25) v1(76.36,82.73) v1(76.49,167.18) v1(76.44,78.68) v1(76.6,164.25) v1(76.92,166.32) v1(77.63,77.22) v1(77.76,80.01) v1(79.84,119.96) v1(79.99,117.63) v1(80.17,258.06) v1(80.91,119.48) v1(80.88,116.87) v1(81.01,140.13) v1(81.28,58.6) v1(81.97,118.52) v1(82.23,138.79) v1(83.09,107.82) v1(83.73,139.7) v1(83.73,137.29) v1(83.93,141.43) v1(84.62,51.82) v1(84.74,67.82) v1(85.02,135.81) v1(85.25,258.06) v1(85.25,118.19) v1(85.28,116.08) v1(85.38,77.98) v1(85.51,55.53) v1(85.61,134.44) v1(85.58,132.36) v1(86.01,217.17) v1(86.27,222.66) v1(86.27,219.2) v1(86.27,215.9) v1(86.27,213.74) v1(86.27,211.71) v1(86.27,209.68) v1(86.29,205.89) v1(86.29,203.76) v1(86.29,201.88) v1(86.29,199.75) v1(86.27,197.89) v1(86.27,195.76) v1(86.24,193.88) v1(86.24,191.74) v1(86.27,187.91) v1(86.27,185.78) v1(86.27,183.79) v1(86.27,181.66) v1(86.24,179.86) v1(86.24,177.72) v1(86.24,175.92) v1(86.24,173.79) v1(86.27,167.89) v1(86.27,165.86) v1(86.37,171.86) v1(86.37,169.72) v1(86.49,164.57) v1(86.52,108.97) v1(86.6,160.91) v1(86.65,158.22) v1(86.7,135.86) v1(86.65,131.29) v1(86.8,132.49) v1(86.77,75.06) v1(86.77,74.42) v1(86.77,73.79) v1(86.77,73.15) v1(86.77,72.52) v1(86.77,71.88) v1(86.82,162.03) v1(86.98,137.16) v1(87.08,144.4) v1(87.13,223.9) v1(87.26,129.36) v1(87.28,128.14) v1(87.33,130.66) v1(88.07,135.33) v1(88.3,211.71) v1(88.3,209.68) v1(88.3,197.89) v1(88.3,195.76) v1(88.27,193.88) v1(88.27,191.74) v1(88.3,187.91) v1(88.3,185.78) v1(88.3,183.79) v1(88.3,181.66) v1(88.27,179.86) v1(88.27,177.72) v1(88.27,175.92) v1(88.22,173.76) v1(88.3,168.02) v1(88.25,158.19) v1(88.35,217.04) v1(88.32,205.89) v1(88.32,203.76) v1(88.32,201.88) v1(88.32,199.75) v1(88.35,171.88) v1(88.35,169.7) v1(88.32,160.93) v1(88.45,162.08) v1(88.55,230.89) v1(88.55,165.74) v1(88.53,164.57) v1(88.68,215.9) v1(88.71,151.37) v1(88.76,218.69) v1(88.81,213.74) v1(89.09,108.18) v1(89.21,220.83) v1(89.44,128.65) v1(89.72,221.31) v1(89.8,150.67) v1(89.82,231.27) v1(90.33,258.06) v1(90.33,25.59) v1(90.61,159.87) v1(90.53,151.23) v1(91.6,151.51) v1(91.68,159.87) v1(92.18,146.48) v1(92.57,152.32) v1(92.92,51.21) v1(93.51,158.37) v1(93.45,65.33) v1(93.58,157.66) v1(93.73,154.79) v1(93.99,153.19) v1(94.14,147.32) v1(94.51,215.75) v1(94.52,158.88) v1(94.57,107.92) v1(94.98,125.35) v1(95.08,244.02) v1(95.06,243.23) v1(95.18,151.28) v1(95.28,148.59) v1(95.41,258.06) v1(95.41,25.59) v1(95.49,154.66) v1(95.62,247.65) v1(95.61,125.35) v1(95.55,109.42) v1(95.87,155.91) v1(95.84,105.74) v1(96,245.54) v1(95.99,51) v1(96.25,125.35) v1(96.38,50.09) v1(96.55,237.36) v1(96.53,142.93) v1(96.6,132.77) v1(96.68,157.45) v1(96.68,156.69) v1(96.65,149.35) v1(96.78,106.83) v1(97.95,153.16) v1(98.2,147.95) v1(98.84,154.05) v1(100.24,118.95) v1(100.36,149.35) v1(100.49,258.06) v1(100.49,151.13) v1(100.49,25.59) v1(101.25,151.64) v1(101.38,153.8) v1(101.51,125.09) v1(101.71,228.24) v1(102.14,74.68) v1(102.14,68.33) v1(102.32,219.89) v1(102.27,133.86) v1(102.27,132.84) v1(102.27,132.08) v1(102.34,118.9) v1(102.78,68.33) v1(102.9,132.84) v1(102.9,132.08) v1(102.83,103.96) v1(102.9,74.68) v1(102.95,219.89) v1(103.67,74.68) v1(104.1,228.19) v1(104.43,74.68) v1(104.73,153.06) v1(105.11,135.56) v1(105.06,74.68) v1(105.57,258.06) v1(105.57,25.59) v1(105.82,74.68) v1(106.59,152.76) v1(106.59,74.68) v1(107.53,219.76) v1(107.88,153.29) v1(109.48,154.91) v1(109.63,228.22) v1(109.63,227.2) v1(109.63,226.34) v1(110.14,232.16) v1(110.65,258.06) v1(110.65,228.22) v1(110.65,227.2) v1(110.65,226.34) v1(110.65,25.59) v1(111.67,228.22) v1(111.67,227.2) v1(111.67,226.34) v1(112.02,232.08) v1(114.84,196.72) v1(114.84,195.83) v1(114.84,194.94) v1(114.84,194.18) v1(115.1,151.38) v1(115.37,135.38) v1(115.48,141.86) v1(115.73,258.06) v1(115.73,128.91) v1(115.73,25.59) v1(115.86,203.1) v1(116.57,201.12) v1(116.62,135.4) v1(116.54,67.37) v1(116.54,66.55) v1(116.75,141.86) v1(116.87,150.88) v1(116.87,134.29) v1(116.87,133.22) v1(116.92,132.13) v1(117.13,151.51) v1(117.38,51.56) v1(117.48,137.34) v1(117.71,48.26) v1(118.02,141.86) v1(118.02,51.56) v1(118.4,136.27) v1(119.93,136.42) v1(120.12,134.98) v1(120.44,67.5) v1(120.44,66.62) v1(120.81,258.06) v1(120.81,226.19) v1(120.76,139.88) v1(120.81,25.59) v1(121.11,137.97) v1(121.24,136.73) v1(121.67,47.19) v1(121.8,46.51) v1(122.28,222.1) v1(123.1,57.01) v1(123.76,159.72) v1(124.24,231.52) v1(124.24,224.03) v1(124.39,155.8) v1(125.18,25.15) v1(125.46,67.64) v1(125.66,237.44) v1(125.76,20.07) v1(125.76,9.99) v1(125.76,5.74) v1(125.89,258.06) v1(126.04,161.11) v1(126.3,236.63) v1(126.35,238.38) v1(126.32,235.94) v1(126.78,154.84) v1(127.59,162.38) v1(127.67,32.13) v1(127.8,206.86) v1(129.37,209.85) v1(129.47,159.16) v1(129.9,67.69) v1(129.98,162.84) v1(130.34,232.77) v1(130.41,72.31) v1(130.54,166.85) v1(130.97,258.06) v1(130.96,2.2) v1(131.03,71.16) v1(131.16,66.3) v1(131.27,216.56) v1(131.27,175.46) v1(131.22,8.21) v1(131.63,193.24) v1(131.66,59.94) v1(131.88,159.16) v1(132.57,233.93) v1(132.67,164.77) v1(132.84,61.32) v1(132.98,68.03) v1(133.03,175.49) v1(133.1,172.26) v1(133.15,66.2) v1(133.48,167.36) v1(133.51,8.14) v1(134.53,173.66) v1(134.91,170.23) v1(134.87,68.02) v1(134.99,233.93) v1(135.41,32.37) v1(135.47,172.11) v1(135.95,167.28) v1(136,33.02) v1(136.05,258.06) v1(136.04,2.2) v1(136.18,177.55) v1(136.33,169.16) v1(136.63,33.02) v1(138.72,66.04) v1(138.85,25.43) v1(139.48,23.52) v1(139.73,198.88) v1(140.5,227.08) v1(140.88,222.96) v1(141.12,2.2) v1(141.13,258.06) v1(141.38,66.5) v1(141.51,226.24) v1(141.43,224.49) v1(141.49,198.68) v1(141.51,197.74) v1(141.57,222.1) v1(141.64,64.83) v1(142.18,220.58) v1(143.01,198.68) v1(143.04,197.74) v1(143.14,66.6) v1(143.64,35.86) v1(143.93,25.43) v1(144.35,167.67) v1(144.56,23.52) v1(144.9,209) v1(145.14,224.64) v1(145.32,222.5) v1(146.06,223.37) v1(146.21,258.06) v1(146.2,2.2) v1(146.37,210.2) v1(147.56,64.13) v1(147.61,46.48) v1(148,58.24) v1(148.92,54.38) v1(149.87,35.31) v1(150.68,35.36) v1(151.29,258.06) v1(151.29,230) v1(151.28,2.2) v1(151.43,18.4) v1(151.54,35.36) v1(151.93,232.03) v1(151.93,201.68) v1(151.93,201.04) v1(152.56,201.68) v1(152.56,201.04) v1(153.2,197.36) v1(153.2,196.72) v1(153.2,196.09) v1(153.45,74.68) v1(153.83,197.36) v1(153.83,196.72) v1(153.83,196.09) v1(153.83,177.29) v1(153.83,71.12) v1(153.83,69.85) v1(153.83,68.58) v1(154.41,168.91) v1(154.47,197.36) v1(154.47,196.72) v1(154.47,196.09) v1(154.97,142.79) v1(155.1,169.01) v1(155.35,167.18) v1(156.37,258.06) v1(156.36,2.2) v1(156.7,167.69) v1(157.64,148.97) v1(157.64,147.95) v1(157.64,143.89) v1(157.64,142.75) v1(158.28,223.52) v1(158.53,213.94) v1(158.91,223.01) v1(159.11,214.55) v1(159.42,152.65) v1(159.42,148.97) v1(159.42,147.95) v1(159.55,151.26) v1(159.55,144.02) v1(159.55,142.88) v1(160.36,216.31) v1(161.32,152.65) v1(161.32,151.38) v1(161.45,258.06) v1(161.45,148.97) v1(161.45,147.95) v1(161.45,143.89) v1(161.45,142.88) v1(161.44,2.2) v1(162.21,31.62) v1(163.86,146.05) v1(164.63,146.05) v1(165.26,150.75) v1(165.26,149.99) v1(165.9,146.05) v1(166.52,2.2) v1(166.53,258.06) v1(166.66,146.05) v1(167.55,142.24) v1(167.55,141.6) v1(167.55,57.4) v1(167.93,146.05) v1(168.05,215.01) v1(168.69,146.05) v1(168.94,215.01) v1(169.32,150.75) v1(169.32,149.99) v1(169.83,215.01) v1(169.96,146.05) v1(170.72,215.01) v1(170.72,146.05) v1(171.37,126.59) v1(171.48,215.01) v1(171.61,258.06) v1(171.6,2.2) v1(172.25,118.36) v1(172.88,208.28) v1(172.88,207.64) v1(173.77,204.72) v1(173.77,150.75) v1(173.77,149.99) v1(173.77,147.32) v1(173.77,146.56) v1(173.77,143.76) v1(173.77,143) v1(174.15,207.14) v1(174.21,141.05) v1(174.53,204.72) v1(174.53,76.48) v1(174.89,34.45) v1(175.43,122.5) v1(176.69,258.06) v1(177.33,187.68) v1(178.09,196.47) v1(178.09,195.45) v1(178.09,194.67) v1(178.09,192.66) v1(178.09,191.64) v1(178.09,190.37) v1(178.09,189.23) v1(178.09,188.09) v1(178.09,187.07) v1(178.09,186.18) v1(178.09,75.06) v1(178.21,198.12) v1(178.34,200.15) v1(178.34,199.01) v1(178.72,191.64) v1(178.72,190.37) v1(178.72,189.23) v1(178.72,188.09) v1(178.72,187.07) v1(178.72,186.18) v1(178.85,199.64) v1(178.85,198.5) v1(178.85,197.49) v1(178.85,196.47) v1(178.85,195.45) v1(178.85,194.67) v1(178.85,192.66) v1(180.99,34.84) v1(181.39,215.01) v1(181.77,258.06) v1(182.28,215.01) v1(183.04,215.01) v1(183.8,215.01) v1(184.06,25.35) v1(184.06,23.83) v1(184.06,22.31) v1(184.69,215.01) v1(185.58,25.35) v1(185.58,23.83) v1(185.58,22.31) v1(186.22,35.56) v1(186.85,258.06) v1(187.1,25.35) v1(187.1,23.83) v1(187.1,22.43) v1(190.41,211.33) v1(190.91,208.53) v1(191.55,211.07) v1(191.55,208.53) v1(191.93,258.06) v1(192.79,236.73) v1(193.58,191.52) v1(193.58,190.88) v1(195.11,200.61) v1(195.13,199.85) v1(195.44,215.24) v1(195.69,176.4) v1(195.69,175.41) v1(195.66,174.4) v1(195.77,200.38) v1(195.87,203.71) v1(195.87,202.95) v1(195.87,202.31) v1(195.87,201.55) v1(195.87,195.96) v1(195.87,195.07) v1(195.87,194.06) v1(195.94,196.82) v1(196.2,215.24) v1(196.15,200.96) v1(196.5,203.17) v1(196.43,201.98) v1(196.65,203.81) v1(196.76,202.59) v1(196.78,197.14) v1(196.76,195.96) v1(196.76,195.07) v1(196.76,194.06) v1(196.88,28.02) v1(196.88,27.26) v1(197.01,258.06) v1(196.96,215.24) v1(197.65,28.02) v1(197.65,27.26) v1(197.72,215.24) v1(198.61,215.24) v1(199.93,237.49) v1(200.95,238.76) v1(202.09,258.06) v1(203.16,21.77) v1(203.49,73.28) v1(203.49,71.63) v1(203.49,70.74) v1(203.49,69.98) v1(203.64,20.25) v1(203.87,224.54) v1(204.25,73.28) v1(204.25,72.39) v1(204.25,71.63) v1(204.25,70.74) v1(204.25,69.98) v1(204.5,224.54) v1(204.76,29.41) v1(204.88,223.11) v1(205.39,237.36) v1(205.39,73.28) v1(205.52,167.64) v1(205.52,167) v1(205.52,160.78) v1(205.52,160.15) v1(205.65,153.92) v1(205.65,153.29) v1(205.65,146.81) v1(205.65,146.18) v1(206.15,72.77) v1(206.15,71.63) v1(206.28,45.06) v1(207.17,258.06) v1(207.3,242.06) v1(207.93,242.06) v1(208.59,29.24) v1(208.95,237.11) v1(209.13,52.83) v1(209.33,26.7) v1(209.72,135.89) v1(209.75,131.61) v1(211.46,198.09) v1(211.45,129.82) v1(211.74,199.77) v1(212.1,40.26) v1(212.12,72.14) v1(212.12,70.74) v1(212.25,258.06) v1(212.25,137.67) v1(212.28,35.66) v1(212.38,199.77) v1(212.38,198.88) v1(212.38,155.57) v1(213.14,136.91) v1(213.14,136.27) v1(213.27,242.06) v1(213.27,209.68) v1(213.27,208.66) v1(213.27,207.64) v1(213.27,206.63) v1(213.27,205.74) v1(213.27,41.07) v1(213.39,203.45) v1(213.39,202.44) v1(213.39,201.55) v1(213.39,200.66) v1(213.59,127.77) v1(213.65,209.17) v1(213.65,208.15) v1(213.65,42.42) v1(213.77,207.26) v1(213.9,206.63) v1(213.9,205.74) v1(213.9,155.07) v1(213.9,154.43) v1(214.03,242.06) v1(214.03,204.72) v1(214.03,203.45) v1(214.03,202.44) v1(214.03,201.55) v1(214.03,200.66) v1(214.41,136.91) v1(214.41,136.27) v1(214.66,174.75) v1(214.66,41.78) v1(214.79,40.13) v1(215.17,155.07) v1(215.17,154.43) v1(215.25,45.82) v1(215.68,136.91) v1(215.68,136.27) v1(215.98,45.82) v1(216.3,124.98) v1(216.44,211.71) v1(216.44,155.07) v1(216.44,154.43) v1(216.44,22.48) v1(216.57,41.15) v1(216.95,136.91) v1(216.95,136.27) v1(216.95,57.99) v1(217.08,210.31) v1(217.33,258.06) v1(217.46,208.03) v1(217.71,210.31) v1(217.71,154.43) v1(217.99,43.89) v1(218.32,56.74) v1(218.73,136.91) v1(218.73,136.27) v1(218.93,122.19) v1(219.24,155.07) v1(219.24,154.43) v1(220,136.91) v1(220,136.27) v1(220.17,133.96) v1(220.38,32.21) v1(220.51,155.07) v1(220.51,154.43) v1(221.04,119.99) v1(221.14,28.12) v1(221.27,136.91) v1(221.27,136.27) v1(221.78,155.07) v1(221.78,154.43) v1(222.41,258.06) v1(222.54,136.91) v1(222.54,136.27) v1(223.05,155.07) v1(223.05,154.43) v1(224.01,116.8) v1(224.01,110.39) v1(224.04,113.4) v1(224.02,106.39) v1(224.24,242.87) v1(224.49,26.01) v1(226.8,242.75) v1(226.98,38.86) v1(227.13,185.09) v1(227.49,145.29) v1(227.49,84.56) v1(227.62,143.89) v1(227.74,172.08) v1(227.87,162.18) v1(227.87,161.42) v1(228.51,40.49) v1(228.51,29.03) v1(228.76,143.89) v1(228.76,141.1) v1(229.27,158.5) v1(229.73,114.94) v1(230.44,45.95) v1(230.72,122.43) v1(230.79,109.91) v1(230.79,108.61) v1(231.05,163.07) v1(231.15,42.98) v1(231.27,199.03) v1(231.3,172.29) v1(231.55,154.69) v1(231.55,145.54) v1(231.68,163.07) v1(231.94,170.59) v1(232.19,154.69) v1(232.19,145.54) v1(232.32,163.07) v1(232.7,181.23) v1(232.82,154.69) v1(232.82,145.54) v1(232.87,49.15) v1(232.85,45.54) v1(233,48.46) v1(233.05,46.74) v1(236.58,42.11) v1(239.68,116.33) v2(104.58,112.83) v2(104.71,107.42) v2(110.35,118.95) v2(125.33,98.65) v2(127.13,101.5) v2(134.58,110.29) v2(135.08,116.46) v2(152.94,121.28) v2(161.5,107.75) v2(173.64,101.35) v2(187.28,116.54) v2(193.66,101.88) v2(204.5,102.79) v2(204.5,98.73) v2(211.74,128.57) v2(214.79,116.59) v2(222.05,106.04) v2(222.69,113.46) v3(48.6,125.63) v3(50.27,120.98) v3(53.76,123.27) v3(56.19,129.16) v3(58.48,129.18) v3(60.87,129.16) v3(60.99,128.38) v3(61.88,124.46) v3(61.89,118.36) v3(62.08,126.69) v3(62.08,125.65) v3(62.64,129.03) v3(63.52,118.74) v3(64.27,128.11) v3(64.34,125.55) v3(64.37,123.32) v3(64.36,122.1) v3(64.37,120.81) v3(64.44,126.76) v3(68.36,113.41) v3(68.87,112.9) v3(115.04,192.84) v3(118.22,190.86) v3(119.77,191.26) v3(150.43,225.92) v3(150.43,224.92) v3(150.43,223.92) v3(151.43,225.92) v3(151.43,224.92) v3(151.43,223.92) v3(152.43,225.92) v3(152.43,224.92) v3(152.43,223.92) v3(209.33,195.45) v3(210.35,193.42) v3(213.24,198.12) v3(220.82,192.47) v3(220.82,190.94) v3(220.82,189.42) v3(222.35,192.47) v3(222.35,190.94) v3(222.35,189.42) v3(223.87,192.47) v3(223.87,190.94) v3(223.87,189.42)
