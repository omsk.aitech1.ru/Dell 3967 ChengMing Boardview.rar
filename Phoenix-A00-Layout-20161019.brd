# Allegro board Phoenix-A00-Layout-20161019.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
K_AD14: length 80.5
  TOP w0.102: SLOT4.B45 23.03,187.06 24.07,186.02 31.75,186.02 32.79,187.06 SLOT3.B45 42.97,187.06 44.01,186.02 45.33,186.02 46.77,184.57 46.77,178.24 47.18,177.84 47.18,176.74 48.81,175.11 51.18,175.11 53.5,172.79 53.5,171.96 v1(53.12,171.58) ; v1(64,194.6) BRIDGE.E2
  BOTTOM w0.102: v1(64,194.6) 64.32,194.6 66.41,192.5 66.41,179.92 65.57,179.08 65.57,178.18 61.49,174.1 55.09,174.1 53.5,172.51 53.5,171.96 v1(53.12,171.58)
K_AD15: length 81
  TOP w0.102: v1(53.12,170.94) 53.73,171.55 53.73,172.89 51.28,175.34 48.9,175.34 47.41,176.83 47.41,177.93 47,178.34 47,184.72 45.91,185.81 45.91,187.33 45.13,188.11 43.88,188.11 43.66,188.33 SLOT3.A44 39.52,188.33 38.48,187.29 32.71,187.29 31.67,188.33 SLOT4.A44 ; v1(65.21,194.46) 65.21,194.67 64.91,194.97 64.43,194.97 BRIDGE.E1
  BOTTOM w0.102: v1(53.12,170.94) 53.73,171.55 53.73,172.42 55.19,173.88 61.58,173.88 65.79,178.09 65.79,178.98 66.64,179.82 66.64,192.61 66.5,192.74 65.49,193.76 65.49,194.18 v1(65.21,194.46)
K_AD16: length 70.6
  TOP w0.102: v1(60.36,214.5) 60.1,214.25 59.85,214.25 59.44,213.84 57.03,213.84 56.11,212.93 50.97,212.93 50.43,212.39 48.9,212.39 46.95,210.45 46.95,206.73 46.27,206.05 46.27,204.28 45.4,203.42 43.9,203.42 43.75,203.57 SLOT3.A32 39.47,203.57 38.53,202.63 38.53,200.82 37.66,199.95 28.02,199.95 26.86,201.12 23.86,201.12 22.06,202.92 SLOT4.A32 ; BRIDGE.K1 64.43,198.96 v1(65.16,198.96)
  BOTTOM w0.102: v1(60.36,214.5) 60.87,214 60.87,213.74 61.25,213.36 61.88,213.36 66.5,208.74 66.5,204.3 66.02,203.81 66.02,202.64 66.31,202.35 66.31,200.11 v1(65.16,198.96)
K_AD17: length 73.5
  TOP w0.102: BRIDGE.K2 63.99,199.39 63.99,199.39 v1(63.99,199.39) ; SLOT4.B32 20.34,203.57 21.34,204.57 22.75,204.57 23.27,204.05 23.27,202.31 24.24,201.35 29.34,201.35 RK55.2 31.2,203.2 36.93,203.2 SLOT3.B32 37.53,203.8 40.08,203.8 40.96,204.68 42.96,204.68 43.99,203.65 45.31,203.65 46.04,204.38 46.04,206.14 46.72,206.83 46.72,210.54 48.8,212.62 50.34,212.62 50.87,213.16 55.56,213.16 56.47,214.07 57.77,214.07 v1(58.2,214.5)
  BOTTOM w0.102: v1(63.99,199.39) 64.49,199.89 64.49,200.45 64.35,200.59 64.35,201.23 65.1,201.98 65.1,209.05 61.66,212.5 60.61,212.5 58.63,214.48 58.22,214.48 v1(58.2,214.5)
K_AD18: length 62.4
  TOP w0.102: SLOT4.A31 25.7,205.94 34.58,205.94 RK13.2 35.63,207 38.02,207 38.77,206.25 40.39,206.25 41.49,205.16 44.6,205.16 SLOT3.A31 44.92,205.67 46.27,207.02 46.27,210.73 48.61,213.08 50.15,213.08 50.68,213.61 54.67,213.61 55.43,214.38 57.31,214.38 v1(58.33,215.39) ; v1(64.93,200.18) 64.55,199.8 BRIDGE.L1
  BOTTOM w0.102: v1(58.33,215.39) 58.33,215.1 60.7,212.72 61.76,212.72 65.33,209.15 65.33,201.89 64.58,201.14 64.58,200.68 64.93,200.33 v1(64.93,200.18)
K_AD18_R: length 11.5
  TOP w0.102: RK13.1 34.81,207.54 v1(35.69,207.54)
  BOTTOM w0.102: SLOT3.A26 38.59,211.19 37.68,210.28 36.55,210.28 35.69,209.42 v1(35.69,207.54)
K_AD19: length 68.9
  TOP w0.102: BRIDGE.L2 63.98,200.18 63.98,200.19 v1(63.99,200.19) ; v1(55.33,213.64) 55.07,213.38 50.78,213.38 50.24,212.85 48.71,212.85 46.49,210.64 46.49,206.92 45.81,206.23 45.81,204.47 45.21,203.88 44.09,203.88 43.04,204.93 41.39,204.93 40.32,205.99 38.7,205.99 38.58,206.11 SLOT3.B30 36.68,205.49 27.12,205.49 25.43,203.8 23.87,203.8 22.87,204.8 21.29,204.8 19.98,206.11 SLOT4.B30
  BOTTOM w0.102: v1(63.99,200.19) 63.98,200.19 63.98,200.18 63.08,201.09 63.08,202.89 63.96,203.77 63.96,206.77 62.34,208.39 62.34,210.2 61.19,211.35 60.14,211.35 59.25,212.24 56.73,212.24 v1(55.33,213.64)
K_AD20: length 58
  TOP w0.102: SLOT4.A29 24.76,207.54 31.55,207.54 32.65,208.64 35.77,208.64 36.86,207.54 37.8,207.54 38.59,208.33 41.11,208.33 41.83,207.61 44.69,207.61 SLOT3.A29 45.81,208.27 45.81,210.92 48.42,213.54 49.96,213.54 50.49,214.07 53.7,214.07 54.26,214.63 54.9,214.63 v1(55.41,215.14) ; v1(64.6,202.59) 64.83,202.36 64.83,201.03 BRIDGE.M1
  BOTTOM w0.102: v1(55.41,215.14) 55.56,214.99 55.71,214.99 57.54,213.16 59.63,213.16 60.52,212.27 61.57,212.27 64.87,208.96 64.87,202.86 v1(64.6,202.59)
K_AD21: length 63.6
  TOP w0.102: BRIDGE.L3 63.18,200.18 63.18,200.19 v1(63.19,200.19) ; SLOT4.B29 22.73,207.38 23.83,206.27 25.2,206.27 26.25,207.31 31.71,207.31 32.77,208.38 35.69,208.38 36.76,207.31 39.44,207.31 SLOT3.B29 43.15,207.38 44.1,206.43 45.25,206.43 46.04,207.22 46.04,210.83 48.52,213.31 50.06,213.31 50.59,213.84 54.11,213.84 v1(54.41,214.15)
  BOTTOM w0.102: v1(54.41,214.15) 54.41,213.88 56.28,212.01 59.15,212.01 60.04,211.12 61.09,211.12 62.09,210.13 62.09,208.32 63.73,206.68 63.73,203.87 62.85,202.98 62.85,200.59 63.19,200.24 v1(63.19,200.19)
K_AD22: length 58.2
  TOP w0.102: SLOT4.A28 22.36,208.35 24.91,208.35 25.48,207.77 31.28,207.77 33.05,209.55 37.69,209.55 38.59,208.65 SLOT3.A28 42.38,209.23 44.13,210.97 45.16,210.97 45.54,210.97 48.33,213.77 49.87,213.77 50.5,214.4 53.66,214.4 v1(54.39,215.14) ; v1(63.74,202.62) 63.94,202.41 63.94,201.6 63.98,201.56 63.98,200.98 BRIDGE.M2
  BOTTOM w0.102: v1(54.39,215.14) 55.05,214.48 55.45,214.48 57.23,212.7 59.44,212.7 60.33,211.81 61.38,211.81 64.42,208.77 64.42,203.34 63.74,202.66 v1(63.74,202.62)
K_AD23: length 59.9
  TOP w0.102: v1(62.39,200.19) 62.38,200.19 62.38,200.18 BRIDGE.L4 ; SLOT4.B27 22.34,209.92 23.69,208.57 25,208.57 25.58,208 31.18,208 33.1,209.92 SLOT3.B27 42.24,212.32 42.76,212.32 43.88,211.2 45.37,211.2 48.17,214 49.77,214 50.66,214.88 v1(51.75,214.88)
  BOTTOM w0.102: v1(51.75,214.88) 51.75,214.14 55.63,210.26 58.47,210.26 59.61,209.13 59.61,205.11 59.95,204.76 59.95,203.35 60.23,203.07 61.4,203.07 61.68,203.35 62.26,203.35 62.62,202.99 62.62,200.42 v1(62.39,200.19)
K_AD24: length 54.8
  TOP w0.102: v1(53.75,216.03) 51.16,216.03 49.58,214.45 46.91,214.45 SLOT3.A25 44.6,212.78 41.44,212.78 40.09,211.43 38.54,211.43 37.89,212.08 36.6,212.08 35.95,211.43 25.63,211.43 SLOT4.A25 ; v1(63.23,204.06) 63.23,203.2 63.02,203 63.02,201.83 63.18,201.68 63.18,200.98 BRIDGE.M3
  BOTTOM w0.102: v1(53.75,216.03) 53.68,215.95 53.68,214.2 56.17,211.71 59.09,211.71 59.98,210.82 61.07,210.82 61.74,210.15 61.74,208.88 61.2,208.33 61.2,206.88 63.23,204.84 v1(63.23,204.06)
K_AD25: length 62.8
  TOP w0.102: BRIDGE.N2 63.6,201.92 v1(63.51,202.01) ; SLOT4.B24 20.24,213.73 21.57,212.39 22.94,212.39 23.9,213.35 36.92,213.35 SLOT3.B24 39.9,213.73 40.94,214.77 42.9,214.77 43.91,213.77 45.34,213.77 46.25,214.68 49.49,214.68 51.34,216.53 54.01,216.53 v1(54.39,216.15)
  BOTTOM w0.102: v1(54.39,216.15) 54.39,215.9 53.91,215.42 53.91,214.86 54.14,214.63 54.57,214.63 54.98,214.22 55.38,214.22 57.13,212.47 59.34,212.47 60.23,211.58 61.28,211.58 64.19,208.68 64.19,203.68 63.3,202.79 63.3,202.21 v1(63.51,202.01)
K_AD26: length 55.9
  TOP w0.102: BRIDGE.M4 62.38,200.98 62.38,201.61 61.53,202.46 61.53,203.17 61.7,203.35 61.7,203.66 v1(61.88,203.83) ; v1(53.63,217.3) 53.32,216.99 51.04,216.99 49.18,215.14 45.06,215.14 SLOT3.A23 44.69,215.23 41.83,215.23 41.17,215.89 39.14,215.89 38.31,215.06 36.23,215.06 34.98,213.81 26.76,213.81 25.57,215 SLOT4.A23
  BOTTOM w0.102: v1(61.88,203.83) 61.88,205.54 60.64,206.79 60.64,208.51 61.28,209.16 61.28,209.96 60.96,210.28 59.75,210.28 58.83,211.2 55.98,211.2 52.99,214.19 52.99,216.66 v1(53.63,217.3)
K_AD27: length 61.5
  TOP w0.102: v1(62.8,203.58) 62.8,203.58 BRIDGE.N3 ; v1(54.39,217.04) 54.11,216.76 51.19,216.76 49.33,214.91 46.16,214.91 45.25,214 44,214 42.99,215 SLOT3.B23 39.34,214.83 36.33,214.83 35.07,213.58 23.8,213.58 22.97,212.75 21.77,212.75 SLOT4.B23
  BOTTOM w0.102: v1(54.39,217.04) 54.14,217.04 53.25,216.15 53.25,214.31 56.07,211.48 58.99,211.48 59.88,210.59 60.98,210.59 61.51,210.06 61.51,209.03 60.97,208.48 60.97,206.78 62.9,204.85 62.9,204.37 62.8,204.27 v1(62.8,203.58)
K_AD28: length 56.2
  TOP w0.102: SLOT4.A22 22.31,216.02 24.88,216.02 26.86,214.04 34.89,214.04 36.14,215.29 38.22,215.29 39.05,216.12 42.23,216.12 SLOT3.A22 45.13,216.27 46.01,215.39 49.06,215.39 50.88,217.22 52.4,217.22 v1(52.64,217.46) ; BRIDGE.M5 61.58,200.98 61.58,201.76 60.83,202.51 v1(60.83,204.06)
  BOTTOM w0.102: v1(60.83,204.06) 60.69,204.2 60.69,204.77 60.07,205.4 60.07,209.32 58.66,210.72 55.82,210.72 52.48,214.05 52.48,217.3 v1(52.64,217.46)
K_AD29: length 63.1
  TOP w0.102: v1(51.73,217.66) 51.53,217.46 46.73,217.46 45.75,218.44 43.79,218.44 42.89,217.54 SLOT3.B21 39.49,217.53 36.33,217.53 35.75,216.94 35.75,215.31 34.7,214.26 26.95,214.26 24.97,216.25 23.78,216.25 22.48,217.54 SLOT4.B21 ; BRIDGE.L5 61.58,200.18 61.58,200.19 v1(61.59,200.19)
  BOTTOM w0.102: v1(61.59,200.19) 62.39,200.99 62.39,202.9 62.16,203.12 61.77,203.12 61.5,202.84 60.14,202.84 59.72,203.26 59.72,204.62 59.38,204.97 59.38,209.03 58.38,210.03 55.53,210.03 51.32,214.25 51.32,217.24 v1(51.73,217.66)
K_AD30: length 56.4
  TOP w0.102: v1(61.26,203.54) 61.26,202.41 62,201.67 BRIDGE.N4 ; v1(53.06,218.1) 52.47,218.68 51.56,218.68 50.79,217.92 46.92,217.92 45.72,219.12 42.69,219.12 SLOT3.A20 40.88,218.81 40.77,218.69 38.98,218.69 37.84,219.84 36.1,219.84 35.54,219.28 35.16,219.28 35.13,219.3 30.03,219.3 28.94,218.21 25.41,218.21 25.18,218.44 23.53,218.44 23.16,218.81 SLOT4.A20
  BOTTOM w0.102: v1(53.06,218.1) 53.16,218 53.16,217.15 52.74,216.73 52.74,214.12 55.91,210.95 58.76,210.95 60.29,209.41 60.29,206.81 61.65,205.45 61.65,204.36 61.26,203.96 v1(61.26,203.54)
K_AD31: length 63.3
  TOP w0.102: v1(52.19,218.13) 51.58,218.13 51.14,217.69 46.83,217.69 45.82,218.69 43.72,218.69 42.93,217.91 41.51,217.91 40.95,218.47 38.88,218.47 38.54,218.81 SLOT3.B20 35.52,217.36 35.52,215.4 34.61,214.49 27.05,214.49 25.07,216.47 23.87,216.47 22.57,217.77 20.62,217.77 19.58,218.81 SLOT4.B20 ; v1(60.38,203.53) 60.38,202.63 61.2,201.82 BRIDGE.N5
  BOTTOM w0.102: v1(60.38,203.53) 60.38,204.76 59.84,205.3 59.84,209.22 58.57,210.49 55.72,210.49 52.19,214.02 v1(52.19,218.13)
K_C/BE#0: length 67.5
  TOP w0.102: SLOT4.A52 22.49,178.6 36.01,178.6 36.48,179.07 38.36,179.07 39.26,178.17 SLOT3.A52 44.91,178.17 45.81,177.27 45.81,175.83 47.9,173.74 49.74,173.74 51.09,172.38 51.09,171.73 v1(51.93,170.89) ; BRIDGE.B1 64.46,192.6 65.03,192.02 65.03,191.06 v1(64.47,190.5)
  BOTTOM w0.102: v1(51.93,170.89) 52.36,171.32 52.36,171.73 52,172.08 52,173.1 53.92,175.02 61.07,175.02 64.65,178.6 64.65,184.56 65.34,185.25 65.34,189.08 64.68,189.74 64.68,190.3 v1(64.47,190.5)
K_C/BE#1: length 85.8
  TOP w0.102: BRIDGE.F2 v1(63.99,195.4) ; v1(54.26,172.34) 54.26,172.68 51.37,175.56 49,175.56 47.64,176.92 47.64,178.03 47.23,178.43 47.23,185.25 46.13,186.35 46.13,187.43 45.22,188.34 43.98,188.34 43.1,189.22 41.68,189.22 41.08,188.62 39.49,188.62 39.2,188.33 SLOT3.B44 36.49,187.52 33.22,187.52 32.16,188.57 23.3,188.57 22.65,189.22 20.93,189.22 20.04,188.33 SLOT4.B44
  BOTTOM w0.102: v1(63.99,195.4) 64.43,194.97 65.52,194.97 65.72,194.77 65.72,193.85 66.87,192.7 66.87,179.73 66.02,178.88 66.02,177.99 61.68,173.65 55.57,173.65 v1(54.26,172.34)
K_C/BE#2: length 72.2
  TOP w0.102: SLOT4.B33 22.35,202.3 23.76,200.89 26.68,200.89 27.85,199.72 37.75,199.72 39.1,201.07 39.1,201.56 SLOT3.B33 42.82,202.3 43.71,203.19 45.5,203.19 46.49,204.19 46.49,205.95 47.18,206.64 47.18,210.35 48.99,212.17 50.53,212.17 51.06,212.7 56.2,212.7 57.12,213.61 60.1,213.61 v1(60.36,213.87) ; v1(63.19,198.59) 63.19,198.59 63.19,198.59 BRIDGE.J3
  BOTTOM w0.102: v1(60.36,213.87) 61.12,213.11 61.76,213.11 65.56,209.3 65.56,206.29 66.28,205.57 66.28,204.39 65.79,203.91 65.79,202.54 66.08,202.25 66.08,200.2 65.29,199.42 64.96,199.42 64.22,198.68 63.28,198.68 v1(63.19,198.59)
K_C/BE#3: length 64.1
  TOP w0.102: SLOT4.B26 20.23,211.19 21.23,210.19 22.4,210.19 23.79,208.8 25.1,208.8 25.67,208.23 30.85,208.23 33.82,211.19 SLOT3.B26 40.17,211.19 41.53,212.55 42.86,212.55 43.98,211.43 45.22,211.43 48.01,214.22 49.68,214.22 50.84,215.39 53.75,215.39 54.01,215.65 54.77,215.65 v1(54.9,215.77) ; BRIDGE.N1 v1(64.4,201.98)
  BOTTOM w0.102: v1(64.4,201.98) 64.17,202.21 64.17,202.77 64.64,203.25 64.64,208.87 61.47,212.04 60.42,212.04 59.53,212.93 57.32,212.93 55.54,214.71 55.2,214.71 54.82,215.09 54.82,215.7 v1(54.9,215.77)
K_DEVSEL#: length 77.8
  TOP w0.102: RNK6.3 67.45,202.29 v1(66.96,201.8) 66.33,201.17 66.33,198.63 65.49,197.79 63.99,197.79 BRIDGE.H2 ; v1(63.41,213.23) 62.85,212.67 57.47,212.67 56.58,211.78 51.44,211.78 50.91,211.25 49.37,211.25 48.1,209.98 48.1,206.23 47.41,205.54 47.41,203.81 46.64,203.04 46.64,201.78 46.11,201.25 46.11,199.14 45.21,198.25 43.72,198.25 42.69,197.22 SLOT3.B37 38.55,197.22 38.28,196.95 25.59,196.95 24.97,196.33 24.23,196.33 23.61,196.95 22.99,196.95 22.73,197.22 SLOT4.B37
  BOTTOM w0.102: v1(63.41,213.23) 67.21,209.43 67.21,202.05 v1(66.96,201.8)
K_FRAME#: length 72.8
  TOP w0.102: SLOT4.A34 24.32,198.77 27.23,198.77 27.95,199.49 37.98,199.49 39.52,201.03 SLOT3.A34 44.92,201.03 45.88,201.99 45.88,203.25 46.72,204.09 46.72,205.86 47.41,206.54 47.41,210.26 49.09,211.94 50.62,211.94 51.16,212.47 56.3,212.47 57.19,213.36 60.99,213.36 v1(61.5,213.87) ; BRIDGE.J2 64.02,198.62 64.59,198.62 64.7,198.5 65.34,198.5 65.84,199 65.84,203.02 v1(66.45,203.64) 68.11,203.64 RNK6.1
  BOTTOM w0.102: v1(61.5,213.87) 61.76,213.87 66.73,208.89 66.73,203.92 v1(66.45,203.64)
K_GNT#0: length 73.4
  TOP w0.102: BRIDGE.A5 61.2,191.72 60.85,191.38 60.85,189.62 62.49,187.99 62.49,185.07 61.83,184.41 61.83,181.73 60.34,180.24 57.34,180.24 v1(56.83,180.75)
  BOTTOM w0.102: SLOT3.A17 44.46,222.16 44.46,220.93 43.87,220.34 43.87,219.46 43.8,219.39 43.8,203.02 43.8,202.83 43.31,202.35 43.31,189.59 43.75,189.15 43.75,186.56 44.41,185.9 45.48,185.9 46.02,185.36 46.16,185.22 46.29,185.09 46.29,180.7 47.49,179.5 51.23,179.5 53.03,181.31 56.23,181.31 56.79,180.75 v1(56.83,180.75)
K_GNT#1: length 96.5
  TOP w0.102: BRIDGE.C6 60.8,193 60.8,191.65 60.62,191.48 60.62,189.22 62.26,187.58 62.26,185.17 61.74,184.64 61.6,184.51 61.6,181.83 60.24,180.47 57.94,180.47 v1(57.46,180.95) ; SLOT4.A17 25.76,221.46 35.19,221.46 36.23,222.5 38.26,222.5 39.15,221.62 40.29,221.62 41.21,222.53 43.67,222.53 45.09,221.11 v1(45.35,221.11)
  BOTTOM w0.102: v1(45.35,221.11) 45.84,220.62 45.84,204.38 45.4,203.94 45.22,203.94 43.54,202.26 43.54,189.69 43.98,189.25 43.98,186.66 44.51,186.13 45.57,186.13 45.57,186.13 45.63,186.13 46.52,185.24 46.52,180.8 47.59,179.73 51.14,179.73 52.94,181.53 56.32,181.53 56.65,181.2 57.21,181.2 v1(57.46,180.95)
K_INTA#: length 83
  TOP w0.102: v1(48.67,232.54) 45.89,235.32 SLOT3.A7 42.2,235.32 40.72,233.84 39.62,233.84 38.47,232.69 34.29,232.69 33.23,233.76 24.4,233.76 23.06,235.09 21.26,235.09 20.22,234.05 SLOT4.B8 ; RNK1.4 59.53,204.3 v1(59.29,204.06) 58.86,203.63 58.86,203.24 59.23,202.87 59.82,202.87 60.78,201.92 60.78,200.98 BRIDGE.M6
  BOTTOM w0.102: v1(48.67,232.54) 50.07,232.54 50.86,231.75 50.86,223.79 52.25,222.4 52.25,220.05 51.31,219.11 50.59,219.11 49.06,217.58 49.06,210.57 50.2,209.42 57.69,209.42 59.15,207.96 59.15,204.79 59.29,204.65 v1(59.29,204.06)
K_INTB#: length 78.6
  TOP w0.102: v1(49.94,231.9) 49.94,232.73 45.88,236.79 44.49,236.79 43.43,237.85 41.72,237.85 40.51,236.64 39.89,236.64 SLOT3.B8 36.62,233.38 34.58,233.38 33.51,234.44 26.83,234.44 25.05,236.22 22.43,236.22 SLOT4.A6 ; RNK1.3 58.83,205.38 58.83,204.24 v1(58.66,204.06) 58.58,203.99 58.58,203.2 59.14,202.64 59.73,202.64 60.4,201.98 BRIDGE.N6
  BOTTOM w0.102: v1(58.66,204.06) 58.92,204.33 58.92,207.87 57.6,209.19 50.05,209.19 48.8,210.44 48.8,217.73 50.41,219.34 51.22,219.34 52.02,220.14 52.02,222.31 50.59,223.74 50.59,231.25 v1(49.94,231.9)
K_INTC#: length 80.1
  TOP w0.102: RNK1.1 57.13,203.89 58.03,202.99 58.03,202.82 v1(58.05,202.8) 58.05,202.77 59.22,201.6 59.22,200.98 BRIDGE.M7 ; v1(48.67,231.9) 49.17,232.4 49.17,232.79 45.63,236.34 42.63,236.34 SLOT3.A6 39.86,234.07 39.41,234.07 38.26,232.92 34.39,232.92 33.32,233.98 24.49,233.98 23.16,235.32 SLOT4.B7
  BOTTOM w0.102: v1(48.67,231.9) 49.77,230.8 49.77,220.57 48.29,219.09 48.29,210.19 49.74,208.74 57.41,208.74 58.47,207.68 58.47,205.83 57.64,205.01 57.64,203.21 v1(58.05,202.8)
K_INTD#: length 76.4
  TOP w0.102: RNK1.2 57.84,205.4 57.84,203.94 v1(58.07,203.71) 58.35,203.43 58.35,203.11 59.04,202.41 59.64,202.41 60.02,202.03 60.02,200.2 59.61,199.8 BRIDGE.L7 ; v1(49.31,231.9) 49.44,232.03 49.44,232.92 45.79,236.57 44.39,236.57 43.34,237.62 41.82,237.62 39.84,235.64 SLOT3.B7 39.84,234.82 38.17,233.15 34.48,233.15 33.42,234.21 25.71,234.21 SLOT4.A7
  BOTTOM w0.102: v1(58.07,203.71) 57.87,203.91 57.87,204.91 58.69,205.74 58.69,207.77 57.5,208.97 49.89,208.97 48.55,210.31 48.55,218.97 50.03,220.45 50.03,231.18 v1(49.31,231.9)
K_IRDY#: length 76.3
  TOP w0.102: RNK6.2 68.21,202.95 v1(66.45,202.95) 66.07,202.56 66.07,198.88 65.39,198.2 BRIDGE.J1 ; SLOT4.B35 22.94,199.76 24.16,198.54 35.11,198.54 36.25,197.41 38.09,197.41 39.84,199.16 SLOT3.B35 42.69,199.76 43.59,200.66 44.88,200.66 46.13,201.92 46.13,203.18 46.95,204 46.95,205.76 47.64,206.45 47.64,210.16 49.18,211.71 50.72,211.71 51.25,212.24 56.39,212.24 57.28,213.13 61.91,213.13 v1(62.64,213.87)
  BOTTOM w0.102: v1(66.45,202.95) 66.96,203.45 66.96,209.04 62.64,213.36 v1(62.64,213.87)
K_LOCK#: length 110.9
  TOP w0.102: v1(59.14,178.71) 59.57,178.28 67.37,178.28 v1(67.37,178.28) ; BRIDGE.M8 58.64,200.6 58.38,200.86 58.38,201.55 57.87,202.06 57.06,202.06 56.4,202.72 56.4,205.41 55.84,205.97 v1(55.84,206.83) ; RNK5.1 v1(67.09,195.38) ; SLOT4.B39 22.6,194.68 23.55,195.63 35.07,195.63 36.27,194.44 39.6,194.44 SLOT3.B39 42.94,194.68 44.36,193.27 46.79,193.27 v1(46.98,193.46)
  BOTTOM w0.102: v1(67.09,195.38) 68.01,194.46 68.01,179.15 67.37,178.52 v1(67.37,178.28) ; v1(55.84,206.83) 55.84,207.47 54.9,208.41 49.31,208.41 48.42,207.52 48.42,206.55 48.1,206.23 48.1,194.57 v1(46.98,193.46) 46.98,192.79 49.86,189.91 49.86,186.19 53.83,182.22 55.84,182.22 56.32,182.7 58,182.7 58.83,181.86 58.83,179.02 v1(59.14,178.71)
K_PAR: length 78.9
  TOP w0.102: SLOT4.A43 26.71,189.6 37.36,189.6 38.34,190.58 40.22,190.58 41.19,189.6 SLOT3.A43 46.39,188.13 46.39,186.42 47.46,185.34 47.46,178.53 47.87,178.12 47.87,177.02 49.09,175.79 51.47,175.79 54.69,172.57 54.69,172.14 v1(54.26,171.7) ; BRIDGE.F1 v1(64.79,195.4)
  BOTTOM w0.102: v1(64.79,195.4) 65.42,195.4 65.95,194.87 65.95,193.95 66.96,192.93 66.96,192.93 67.09,192.8 67.09,179.63 66.25,178.79 66.25,177.9 61.77,173.42 55.98,173.42 v1(54.26,171.7)
K_PCI_M66EN: length 9.8
  TOP w0.102: BRIDGE.L6 60.78,200.18 60.78,200.19 v1(60.79,200.19) ; v1(61.96,202.69) 62.34,203.07 62.34,204.14 61.76,204.72 RK25.2 62.34,205.88 62.34,207.59 62.77,208.03 RK24.1
  BOTTOM w0.102: v1(61.96,202.69) 61.96,201.88 v2(61.63,201.55) 61.63,201.03 v1(60.79,200.19)
K_PCI_PME#: length 11.9
  TOP w0.102: BRIDGE.L12 55.43,199.8 55.01,200.21 54.51,200.21 v1(54.16,200.56) 52.85,201.87 52.85,203.09 51.48,204.45 51.48,206.02 50.75,206.76 RK28.2 50.26,207.77 RK40.1
  BOTTOM w0.102: v1(54.16,200.56) 54.16,200.05 v2(53.88,199.77)
K_PCIRST#_N: length 5.1
  TOP w0.102: v1(59.29,203.43) 60.74,204.88 RK14.1 ; BRIDGE.N7 59.6,201.83 v1(59.46,201.97)
  BOTTOM w0.102: v1(59.29,203.43) 59.29,203.15 58.83,202.69 v2(58.83,202.44) 59.3,201.97 v1(59.46,201.97)
K_PCIRST#_SLOT: length 56.5
  TOP w0.102: v1(58.45,209.3) 59.34,209.3 60.55,208.09 CK23.2 ; CK23.2 RK32.1 ; CK23.2 RK14.2 ; SLOT4.A15 25.22,224.54 28.52,224.54 28.86,224.88 29.06,224.88 38.02,224.88 38.88,224.02 40.33,224.02 41.12,224.81 44.57,224.81 SLOT3.A15 45.51,225.16 46.72,223.95 50.08,223.95 50.6,223.42 53.11,223.42 v1(53.38,223.69)
  BOTTOM w0.102: v1(58.45,209.3) 58.01,209.74 55.47,209.74 51.06,214.15 51.06,217.69 51.47,218.1 51.47,218.45 53.38,220.36 v1(53.38,223.69)
K_PERR#: length 96.7
  TOP w0.102: BRIDGE.G2 63.98,196.98 64.8,196.98 v1(67.09,194.69) 67.2,194.58 RNK5.2 ; v1(55.02,171.07) 55.15,171.2 55.15,172.76 51.66,176.25 49.28,176.25 48.32,177.21 48.32,178.31 47.92,178.72 47.92,185.66 46.87,186.7 46.87,189.48 46.29,190.06 46.29,192.03 45.28,193.04 44.1,193.04 42.84,194.3 42.01,194.3 41.39,193.68 37.56,193.68 SLOT3.B40 36.11,193.41 34.71,194.81 26.18,194.81 25.1,193.73 23.42,193.73 22.71,194.44 21.12,194.44 20.09,193.41 SLOT4.B40
  BOTTOM w0.102: v1(55.02,171.07) 55.53,171.58 56.09,171.58 57.23,172.72 62.07,172.72 66.94,177.59 66.94,178.46 67.78,179.31 67.78,194 v1(67.09,194.69)
K_PME#: length 39.9
  TOP w0.102: v1(50.67,218.42) 47.31,218.42 45.65,220.08 SLOT3.A19 44.21,219.37 43.08,219.37 42.74,219.71 41.46,219.71 40.67,218.92 39.07,218.92 37.93,220.07 35.63,220.07 35.34,219.77 29.94,219.77 28.94,218.77 RK53.2 27.02,218.81 RK30.2 27.02,219.77 26.45,220.34 24.86,220.34 SLOT4.A19 ; v1(50.71,210.57) 50.2,210.06 RK40.2
  BOTTOM w0.102: v1(50.67,218.42) 50.55,218.31 50.55,210.72 v1(50.71,210.57)
K_REQ#0: length 82.3
  TOP w0.102: SLOT3.B18 37.49,221.16 40.24,221.16 41.46,219.94 43.14,219.94 v1(43.19,219.89) ; v1(56.04,179.7) 56.37,179.37 57.11,179.37 57.51,179.78 60.53,179.78 62.29,181.54 62.29,184.22 62.53,184.47 RK37.1 63.46,184.9 63.46,188.42 62,189.88 BRIDGE.A4
  BOTTOM w0.102: v1(56.04,179.7) 55.79,179.96 55.79,180.49 55.43,180.85 53.22,180.85 51.42,179.04 47.3,179.04 45.83,180.51 45.83,184.9 45.29,185.45 44.22,185.45 43.29,186.38 43.29,188.96 42.78,189.47 41.67,189.47 40.93,190.22 40.93,201.98 41.49,202.54 42.86,202.54 43.34,203.02 43.34,219.74 v1(43.19,219.89)
K_REQ#1: length 104.3
  TOP w0.102: SLOT4.B18 17.12,221.49 20.1,221.49 21.24,220.34 22.64,220.34 23.53,221.23 35.28,221.23 36.32,222.28 38.17,222.28 39.05,221.39 40.34,221.39 41.55,220.17 42.45,220.17 43.78,221.49 v1(43.98,221.49) ; v1(56.06,180.87) 56.57,181.38 57.64,181.38 58.32,180.7 60.15,180.7 61.37,181.92 61.37,184.15 61.12,184.4 61.12,186.37 RK49.1 61.63,187.71 60.4,188.94 BRIDGE.A6
  BOTTOM w0.102: v1(56.06,180.87) 55.73,180.87 55.52,181.08 53.13,181.08 51.33,179.27 47.4,179.27 46.06,180.61 46.06,184.99 45.93,185.13 45.38,185.67 44.32,185.67 43.52,186.47 43.52,189.06 42.88,189.7 41.77,189.7 41.16,190.32 41.16,201.89 41.58,202.31 42.95,202.31 43.57,202.93 43.57,219.48 43.64,219.56 43.64,220.5 43.82,220.68 43.82,221.34 v1(43.98,221.49)
K_SERR#: length 94.3
  TOP w0.102: v1(54.26,171.07) 54.92,171.73 54.92,172.66 51.56,176.02 49.19,176.02 48.1,177.11 48.1,178.22 47.69,178.62 47.69,185.44 46.64,186.49 46.64,189.14 45.29,190.49 43.81,190.49 43.3,189.98 41.13,189.98 40.24,190.87 SLOT3.B42 36.59,190.49 23.39,190.49 22.49,189.59 21.22,189.59 19.93,190.87 SLOT4.B42 ; BRIDGE.G3 63.2,196.19 64.88,196.19 65.95,195.12 65.95,194.56 66.45,194.06 v1(66.45,194.06) 67.52,192.98 RNK5.4
  BOTTOM w0.102: v1(54.26,171.07) 56.38,173.19 61.89,173.19 66.48,177.78 66.48,178.69 67.32,179.54 67.32,193.18 v1(66.45,194.06)
K_STOP#: length 91.1
  TOP w0.102: BRIDGE.G1 64.8,196.6 66.45,194.94 v1(66.45,194.69) 67.36,193.78 RNK5.3 ; v1(55.96,172.08) 55.96,173.22 52.36,176.82 49.36,176.82 48.81,177.37 48.81,180.87 48.15,181.53 48.15,185.75 47.1,186.8 47.1,189.57 46.52,190.16 46.52,191.74 47.43,192.66 47.43,193.65 45.13,195.95 SLOT3.A38 39.19,195.95 37.9,194.67 36.36,194.67 35.17,195.86 22.86,195.86 22.77,195.95 SLOT4.A38
  BOTTOM w0.102: v1(55.96,172.08) 56.84,172.96 61.99,172.96 66.71,177.68 66.71,178.56 67.55,179.4 67.55,193.59 v1(66.45,194.69)
K_TCK: length 14.8
  TOP w0.102: SLOT3.B2 39.58,239.39 40.55,239.39 41.56,240.41 43.21,240.41 44.36,241.55 45.37,241.55 46.01,242.19 46.01,244.86 46.39,245.24 RNK4.6
K_TCK1: length 10.4
  TOP w0.102: SLOT4.B2 20.11,241.67 21.37,240.41 22.89,240.41 23.91,241.43 RNK7.6
K_TDI: length 8.7
  TOP w0.102: RNK4.8 46.97,244.22 46.46,243.71 46.46,240.61 45.25,239.39 42.64,239.39 SLOT3.A4
K_TDI1: length 4.9
  TOP w0.102: SLOT4.A4 22.38,239.45 25.36,239.45 26.32,240.41 RNK7.8
K_TMS: length 5.6
  TOP w0.102: SLOT3.A3 44.92,240.72 46.24,242.04 46.24,244.35 46.62,244.73 RNK4.7
K_TMS1: length 2.1
  TOP w0.102: RNK7.7 25.12,240.92 SLOT4.A3
K_TRDY#: length 75.3
  TOP w0.102: v1(63.41,213.87) 62.44,212.9 57.38,212.9 56.49,212.01 51.35,212.01 50.81,211.48 49.28,211.48 47.87,210.07 47.87,206.32 47.18,205.64 47.18,203.9 46.39,203.11 46.39,201.85 45.88,201.34 45.88,199.24 45.13,198.49 SLOT3.A36 42.16,198.27 39.28,198.27 38.18,197.18 36.15,197.18 35.02,198.31 22.24,198.31 SLOT4.A36 ; RNK6.4 67.54,201.49 v1(67.22,201.17) 66.58,200.53 66.58,198.5 65.48,197.4 BRIDGE.H1
  BOTTOM w0.102: v1(67.22,201.17) 67.47,201.42 67.47,209.8 v1(63.41,213.87)
K_TRST: length 4.3
  TOP w0.102: SLOT3.A1 44.92,244.53 46.13,245.75 RNK4.5
K_TRST1: length 2.3
  TOP w0.102: SLOT4.A1 25.61,241.94 RNK7.5
KBDCLK: length 311.2
  TOP w0.102: v1(220,47.98) 217.43,47.98 217.2,47.75 213.87,47.75 211.79,45.67 210.95,45.67 209.77,44.49 SIO_5553.113 ; v1(160.05,223.52) 160.15,223.62 160.15,225.56 159.67,226.05 158.28,227.44 158.28,228.68 157.29,229.67 156.52,229.67 155.46,230.73 155.46,232.61 156.75,233.91 156.75,235.59 L15.1 155.16,237.19 RN5.4
  BOTTOM w0.102: v1(160.05,223.52) 160.05,223.9 162.47,226.31 167.29,226.31 168.18,227.2 172.75,227.2 173.77,226.19 177.55,226.19 178.41,225.32 179.83,225.32 182.87,228.37 182.87,234.25 185.43,236.8 189.88,236.8 192.23,234.44 205.57,234.44 205.95,234.82 211.46,234.82 213.2,233.08 223.98,233.08 225.55,231.52 225.55,225.02 227.53,223.04 227.53,221.8 240.09,209.24 240.09,138.54 239.33,137.78 239.33,123.34 v2(238.92,122.94) 238.92,120.65 237.78,119.51 237.78,117.47 236.28,115.97 236.28,112.85 225.71,102.28 225.71,95.36 231.05,90.03 231.05,77.9 229.2,76.06 229.2,65.85 226.16,62.8 226.16,54.15 220,47.99 v1(220,47.98)
KBDDATA: length 312.4
  TOP w0.102: RN5.3 154.36,236.72 L13.1 155.48,235.59 155.48,233.55 155.23,233.3 155.23,230.64 156.43,229.44 157.19,229.44 158.05,228.59 158.05,227.34 159.12,226.27 159.93,225.46 159.93,224.03 v1(159.42,223.52) ; v1(220.76,48.13) 220.12,47.5 213.94,47.5 211.86,45.43 211.06,45.43 209.73,44.09 SIO_5553.114
  BOTTOM w0.102: v1(220.76,48.13) 220.76,48.43 226.39,54.05 226.39,61.42 230.24,65.28 230.24,75.07 230.52,75.35 230.52,76.77 231.27,77.53 231.27,90.12 225.94,95.45 225.94,102.19 236.5,112.75 236.5,115.19 238.67,117.35 v2(238.67,119.25) 238.67,119.76 239.56,120.65 239.56,137.68 240.32,138.45 240.32,209.33 227.76,221.89 227.76,223.14 225.8,225.09 225.8,231.61 224.07,233.34 213.31,233.34 211.57,235.08 205.85,235.08 205.46,234.7 192.34,234.7 189.95,237.08 185.38,237.08 182.64,234.34 182.64,228.5 179.72,225.58 178.52,225.58 177.65,226.44 173.87,226.44 172.86,227.46 168.08,227.46 167.19,226.57 162.34,226.57 159.42,223.65 v1(159.42,223.52)
KBRST#: length 276.9
  TOP w0.102: v1(29.7,84.24) 29.51,84.05 27.45,84.05 26.8,84.7 24.6,84.7 22.56,86.73 22.56,100.09 20.63,102.03 20.63,108.93 17.2,112.36 17.2,120.34 14.46,123.08 14.46,128.34 15.48,129.36 16.9,129.36 17.43,129.9 19.93,129.9 20.14,130.1 23.6,130.1 24.27,130.77 26.81,130.77 R73.1 ; v1(205.4,44.96) 205.76,44.96 206.39,44.32 R497.2 207.04,44.32 208.11,43.25 208.11,42.77 208.38,42.49 SIO_5553.118
  BOTTOM w0.102: v1(205.4,44.96) 204.23,43.79 201.79,43.79 200.42,45.16 199.1,45.16 196.3,47.96 196.3,50.99 195.6,51.69 192.74,51.69 189.01,55.42 177.32,55.42 v2(176.89,55.86) 176.36,56.39 171.98,56.39 171.48,55.89 171.48,55.04 167.78,51.33 156.92,51.33 154.02,54.24 150.33,54.24 149.57,53.48 133.51,53.48 132.94,52.91 114.28,52.91 111.73,55.46 91.95,55.46 87.93,59.48 86.06,59.48 79.82,65.71 72.77,65.71 71.11,67.37 59.14,67.37 55.88,67.37 55.57,67.68 46.77,67.68 45.95,68.5 39.66,68.5 33.99,74.17 33.99,76.82 29.78,81.04 29.78,84.16 v1(29.7,84.24)
L_ACTLEDN: length 5
  TOP w0.102: RTK_LAN.27 113.15,226.6 113.75,226.01 v1(114.29,226.01) 114.66,226.01 114.87,225.81 RL30.1
  BOTTOM w0.102: v2(116.29,226.16) 116.14,226.01 v1(114.29,226.01)
L_ACTLEDN_R: length 55.3
  TOP w0.102: RL30.2 CL34.2 117.83,226.31 119.16,226.31 119.92,225.55 v1(120.81,225.55) ; v1(127.05,232.28) 126.91,232.42 126.91,238.68 v1(126.53,239.06)
  BOTTOM w0.102: NIC_USB.22 106.85,232.46 109.3,232.46 112.78,235.94 118.84,235.94 120.58,237.69 123.9,237.69 124.11,237.9 124.11,238.73 125.04,239.65 125.94,239.65 v1(126.53,239.06) ; v1(120.81,225.55) 121.47,224.89 121.47,223.7 123.07,222.1 125.43,222.1 126.76,223.43 126.76,232 v1(127.05,232.28)
L_LINK100#: length 5.9
  TOP w0.102: RL28.1 115.21,223.85 114.87,223.85 v1(114.28,224.43) 114.08,224.64 114.08,224.97 113.25,225.8 RTK_LAN.25
  BOTTOM w0.102: v1(114.28,224.43) 116.16,224.43 v2(116.4,224.19)
L_LINK100#_R: length 14.9
  TOP w0.102: v1(118.91,224.03) 118.65,224.28 117.83,224.28 CL31.1 RL28.2 ; NIC_USB.20 117.86,233.31 117.86,231.47 119.41,229.92 v1(119.41,229.41)
  BOTTOM w0.102: v1(119.41,229.41) 118.78,229.41 118.47,229.11 118.47,224.46 v1(118.91,224.03)
L_LINK1000#: length 3.2
  TOP w0.102: RTK_LAN.26 113.17,226.2 113.83,225.55 114.21,225.55 114.63,225.12 v1(114.63,225.11) 114.96,225.11 RL29.1
L_LINK1000#_R: length 15.8
  TOP w0.102: v1(119.87,228.85) 119.87,229.9 120.71,230.73 120.71,231.67 119.7,232.68 NIC_USB.19 ; v1(119.54,224.03) 119.41,224.16 119.41,225.04 119.16,225.3 117.83,225.3 CL32.1 RL29.2
  BOTTOM w0.102: v1(119.87,228.85) 119.13,228.12 119.13,226.59 119.54,226.19 v1(119.54,224.03)
L_MDI_0+: length 39.2
  TOP w0.102: NIC_USB.10 108.07,237.37 108.34,237.63 108.88,237.63 109.28,237.23 109.28,236.38 108.75,235.84 105.16,235.84 103.92,234.59 103.92,233.6 103.49,233.17 100.11,233.17 98.79,231.85 98.79,230.17 98.38,229.77 98.38,229.31 98.64,229.06 UU17.3 100.24,229.06 100.39,228.9 100.39,228.55 v1(100.13,228.29) ; RTK_LAN.1 112.05,229.5 112.32,229.77 112.7,229.77 113.11,230.17 113.42,230.17 113.52,230.07 v1(113.52,229.72)
  BOTTOM w0.102: v1(100.13,228.29) 100.24,228.19 100.24,227.69 100.9,227.03 105.67,227.03 107.06,228.42 108.67,228.42 109.16,228.91 111.85,228.91 112.66,229.72 v1(113.52,229.72)
L_MDI_0-: length 39.2
  TOP w0.102: NIC_USB.11 108.77,238.82 108.77,238.25 109.64,237.38 109.64,236.23 108.89,235.48 105.31,235.48 104.27,234.45 104.27,233.45 103.64,232.82 100.26,232.82 99.14,231.7 99.14,231.12 99.32,230.94 UU17.1 100.16,230.94 100.77,230.33 100.77,228.57 v1(101.05,228.29) ; v1(113.29,230.61) 113.22,230.53 112.96,230.53 112.56,230.12 112.17,230.12 111.65,229.6 RTK_LAN.2
  BOTTOM w0.102: v1(113.29,230.61) 113.29,230.23 113.14,230.07 112.51,230.07 111.7,229.27 109.01,229.27 108.52,228.78 106.92,228.78 105.52,227.38 101.05,227.38 100.59,227.84 100.59,228.19 100.69,228.29 v1(101.05,228.29)
L_MDI_1+: length 41.7
  TOP w0.102: v1(111.57,231.52) 111.29,231.24 111.29,230.76 110.83,230.31 110.83,229.83 110.85,229.81 RTK_LAN.4 ; v1(125.72,238.12) 125.44,238.4 125.16,238.4 124.88,238.12 UU18.4 124.88,237.33 124.68,237.13 122.8,237.13 122.67,237.26 121.41,237.26 118.24,240.44 113.98,240.44 113.14,239.6 113.14,238.86 112.04,237.76 111.39,237.76 111.26,237.89 110.88,237.89 110.61,237.62 NIC_USB.12
  BOTTOM w0.102: v1(111.57,231.52) 111.25,231.52 111.11,231.67 111.11,231.93 114.12,234.95 119.21,234.95 120.98,236.72 124.41,236.72 125.08,237.39 125.08,238.33 125.26,238.52 125.6,238.52 125.72,238.4 v1(125.72,238.12)
L_MDI_1-: length 41.7
  TOP w0.102: v1(125.72,239.04) 125.43,238.76 124.01,238.76 123.68,239.09 123.28,239.09 123,238.81 UU18.6 122.74,237.62 121.56,237.62 118.38,240.79 113.83,240.79 112.79,239.75 112.79,239.01 111.9,238.12 111.54,238.12 111.29,238.37 111.29,238.8 NIC_USB.13 ; v1(110.65,231.52) 110.93,231.24 110.93,230.91 110.47,230.45 110.47,229.83 110.45,229.81 RTK_LAN.5
  BOTTOM w0.102: v1(125.72,239.04) 125.54,238.87 125.12,238.87 124.72,238.48 124.72,237.54 124.27,237.08 120.84,237.08 119.06,235.31 113.98,235.31 110.75,232.08 110.75,231.62 v1(110.65,231.52)
L_MDI_2+: length 34.8
  TOP w0.102: v1(102.4,228.22) 102.67,228.5 102.67,228.83 102.45,229.06 UU17.4 102.01,229.06 101.4,229.67 101.4,231.13 101.53,231.27 101.53,231.8 101.87,232.13 104.25,232.13 105.27,233.15 108.21,233.15 109.81,234.75 112.71,234.75 114.18,236.22 114.18,237.81 113.95,238.04 113.57,238.04 113.15,237.62 NIC_USB.14 ; v1(109.94,231.01) 109.68,230.76 109.68,230.53 110.02,230.2 110.02,229.41 110.03,229.39 110.05,229.39 RTK_LAN.6
  BOTTOM w0.102: v1(102.4,228.22) 102.47,228.3 102.47,228.75 102.96,229.23 105.32,229.23 106.36,230.28 106.36,230.53 107.68,231.85 109.55,231.85 109.89,231.52 109.89,231.06 v1(109.94,231.01)
L_MDI_2-: length 34.8
  TOP w0.102: RTK_LAN.7 109.65,229.46 109.66,229.47 109.66,230.05 109.33,230.38 109.33,230.71 v1(109.02,231.01) ; v1(103.31,228.22) 103.03,228.5 103.03,229.92 103.36,230.25 103.36,230.66 103.08,230.94 UU17.6 101.89,231.19 101.89,231.65 102.01,231.78 104.4,231.78 105.41,232.79 108.36,232.79 109.96,234.39 112.86,234.39 114.54,236.07 114.54,239.27 NIC_USB.15
  BOTTOM w0.102: v1(103.31,228.22) 103.31,228.09 103.21,227.99 102.98,227.99 102.83,228.14 102.83,228.6 103.11,228.88 105.46,228.88 106.71,230.13 106.71,230.38 107.83,231.5 109.41,231.5 109.53,231.37 109.53,231.17 109.38,231.01 v1(109.02,231.01)
L_MDI_3+: length 38.3
  TOP w0.102: v1(125.72,235.3) 125.43,235.59 125.13,235.59 124.88,235.33 124.88,234.37 124.62,234.11 124.17,234.11 123.76,234.52 122.34,234.52 119.12,237.74 116.11,237.74 115.69,237.32 NIC_USB.16 ; v1(108.24,229.49) 108.11,229.62 107.81,229.62 107.65,229.46 107.65,229.08 108.13,228.6 RTK_LAN.9
  BOTTOM w0.102: v1(125.72,235.3) 125.72,235.48 125.53,235.66 121.54,235.66 120.94,235.06 120.94,233.5 120.18,232.74 114.15,232.74 111.29,229.88 108.82,229.88 108.63,230.07 107.98,230.07 107.75,229.84 107.75,229.57 107.93,229.39 108.14,229.39 v1(108.24,229.49)
L_MDI_3-: length 38.3
  TOP w0.102: v1(125.72,236.22) 125.44,235.94 125.21,235.94 125.01,236.14 123.25,236.14 123,235.89 123,235.05 122.82,234.87 122.49,234.87 119.27,238.09 116.47,238.09 116.26,238.29 116.26,238.7 NIC_USB.17 ; RTK_LAN.10 108.03,228.2 107.22,229.01 v1(107.22,229.51)
  BOTTOM w0.102: v1(107.22,229.51) 107.3,229.51 107.4,229.62 107.4,229.99 107.84,230.43 108.77,230.43 108.97,230.23 111.14,230.23 114,233.1 120.03,233.1 120.58,233.65 120.58,235.2 121.39,236.02 125.51,236.02 v1(125.72,236.22)
LAD0_MISO: length 3.7
  TOP w0.102: UF1.24 32.09,91.77 32.29,91.57 RF41.2 31.9,90.36 v1(31.2,89.66)
LAD1_MOSI: length 1.9
  TOP w0.102: RF39.2 31.02,93.6 31.53,94.11 UF1.21
LAD2_SPIIRQ: length 2.2
  TOP w0.102: RF45.2 31.07,96.65 v1(31.2,96.52) 31.2,96.22 31.8,95.61 UF1.18
LAN_DISABLE#: length 161.9
  TOP w0.089: v1(51.14,127.97) 51.45,128.27 U4.AR15
  TOP w0.102: v1(49.69,169.27) 50.48,170.05 54.67,170.05 55.51,170.89 55.51,173.13 52.04,176.59 49.26,176.59 48.55,177.3 48.55,178.41 48.15,178.81 48.15,180.45 v1(48.36,180.66) ; RL37.1 51.98,250.19 v1(50.58,248.79) ; v1(38.39,143.64) 37.88,143.13 37.88,141.55 38.96,140.46 v1(39.28,140.46) ; v1(46.31,159.07) 44.11,156.88 44.11,155.88 v1(43.98,155.74)
  BOTTOM w0.089: 43.37,137.31 43.37,137.16 43.87,136.65 43.87,134.85 44.21,134.51 44.33,134.51 46.86,131.98 50.27,131.98 50.83,131.42 50.93,131.42 v2(51.29,131.06) 51.67,130.68 51.67,130.3 51.34,129.97 51.34,129.49 51.67,129.16 51.67,128.65 51.21,128.19 51.21,128.04 v1(51.14,127.97)
  BOTTOM w0.102: 43.37,137.31 43.37,138.23 42.91,138.68 42.91,141.1 41.89,142.11 39.53,142.11 39.02,141.6 39.02,140.72 v1(39.28,140.46) ; v1(46.31,159.07) 49.19,159.07 50.48,160.35 50.48,168.48 v1(49.69,169.27) ; v1(43.98,155.74) 43.98,155.12 41.77,152.91 40.45,152.91 39.1,151.56 37.98,150.43 37.98,144.04 v1(38.39,143.64) ; v1(50.58,248.79) 49.51,248.79 47.4,246.69 47.4,243.59 47.91,243.08 47.91,240.79 47.4,240.28 47.4,228.83 49.54,226.69 49.54,220.66 48.06,219.19 48.06,206.55 47.84,206.33 47.84,195 46.46,193.62 46.46,192.99 47.96,191.49 47.96,181.05 v1(48.36,180.66)
LAN_DISABLE#_R: length 4.5
  TOP w0.508: RL38.1 54.26,251.27 54.58,251.59 RL37.2 v1(55.53,250.19) CL52.1
LAN_QL5_B: length 7.6
  TOP w0.508: RL38.2 RL39.2 v1(54.19,253.3) 54.96,253.3 QL4.C 56.68,253.87 58.01,252.54 58.01,251.59
LAN_QL5_C: length 7.1
  TOP w0.508: QL5.C QL6.C 62.96,253.3 v1(63.52,253.3) RL40.2 RL42.1
LAN_QL6_B: length 3.1
  TOP w0.508: 61.44,251.59 61.56,251.46 CL53.1 v1(60.74,250.19) RL41.2
LAN_QL7_G: length 11.8
  TOP w0.508: RL42.2 64.74,251.21 CL54.1 v1(65.67,249.26) 69.21,249.26 69.57,249.62 CL55.2 69.57,252.22 QL7.G
  BOTTOM w0.102: v1(65.67,249.26) v2(64.94,248.53)
LAN_WAKE#: length 189.3
  TOP w0.089: U4.BD11 46.81,130.04 46.69,130.04 46.64,130 45.37,130 v1(44.58,130.78)
  TOP w0.102: v1(101.63,219.96) 102.01,220.34 103.16,220.34 103.41,220.09 103.41,219.71 104.02,219.1 105.06,219.1 106.48,220.52 106.48,221.2 RL3.2 106.97,222.33 107.14,222.5 108.93,222.5 110.47,224.04 110.47,224.46 110.85,224.84 RTK_LAN.21 ; v1(38.39,142.88) 38.11,142.59 38.11,141.64 38.78,140.97 39.4,140.97 39.78,140.59 39.78,139.64 41.17,138.26 v1(41.17,137.44) ; v1(66.33,167.64) 65.92,167.64 62.49,171.07 59.46,171.07 56.08,167.69 52.63,167.69 51.64,166.7 50.52,166.7 48.75,164.92 46.51,164.92 44.53,162.94 44.36,162.94 40.67,159.26 40.67,156.92 42.07,155.52 v1(42.07,153.92)
  BOTTOM w0.089: v1(44.58,130.78) 44.34,130.78 43.23,131.89
  BOTTOM w0.102: v1(66.33,167.64) 66.33,169.49 70.75,173.91 72.42,173.91 74.71,176.2 74.71,179.94 74.71,204.09 v2(74.33,204.47) 73.57,205.23 73.57,219.46 74.89,220.78 74.89,226.66 76.11,227.88 76.11,230.89 77.73,232.51 78.93,232.51 79.69,231.75 83.78,231.75 84.77,232.74 85.91,232.74 86.11,232.94 86.11,233.98 86.49,234.37 87.74,234.37 90.75,231.35 90.75,228.16 98.47,220.45 101.15,220.45 v1(101.63,219.96) ; 43.23,131.89 42.96,132.16 42.96,135.51 42.81,135.66 42.1,135.66 41.17,136.59 v1(41.17,137.44) ; v1(38.39,142.88) 37.75,143.51 37.75,150.53 40.51,153.29 41.44,153.29 v1(42.07,153.92)
LANE0_N: length 6.2
  TOP w0.102: RTK_VGA.30 148.59,224.17 148.44,224.32 147.13,224.32 v1(146.72,223.9) 145.45,223.9 144.97,223.42 143.67,223.42 143.49,223.24 CG4.2
LANE0_P: length 6.2
  TOP w0.102: RTK_VGA.29 148.6,224.67 148.45,224.52 147.05,224.52 146.89,224.36 146.54,224.36 146.29,224.1 145.02,224.1 v1(144.81,223.9) 144.53,223.62 143.67,223.62 143.49,223.8 CG3.2
LANE1_N: length 6.1
  TOP w0.102: RTK_VGA.32 148.6,223.17 148.45,223.32 148.16,223.32 v1(146.72,221.87) 146.12,221.87 145.91,221.67 145.24,221.67 144.97,221.39 144.1,221.39 144,221.28 CG6.2
LANE1_P: length 6.1
  TOP w0.102: CG5.2 144,221.69 144.1,221.59 144.53,221.59 v1(144.81,221.87) 145.83,221.87 146.03,222.07 146.29,222.07 146.59,222.38 146.94,222.38 148.08,223.52 148.44,223.52 148.59,223.67 RTK_VGA.31
LD_FP_RST#_R: length 4.2
  TOP w0.102: RST_SWH.1 9.56,117.92 CB5.1 RB16.2 10.96,117.67 v1(10.96,117.35)
LD_LPC_DEBUG_PIN2: length 3.1
  TOP w0.102: LPC_DEBUG.2 v1(12.25,156.08) RB12.1
LD_LPC_DEBUG_PIN6: length 3.6
  TOP w0.102: RB13.1 v1(12.3,151) 10.99,151 LPC_DEBUG.6
LD_SIO_24M_CLOCKI_R: length 7
  TOP w0.102: RB11.2 CB1.1 v1(11.87,158.12) 9.94,158.12 LPC_DEBUG.1
LDO2_C: length 7.6
  TOP w0.203: UA1.39 188.96,22.43 189.01,22.38
  TOP w0.254: v1(192.64,17.61) 192.64,19.43 191.96,20.11 CA3.1 191.46,20.37 190.18,21.64 190.18,22.13 189.92,22.38 189.01,22.38
LDO_EN: length 4.2
  TOP w0.102: RTK_VGA.21 151.18,227.82 v1(150.4,228.6) 149.34,229.66 RG9.2 149.34,230.76 RG10.1
LED_M2_SSD_ACT_N: length 5.1
  TOP w0.102: v1(111.29,129.16) 111.14,129.3 M.2_SSD.10 111.14,131.37 RM6.2 113.06,133.29 RM8.2
LED_YELLOW_R: length 2.1
  TOP w0.508: PR232.2 v1(13.37,34.67) 12.53,34.67 AUX_PWR1.1
LINE1-L: length 7.6
  TOP w0.203: UA1.22 181.77,22.43 181.49,22.15
  TOP w0.254: 181.49,22.15 181.32,22.15 180.63,21.47 v1(178.09,21.47) 176.23,21.47 CA123.1
LINE1-L_J: length 8.7
  TOP w0.254: DA4.2 190.53,12.72 CA121.1 IO_FBI9.2 189.64,11.38 v1(189.01,10.75)
  BOTTOM w0.254: F_AUDIO.1 186.32,11.44 187.39,10.37 188.63,10.37 v1(189.01,10.75)
LINE1-R: length 9.4
  TOP w0.203: 181.46,22.66 181.63,22.83 UA1.21
  TOP w0.254: CA122.1 174.4,20.91 175.47,21.97 v1(180.3,21.97) 180.38,21.97 181.06,22.66 181.46,22.66
LINE1-R_J: length 18.8
  TOP w0.254: DA4.1 190.41,13.86 189.96,14.3 187.99,14.3 187.61,13.92 187.61,13.42 188.25,12.78 CA120.1 188.25,12.08 188.37,11.95 IO_FBI10.2 186.42,9.48 185.2,9.48 181.27,5.54 178.82,5.54 F_AUDIO.2
LINE1-VREFO-L: length 4
  TOP w0.203: UA1.31 185.78,19.7 185.69,19.6
  TOP w0.254: RA77.1 186.06,17.47 185.58,17.95 v1(185.58,18.88) 185.58,19.49 185.69,19.6
LINE1-VREFO-R: length 6.5
  TOP w0.203: UA1.30 185.38,19.85 185.28,19.75
  TOP w0.254: 185.28,19.75 185.07,19.54 185.07,17.74 185.38,17.42 185.38,16.47 RA76.1 186.02,15.71 v1(185.48,15.17)
LINE2-JD: length 332.9
  TOP w0.254: v1(177.2,27.89) 177.64,27.45 RA15.2
  BOTTOM w0.254: v1(177.2,27.89) 179.36,25.73 179.36,21.93 180.23,21.06 181.19,21.06 181.97,20.27 185.25,20.27 186.6,18.92 186.6,18.54 188.5,16.64 189.22,16.64 192.06,13.8 192.06,7.19 193.58,5.67 202.68,5.67 204.12,7.11 204.12,10.24 205.65,11.76 221.65,11.76 223.68,9.73 231.55,9.73 232.82,11 232.82,25.53 234.22,26.92 239.05,26.92 242.63,30.51 242.63,210.29 230.13,222.78 230.13,229.17 232.95,231.99 232.95,237.74 233.33,238.12 233.33,247.11 236.17,249.94 REAR_AUDIO.4
LINE2-L: length 7.5
  TOP w0.203: UA1.24 182.35,21.63 182.15,21.43 v1(182.15,21.08)
  TOP w0.254: CA85.1 177.58,19.68 178.23,19.03 179.74,19.03 181.27,20.56 181.63,20.56 v1(182.15,21.08)
LINE2-R: length 4.6
  TOP w0.203: 181.66,21.67 182.02,22.03 UA1.23
  TOP w0.254: 181.66,21.67 180.52,20.53 CA83.1 179.1,19.89 v1(179.1,19.69)
LPC_AD0: length 307.2
  TOP w0.102: v1(24.45,142.56) 23.98,142.56 22.59,141.17 15.32,141.17 14.96,141.54 RB18.1 RB17.1 ; SIO_5553.8 213.29,40.29 v1(213.46,40.45) ; R6375.1 29.56,122.43 19.59,122.43 v1(19.34,122.17)
  BOTTOM w0.102: v1(213.46,40.45) 213.18,40.45 212.43,41.2 210.91,41.2 209.71,40 205.65,40 204.76,40.9 200.38,40.9 188.72,52.56 178.2,52.56 177.45,53.31 172.95,53.31 168.86,49.23 162.65,49.23 162.08,48.65 156.62,48.65 153.94,51.34 134.48,51.34 133.94,50.8 120.23,50.8 119.32,49.9 115.67,49.9 111.25,54.31 91.43,54.31 87.41,58.33 85.49,58.33 79.27,64.55 72.32,64.55 70.64,66.22 60.28,66.22 55.41,66.22 55.09,66.54 46.3,66.54 45.48,67.36 39.19,67.36 32.85,73.7 32.85,76.35 28.43,80.77 28.43,83.59 28.2,83.81 28.2,86.32 28.75,86.87 28.75,90.9 27.67,91.98 27.09,91.98 25.48,93.59 25.48,98.3 17.46,106.33 17.46,114.99 19.64,117.17 19.64,121.87 v1(19.34,122.17) 18.42,123.09 18.42,124.56 19.97,126.11 19.97,137.49 24.45,141.97 v1(24.45,142.56)
LPC_AD0_DEBUG: length 16.3
  TOP w0.102: RB17.2 v1(12.05,142.37) 11.21,141.53 8.87,141.53 6.81,143.59 6.81,150.99 LPC_DEBUG.5
LPC_AD0_TCM: length 20.3
  TOP w0.102: RB18.2 v1(16.54,142.37) ; v1(25.31,155.7) 25.06,155.46 UF2.27
  BOTTOM w0.102: v1(25.31,155.7) 24.67,155.07 24.67,152.91 22.25,150.48 19.91,150.48 v2(19.06,149.63) 19.06,148.96 18.46,148.36 18.46,146.82 17.69,146.05 17.69,145.54 17.98,145.25 17.98,143.8 v1(16.54,142.37)
LPC_AD1: length 309
  TOP w0.102: R6378.1 30.11,122.6 29.96,122.6 v1(29.5,123.06) 27.2,123.06 26.8,122.66 19.49,122.66 v1(19.34,122.81) ; v1(214.03,41.15) 214.03,40.33 213.69,40 SIO_5553.9 ; v1(24.8,143.26) 24.35,143.26 22.49,141.4 20.22,141.4 18.75,142.88 15.46,142.88 RB20.1 RB19.1
  BOTTOM w0.102: v1(24.8,143.26) 25.04,143.01 25.04,142.22 20.2,137.38 20.2,125.65 19.29,124.73 19.29,122.86 v1(19.34,122.81) 19.87,122.28 19.87,116.94 17.69,114.76 17.69,106.42 25.71,98.4 25.71,93.68 27.18,92.21 27.76,92.21 28.98,91 28.98,86.77 28.43,86.23 28.43,83.91 28.66,83.68 28.66,80.86 33.08,76.44 33.08,73.79 39.28,67.58 45.57,67.58 46.39,66.76 55.19,66.76 55.5,66.45 60.06,66.45 70.74,66.45 72.39,64.8 79.34,64.8 85.58,58.56 87.55,58.56 91.57,54.54 111.35,54.54 115.76,50.13 119.23,50.13 120.13,51.03 133.84,51.03 134.38,51.57 154.03,51.57 156.71,48.88 161.98,48.88 162.55,49.45 168.77,49.45 172.86,53.54 177.54,53.54 178.3,52.79 188.81,52.79 200.47,41.13 204.85,41.13 205.75,40.23 209.59,40.23 210.92,41.55 213.62,41.55 v1(214.03,41.15)
LPC_AD1_DEBUG: length 13.6
  TOP w0.102: LPC_DEBUG.7 7.52,150.08 7.04,149.61 7.04,143.71 8.16,142.6 10.76,142.6 11.55,143.38 RB19.2
LPC_AD1_TCM: length 16.3
  TOP w0.102: RB20.2 v1(16.54,143.38) ; UF2.24 23.75,153.19 v1(24.04,152.91)
  BOTTOM w0.102: v1(16.54,143.38) 16.54,143.76 17.38,144.6 17.38,146.07 18.23,146.92 18.23,148.05 17.89,148.39 17.89,149.35 19.25,150.71 22.14,150.71 24.04,152.61 v1(24.04,152.91)
LPC_AD2: length 311.5
  TOP w0.102: R6380.1 27.39,123.57 26.73,122.91 20.12,122.91 v1(19.72,123.32) ; SIO_5553.10 214.09,40.07 v1(214.79,40.77) ; v1(24.93,144.45) 24.57,144.45 22.21,142.09 20.51,142.09 16.67,145.92 15.46,145.92 RB22.1 RB21.1
  BOTTOM w0.102: v1(214.79,40.77) 214.79,41.02 214.03,41.78 210.82,41.78 209.5,40.46 205.84,40.46 204.95,41.36 200.57,41.36 188.91,53.02 178.39,53.02 177.64,53.77 172.76,53.77 168.67,49.68 162.43,49.68 161.86,49.11 156.81,49.11 154.13,51.79 134.26,51.79 133.86,51.39 133.86,51.39 133.73,51.26 120.02,51.26 119.12,50.36 115.86,50.36 111.44,54.77 91.66,54.77 87.64,58.79 85.68,58.79 79.44,65.03 72.48,65.03 70.83,66.68 59.83,66.68 55.6,66.68 55.28,66.99 46.49,66.99 45.67,67.81 39.38,67.81 33.31,73.88 33.31,76.54 28.89,80.96 28.89,83.78 28.66,84 28.66,86.13 29.2,86.68 29.2,91.09 27.86,92.44 27.28,92.44 26.12,93.6 26.12,98.31 17.91,106.52 17.91,114.67 20.1,116.85 20.1,122.94 v1(19.72,123.32) 19.54,123.49 19.54,124.66 20.43,125.55 20.43,137.26 25.27,142.1 25.27,144.1 v1(24.93,144.45)
LPC_AD2_DEBUG: length 6.6
  TOP w0.102: LPC_DEBUG.9 10.07,148.08 11.72,146.43 RB21.2 12.92,146.9 v1(12.61,147.22)
LPC_AD2_TCM: length 11.3
  TOP w0.102: RB22.2 16.92,147.51 v1(16.92,148.08) ; UF2.21 22.25,153.04 v1(22.39,152.91)
  BOTTOM w0.102: v1(16.92,148.08) 16.92,148.16 17.43,148.67 17.43,149.54 19.31,151.42 19.31,151.79 19.69,152.17 21.65,152.17 v1(22.39,152.91)
LPC_AD3: length 320.8
  TOP w0.102: v1(26.27,145.82) 26.27,145.11 25.13,143.97 24.41,143.97 22.3,141.86 20.41,141.86 17.36,144.91 15.46,144.91 RB24.1 RB23.1 ; v1(214.38,42.47) 214.74,42.47 215.3,41.91 215.3,39.41 214.49,38.61 SIO_5553.11 ; R6383.1 32.28,124.03 27.41,124.03 26.55,123.17 20.76,123.17 v1(19.97,123.95)
  BOTTOM w0.102: v1(26.27,145.82) 26.2,145.75 26.2,142.68 20.66,137.15 20.66,125.46 19.97,124.77 v1(19.97,123.95) 20.35,123.57 20.35,116.78 18.14,114.57 18.14,106.61 26.35,98.41 26.35,93.69 27.37,92.67 28.24,92.67 28.33,92.76 29.01,92.76 29.43,92.34 29.43,86.58 28.89,86.04 28.89,84.1 29.12,83.87 29.12,81.05 33.54,76.63 33.54,73.98 39.47,68.04 45.76,68.04 46.58,67.22 55.38,67.22 55.69,66.91 59.6,66.91 70.92,66.91 72.58,65.26 79.53,65.26 85.77,59.02 87.74,59.02 91.76,55 111.54,55 115.95,50.58 119.01,50.58 119.91,51.49 133.63,51.49 134.17,52.02 154.22,52.02 156.9,49.34 161.77,49.34 162.34,49.91 168.58,49.91 172.67,54 177.73,54 178.49,53.25 189,53.25 200.66,41.59 205.04,41.59 205.94,40.69 209.4,40.69 210.72,42.01 211.21,42.01 212.25,43.05 213.8,43.05 v1(214.38,42.47)
LPC_AD3_DEBUG: length 5.6
  TOP w0.102: RB23.2 11.08,145.41 10.7,145.03 8.96,145.03 LPC_DEBUG.11
LPC_AD3_TCM: length 12
  TOP w0.102: UF2.19 21.25,153.05 v1(21.12,152.91) ; RB24.2 v1(16.54,145.41)
  BOTTOM w0.102: v1(21.12,152.91) 20.61,152.4 19.6,152.4 19.08,151.89 19.08,151.52 17.2,149.64 17.2,149.02 16.42,148.23 16.42,147.09 16.04,146.71 16.04,145.92 v1(16.54,145.41)
LPC_FRAME#: length 319.9
  TOP w0.102: R6388.1 32.94,124.26 27.32,124.26 26.46,123.39 21.16,123.39 v1(20.61,123.95) ; SIO_5553.12 214.89,38.46 216.06,39.62 v1(216.06,40.51) ; RB25.1 RB26.1 15.46,143.89 16.72,143.89 17.41,143.21 18.74,143.21 20.32,141.63 22.4,141.63 24.5,143.74 25.28,143.74 27.03,145.49 v1(27.03,146.02)
  BOTTOM w0.102: v1(216.06,40.51) 216.06,41.55 214.18,43.43 212.31,43.43 211.11,42.24 210.63,42.24 209.31,40.92 206.03,40.92 205.12,41.83 202.06,41.83 200.69,43.21 199.37,43.21 189.05,53.52 178.53,53.52 177.83,54.23 172.57,54.23 168.48,50.14 162.24,50.14 161.67,49.57 157,49.57 154.32,52.25 134.05,52.25 133.51,51.71 119.81,51.71 119.06,50.96 118.92,50.83 116.04,50.83 111.63,55.23 91.85,55.23 87.83,59.25 85.87,59.25 79.63,65.49 72.67,65.49 71.02,67.14 59.37,67.14 55.78,67.14 55.47,67.45 46.68,67.45 45.86,68.27 39.57,68.27 33.76,74.07 33.76,76.73 29.34,81.15 29.34,83.97 29.12,84.19 29.12,85.94 29.66,86.49 29.66,92.8 26.58,95.88 26.58,98.53 18.37,106.73 18.37,114.48 20.61,116.71 v1(20.61,123.95) 20.89,124.23 20.89,137.03 26.47,142.62 26.47,145.15 27.03,145.71 v1(27.03,146.02)
LPC_FRAME#_DEBUG: length 6.2
  TOP w0.102: RB25.2 12.58,144.74 v1(12.19,144.74) 10.57,143.13 8.86,143.13 LPC_DEBUG.13
LPC_FRAME#_TCM: length 15.3
  TOP w0.102: UF2.23 23.25,153.06 v1(23.4,152.91) ; RB26.2 v1(16.54,144.4)
  BOTTOM w0.102: v1(23.4,152.91) 23.4,152.3 22.04,150.94 20.51,150.94 v2(20.05,151.4) 19.61,151.4 17.66,149.45 17.66,148.3 18,147.96 18,147.01 17.13,146.14 17.13,144.98 v1(16.54,144.4)
M2_DEVSLP: length 5.4
  TOP w0.102: RM5.2 101.51,132.21 102.23,131.49 v1(103.91,131.49) 104.14,131.25 M.2_SSD.38
  BOTTOM w0.102: v1(103.91,131.49) 103.62,131.19 v2(103.16,131.19)
M2_PE_WAKE#: length 2.6
  TOP w0.102: M.2_SSD.54 100.14,131.73 RM4.2 v1(99.92,132.78)
M2_Q1_C: length 4
  TOP w0.102: v1(110.84,131.83) 110.59,132.08 RM7.2 109.76,133.29 QM2.6 110.29,133.59 110.4,133.69 110.4,134.14 110.29,134.24 QM2.5
M2_Q1A_B: length 1.8
  TOP w0.102: 111.79,134.24 112.17,134.24 v1(112.68,133.73) 112.75,133.73 RM8.1
M2_Q2_B: length 4.6
  TOP w0.102: RM2.1 100.1,144.08 100.21,143.97 v1(100.21,142.57) 100.07,142.43 QM1.B
  BOTTOM w0.102: v2(100.46,141.73) 100.46,142.32 v1(100.21,142.57)
M2_SATA_RXN3_C: length 3.6
  TOP w0.102: CM3.1 104.47,121.73 104.58,121.84 104.58,122.03 104.13,122.48 103.3,122.48 103.04,122.74 103.04,122.97 102.89,123.12 M.2_SSD.43
M2_SATA_RXP3_C: length 3.7
  TOP w0.102: CM4.1 104.88,121.73 104.78,121.83 104.78,122.12 104.22,122.68 103.39,122.68 103.25,122.82 103.25,122.97 103.39,123.12 M.2_SSD.41
M2_SATA_TXN3_C: length 3.2
  TOP w0.102: M.2_SSD.47 101.89,123.12 101.75,122.97 101.75,122.88 101.92,122.71 102.29,122.71 102.75,122.25 102.75,121.83 102.85,121.73 CM2.1
M2_SATA_TXP3_C: length 3.2
  TOP w0.102: M.2_SSD.49 101.39,123.15 101.54,123 101.54,122.8 101.84,122.5 102.2,122.5 102.55,122.16 102.55,121.83 102.45,121.73 CM1.1
M.2_PEDET: length 26.4
  TOP w0.102: RM3.2 100.81,144.91 RM1.2 RM2.2 99.73,144.78 97.7,142.75 97.7,141.81 97.43,141.54 97.43,140.39 95.84,138.8 95.84,136.32 v1(96.48,135.69) ; M.2_SSD.69 96.39,124.5 97.37,125.48 v1(97.37,132.77)
  BOTTOM w0.102: v1(97.37,132.77) 96.48,133.65 v2(96.48,134.77) v1(96.48,135.69)
M.2_SSD_PEDET: length 135.5
  TOP w0.102: v1(66.84,99.44) 66.4,99.88 66.33,99.95 65.95,99.95 65.39,99.39 59.84,99.39 59.28,98.82 59.28,98.07 58.74,97.54 56.76,97.54 55.44,96.22 53.36,96.22 52.65,95.5 49.6,95.5 49.14,95.96 v1(48.34,95.96) ; v1(87.31,132.87) 87.93,132.24 87.93,128.53 89.36,127.09 89.36,126.28 89.49,126.15 89.49,114.61 85.66,110.77 85.66,108.87 88.2,106.32 89.32,106.32 93.76,101.88 93.76,95.68 88.88,90.81 87.06,90.81 85.48,89.23 84.79,89.23 v1(84.36,89.66) ; v1(96.55,136.32) 96.42,136.46 96.42,139.06 97.66,140.3 97.66,140.88 98.25,141.48 QM1.C 100.87,141.94 100.74,142.06 RM1.1 ; v1(47.91,103.12) 48.29,103.5 RP26.2
  BOTTOM w0.102: v1(47.91,103.12) 47.91,101.22 47.4,100.71 47.4,98.99 47.84,98.56 47.84,98.25 48.67,97.41 48.67,96.29 v1(48.34,95.96) ; v1(66.84,99.44) 67.01,99.62 71.26,99.62 72.07,98.81 74.54,98.81 76.54,96.82 76.54,96.17 82.71,89.99 83.07,89.99 84.03,89.99 v1(84.36,89.66) ; v1(96.55,136.32) 97.85,135.03 97.85,132.59 97.54,132.28 96.31,132.28 94.72,133.87 91.59,133.87 90.41,132.69 v2(89.7,132.69) 87.49,132.69 v1(87.31,132.87)
