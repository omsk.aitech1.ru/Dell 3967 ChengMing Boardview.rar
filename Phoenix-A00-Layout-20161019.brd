# Allegro board Phoenix-A00-Layout-20161019.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
O_DSR1#: length 21.2
  TOP w0.102: UO2.4 179.26,230.73 v1(179.1,230.89) 178.74,231.25 CNO1.6
  BOTTOM w0.102: VGA_COM.A6 187.18,243.08 185.2,243.08 182.91,240.79 182.91,238.25 179.77,235.11 179.77,231.56 v1(179.1,230.89)
O_DSR1#_R: length 247
  TOP w0.102: v1(189.77,229.49) 189.77,230.25 189.29,230.73 UO2.17 ; v1(220.05,49.91) 219.92,50.04 212.61,50.04 211.75,50.89 SIO_5553.97
  BOTTOM w0.102: v1(220.05,49.91) 220.05,50.55 220.35,50.85 221.01,50.85 224.89,54.73 224.89,63.33 227.93,66.38 227.93,69.98 226.4,71.52 226.4,76.13 226.97,76.71 226.97,86.25 227.39,86.66 227.39,91.86 224.44,94.81 224.44,102.83 228.81,107.19 228.81,110.14 233.21,114.54 233.21,126.8 231.15,128.85 231.15,134.8 232.61,136.27 234.52,136.27 238.59,140.34 238.59,208.56 225.66,221.48 v2(225.66,222.05) 225.66,222.64 221.24,227.06 221.24,228.49 220.07,229.67 189.95,229.67 v1(189.77,229.49)
O_DTR1#: length 14.1
  TOP w0.102: UO2.6 179.43,229.43 v1(179.1,229.11) 179.03,229.04 CNO2.2
  BOTTOM w0.102: v1(179.1,229.11) 178.67,229.54 178.67,235.15 181.37,237.85 VGA_COM.A4
O_DTR1#_R: length 256.4
  TOP w0.102: v1(189.26,227.84) 189.52,228.09 189.52,228.98 189.06,229.43 UO2.15 ; RO27.2 212.03,54.25 v1(212.03,53.82) ; v1(216.95,48.64) 211.61,48.64 211.36,48.89 SIO_5553.102 208.19,48.89 207.27,49.81 207.27,50.69 208.27,51.69 v1(208.69,51.69)
  BOTTOM w0.102: v1(208.69,51.69) 210.15,51.69 212.03,53.57 v1(212.03,53.82) ; v1(189.26,227.84) 189.69,227.41 191.47,227.41 191.8,227.08 193.96,227.08 195.64,228.75 219.69,228.75 220.33,228.11 220.33,226.67 224.39,222.6 224.39,221.39 236.91,208.88 v2(236.91,207.64) 237.68,206.88 237.68,140.74 234.12,137.19 232.24,137.19 230.18,135.13 230.18,128.19 232.29,126.08 232.29,114.92 227.9,110.52 227.9,107.57 223.53,103.2 223.53,94.43 226.47,91.49 226.47,87.17 226.06,86.75 226.06,77.09 225.48,76.51 225.48,71.07 226.86,69.7 226.86,66.85 223.97,63.97 223.97,56.38 223.08,55.48 222.59,55.48 221.17,54.06 221.17,53.84 219.86,52.53 218.93,52.53 218.02,51.61 218.02,50.85 216.95,49.78 v1(216.95,48.64)
O_FIO_SATA_LED#: length 303.1
  TOP w0.102: v1(86.16,55.53) 86.16,56.18 78.54,63.8 78.54,80.65 77.1,82.09 76.31,82.09 75.6,82.8 v1(75.47,82.8) ; v1(202.47,21.8) 202.31,21.64 202.31,16.25 201.3,15.24 200.49,15.24 200.31,15.42 199.26,15.42 198.86,15.03 198.86,13.88 199.22,13.53 QO6.3 200.31,12.72 CO53.1 199.49,11.89 199.11,11.89 198.64,11.43 HDD_LED.2 202.03,10.97 203.87,12.81 203.87,14.25 204.35,14.74 RNO2.4 ; v1(94.37,105.49) 94.6,105.26 101.59,105.26 103.16,106.83 103.16,113.92 111.41,122.17 115.36,122.17 116.44,123.26 116.44,127.43 115.22,128.65 115.22,129.41 114.08,130.56 114.08,134.28 113.47,134.89 111.79,134.89
  BOTTOM w0.102: v1(86.16,55.53) 86.54,55.53 93.14,48.92 96.15,48.92 97.5,50.27 109.77,50.27 115.4,44.63 118.66,44.63 120.33,42.95 135.79,42.95 136.5,42.24 138.56,42.24 139.6,41.21 145.16,41.21 146.19,42.24 150.19,42.24 151.16,41.28 153.26,41.28 154.3,40.23 173.76,40.23 176.99,43.47 182.26,43.47 185.73,40 187.51,40 197.57,29.95 202.75,29.95 203.23,29.46 203.23,22.56 v1(202.47,21.8) ; v1(94.37,105.49) 93.94,105.05 93.33,105.05 92.36,106.02 92.36,108.31 91.83,108.84 89.01,108.84 88.5,108.33 88.17,108.33 87,107.16 82.51,107.16 77.4,102.06 77.4,96.52 83.07,90.86 85.58,90.86 87.18,89.26 87.18,85.93 84.44,83.19 75.85,83.19 v1(75.47,82.8)
O_FP_CBL_DET#_SIO: length 4
  TOP w0.102: v1(222.69,45.14) 222.85,45.29 SIO_5553.50 225.16,45.29 225.33,45.47 RO176.1
O_GREEN#: length 42.7
  TOP w0.102: QO12.2 219.43,15.67 219.55,15.8 220.32,15.8 220.7,16.18 220.7,16.49 CO52.1 221.4,17.19 RNO5.8 223.03,16.51 224.32,16.51 224.82,17.02 224.82,23.75 220.81,27.76 219.54,27.76 218.37,28.93 218.37,34.5 219.69,35.82 SIO_5553.24 219.69,37.91 218.39,39.22 v1(218.27,39.22) ; SIO_5553.2 210.89,37.81 211.72,38.63 v1(211.79,38.63)
  BOTTOM w0.102: v1(211.79,38.63) 211.79,38.66 212.12,38.99 218.04,38.99 v1(218.27,39.22)
O_GREEN#_CTL: length 5.3
  TOP w0.102: QO12.6 218.78,16.68 218.9,16.56 219.3,16.56 219.43,16.68 QO12.5 219.43,17.57 219.81,17.95 220.8,17.95 v1(221.05,17.7) RNO5.7
O_GREEN#_R: length 10.8
  TOP w0.102: PWR_SW.4 212.1,15.57 217.22,15.57 RIO9.2 218.03,15.36 218.03,14.78 218.41,14.4 219.71,14.4 220.08,14.77 QO12.3
O_MB_REG_PG: length 9.4
  TOP w0.102: RO16.1 206.09,51.82 206.09,46.26 206.61,45.74 207.29,45.74 v1(207.85,46.3) 208.06,46.09 SIO_5553.109
O_MB_REG_PG_R: length 22.7
  TOP w0.102: RO16.2 207.68,52.07 v1(209.2,53.59) RNO1.7 ; v1(201.84,53.21) 201.57,52.94 QO4.6 201.57,51.81 202.87,50.51 QO4.3 203.49,49.67 QO2.3 203.25,48.91 202.73,48.39 202.73,45.57 202.47,45.31 202.19,45.31 201.57,44.69 QO1.6
  BOTTOM w0.102: v1(209.2,53.59) 208.39,54.41 205.42,54.41 203.72,52.7 202.34,52.7 v1(201.84,53.21)
O_MEM_REG_PG: length 11.8
  TOP w0.102: SIO_5553.111 208.23,45.29 208.01,45.07 208.01,44.67 v1(207.72,44.39) 206.61,45.5 206.53,45.5 205.77,46.25 205.77,52.51 RO18.1
O_MEM_REG_PG_R: length 13.5
  TOP w0.102: QO1.3 203.67,46.3 205.21,46.3 205.54,46.63 v1(205.54,53.11) 206.03,53.59 206.73,53.59 RO18.2 208.19,53.09 208.69,53.59 RNO1.6
O_PCIAUX_CTRL: length 382.6
  TOP w0.102: v1(14.64,160.02) 14.64,160.66 14.33,160.96 13.57,160.96 11.34,163.19 11.34,182.36 10.09,183.62 7.3,183.62 5.75,185.17 5.75,208.34 PR31.2 6.26,209.87 PR35.1 ; RO99.1 215.3,56.13 216.33,57.16 QS11.D2 216.33,58.28 v1(215.81,58.8) 215.03,59.58 215.03,59.82 ; v1(15.98,83.79) 15.78,83.59 15.78,81.61 17.22,80.17 19.3,80.17 21.14,78.33 21.14,78.02 24.64,74.52 30.37,74.52 31.29,75.44 35.9,75.44 40.05,79.58 42.84,79.58 43.27,80 46.1,80 46.4,79.7 v1(46.6,79.7) ; QV72.D v1(211.23,60.2)
  BOTTOM w0.102: v1(46.6,79.7) 46.6,79.31 47.33,78.59 47.78,78.59 48.45,79.25 48.45,80.58 49.32,81.46 52.62,81.46 53.24,80.84 53.24,79.79 56.65,76.38 60.02,76.38 60.03,76.38 60.17,76.38 60.35,76.2 61.7,76.2 63.43,74.48 65.78,74.48 66.37,73.89 68.74,73.89 69.12,73.51 81.08,73.51 81.46,73.51 v2(82.98,71.99) 85.75,69.22 85.88,69.09 85.88,67.32 88.39,64.81 90.19,64.81 93.2,61.81 97.1,61.81 97.6,61.31 109.81,61.31 110.34,61.84 112.88,61.84 115.47,59.26 126.35,59.26 130.72,63.63 144.49,63.63 145.89,65.02 146.54,65.02 147.43,65.9 147.43,65.91 147.53,66.01 154.06,66.01 154.85,66.8 155.78,66.8 156.21,67.23 159.07,67.23 160.24,66.06 178.41,66.06 182.12,62.36 194.44,62.36 198.53,58.27 200.24,58.27 201.41,57.1 207.75,57.1 210.85,60.2 v1(211.23,60.2) 212.12,59.31 215.3,59.31 v1(215.81,58.8) ; v1(14.64,160.02) 14.05,159.44 14.05,157.43 15.33,156.16 15.33,152.33 13.98,150.98 13.98,149.23 14.13,149.08 14.13,140.94 10.96,137.77 10.96,126.26 12.99,124.23 12.99,111.62 12.45,111.09 12.45,103.15 6.26,96.96 6.26,90.42 10.87,85.8 15.12,85.8 15.78,85.14 15.78,84 v1(15.98,83.79)
O_PCIAUX_CTRL_R: length 5.2
  TOP w0.102: RO99.2 215.63,54.22 v1(215.63,53.77) 215.3,53.44 212.73,53.44 212.49,53.2 SIO_5553.91
O_PSON#: length 358.8
  TOP w0.102: RO9.1 229.59,47.62 228.57,46.61 v1(225.46,46.61) 225.33,46.61 225.22,46.49 SIO_5553.53 ; v1(11.97,76.2) 10.57,76.2 9.3,74.93 6.26,74.93 5.04,73.71 5.04,49.1 11.78,42.35 PR231.2 PC302.1 13.88,41.97 13.88,40.58 PQ71.G 13.18,37.34 16.48,37.34 17.24,36.58 20.31,36.58 ATX_SYS.8 ; v1(136.94,32.38) 137.19,32.64 137.19,33.52 119.15,51.56 v1(118.65,51.56)
  BOTTOM w0.102: v1(136.94,32.38) 136.4,31.85 130.7,31.85 129.96,32.59 117.7,32.59 117.45,32.33 98.96,32.33 90.97,40.32 89.58,40.32 83.68,46.23 82.01,46.23 78.81,49.43 72.39,49.43 66.92,54.9 60.54,54.9 60.14,55.3 59.04,55.3 58.45,55.89 44.52,55.89 43.92,56.49 36.31,56.49 29.44,63.36 23.45,63.36 20.22,66.59 20.22,69.02 15.15,74.09 15.15,75.31 14.26,76.2 v1(11.97,76.2) ; v1(225.46,46.61) 224.83,46.61 v2(224.44,46.23) 224.44,45.74 222.98,44.27 222.38,44.27 220.84,42.72 215.58,42.72 214.36,43.94 212.12,43.94 211.72,44.35 210.22,44.35 207.75,41.88 206.58,41.88 205.16,43.31 201.59,43.31 200.22,44.68 198.9,44.68 189.34,54.24 178.9,54.24 178.19,54.94 172.07,54.94 167.98,50.85 161.88,50.85 161.32,50.29 157.28,50.29 154.58,53 133.79,53 133.22,52.43 119.51,52.43 v1(118.65,51.56)
O_PWR2_PRSNT_R: length 20.8
  TOP w0.102: SIO_5553.108 208.39,46.49 208.07,46.81 207.6,46.81 207.41,46.63 207.41,46.3 207.1,45.99 206.69,45.99 206.32,46.35 206.32,50.39 208.28,52.35 209.29,52.35 209.71,52.77 RNO1.8 209.71,54.61 210.09,54.99 210.09,58.43 v1(210.7,59.04) 211.48,59.82 212.49,59.82
O_QO11_2: length 13.4
  TOP w0.102: RNF2.4 234.22,130.94 v1(234.09,130.81) ; U122.2 v1(236,120.9)
  BOTTOM w0.102: v1(236,120.9) 236.13,121.03 v2(236.13,121.74) 236.46,122.07 236.46,127.56 234.09,129.92 v1(234.09,130.81)
O_QO11_5: length 16.5
  TOP w0.102: 234.98,120.9 234.73,120.9 234.35,121.28 234.35,121.77 234.56,121.98 v1(234.56,122.95) ; v1(232.32,133.86) 233.08,133.86 233.21,133.73 RNF2.7
  BOTTOM w0.102: v1(234.56,122.95) 234.83,123.22 234.83,126.77 232.06,129.54 232.06,132.08 v2(232.44,132.46) 232.44,132.5 232.32,132.63 v1(232.32,133.86)
O_RI1#: length 15.4
  TOP w0.102: CNO1.2 178.67,232.85 v1(179.1,232.41) 179.48,232.03 UO2.2
  BOTTOM w0.102: v1(179.1,232.41) 179.1,235.16 182.41,238.46 182.41,240.28 180.72,241.97 VGA_COM.A9
O_RI1#_R: length 249.3
  TOP w0.102: UO2.19 188.75,232.03 190.53,230.25 190.53,228.35 v1(190.03,227.84) ; v1(217.71,48.64) 217.2,48.13 211.23,48.13 210.87,48.49 SIO_5553.103
  BOTTOM w0.102: v1(190.03,227.84) v2(192.82,227.84) 194.34,227.84 195.49,228.98 219.78,228.98 220.56,228.21 220.56,226.77 224.62,222.71 224.62,221.5 237.9,208.22 237.9,140.62 234.24,136.96 232.33,136.96 230.41,135.04 230.41,128.38 232.52,126.27 232.52,114.82 228.13,110.43 228.13,107.48 223.76,103.11 223.76,94.53 226.7,91.58 226.7,87.07 226.29,86.65 226.29,76.99 225.71,76.42 225.71,71.17 227.25,69.63 227.25,66.69 224.2,63.64 224.2,56.25 223.21,55.25 222.68,55.25 221.39,53.96 221.39,53.74 219.95,52.3 219.06,52.3 218.24,51.49 218.24,50.75 217.71,50.22 v1(217.71,48.64)
O_RTS1#: length 17.3
  TOP w0.102: CNO1.8 178.78,230.45 v1(179.1,230.12) 179.14,230.08 UO2.5
  BOTTOM w0.102: VGA_COM.A7 183.17,239.61 183.17,238.12 180,234.96 180,231.02 v1(179.1,230.12)
O_RTS1#_R: length 254.3
  TOP w0.102: v1(207.93,50.42) 208.26,50.09 SIO_5553.99 211.56,50.09 212.34,49.31 218.69,49.31 v1(219.24,48.77) ; v1(188.93,230.17) 188.84,230.08 UO2.16 ; v1(207.93,53.59) 208.19,53.85 RNO1.5
  BOTTOM w0.102: v1(188.93,230.17) 220.2,230.17 221.7,228.68 221.7,227.25 226.49,222.46 226.49,221.31 239.05,208.76 239.05,140.15 234.71,135.81 232.8,135.81 231.6,134.61 231.6,129.11 233.66,127.05 233.66,114.35 229.27,109.95 229.27,107.01 224.9,102.64 224.9,95 228.19,91.71 228.19,87.46 230.23,85.42 230.23,82.72 229.84,82.32 228.99,82.32 228.19,81.52 228.19,78.09 228.39,77.89 228.39,66.19 225.34,63.14 225.34,54.54 219.58,48.77 v1(219.24,48.77) ; v1(207.93,53.59) v1(207.93,50.42)
O_RXD1: length 17.8
  TOP w0.102: CNO2.4 179.08,228.24 v1(179.1,228.22) 179.67,228.78 UO2.7
  BOTTOM w0.102: VGA_COM.A2 185.95,239.13 181.68,234.86 181.68,230.47 179.43,228.22 v1(179.1,228.22)
O_RXD1_R: length 246.2
  TOP w0.102: SIO_5553.98 211.74,50.49 212.69,49.54 219.53,49.54 v1(219.54,49.53) ; UO2.14 v1(189.01,228.78)
  BOTTOM w0.102: v1(219.54,49.53) 219.54,50.36 220.26,51.08 220.92,51.08 224.66,54.82 224.66,63.42 227.71,66.47 227.71,69.89 226.17,71.42 226.17,76.23 226.74,76.8 226.74,86.35 227.16,86.77 227.16,91.77 224.21,94.72 224.21,102.92 228.58,107.29 228.58,110.24 232.98,114.63 232.98,126.64 230.92,128.7 230.92,134.9 232.52,136.5 234.43,136.5 238.36,140.43 238.36,208.45 225.08,221.71 225.08,222.9 221.01,226.96 221.01,228.4 219.97,229.44 195.05,229.44 194.7,229.08 v2(194.37,229.08) 193.99,229.08 193.63,229.44 190.43,229.44 189.97,228.98 189.21,228.98 v1(189.01,228.78)
O_SEN_CHAFAN: length 248.4
  TOP w0.102: RF2.1 201.71,223.14 202.09,223.52 CF4.1 202.55,222.62 RF3.1 202.79,221.68 203.49,220.98 217.71,220.98 218.17,221.44 218.17,223.98 220.57,226.38 221.22,226.38 222.13,227.29 v1(222.13,229.12) ; v1(220.43,43.69) 220.43,43.26 223.19,40.49 SIO_5553.38 ; v1(234.11,120.24) 234.11,118.78 237.07,115.82 v1(239.17,115.82)
  BOTTOM w0.102: v1(222.13,229.12) 222.13,227.14 226.72,222.55 226.72,221.41 239.28,208.85 239.28,140.06 234.81,135.59 232.9,135.59 231.83,134.52 231.83,129.26 234.11,126.99 v1(234.11,120.24) ; v1(239.17,115.82) 239.17,114.13 226.91,101.87 226.91,95.78 232.4,90.28 232.4,75.72 231.45,74.76 231.45,66.83 231.15,66.53 231.15,64.52 228.67,62.03 228.67,53.43 225.11,49.88 225.11,48.99 223.7,47.58 223.2,47.58 v1(222.66,47.04) 222.11,46.48 222.11,45.87 221.47,45.24 221.47,44.93 220.43,43.89 v1(220.43,43.69)
O_SEN_CPUFAN: length 96.3
  TOP w0.102: v1(229.78,109.09) 229.78,106.09 225.96,102.27 225.96,95.32 230.19,91.08 230.47,91.08 233.16,88.39 v1(233.16,87.38) ; v1(236.38,117.47) 236.51,117.6 RF8.1 ; v1(226.86,38.1) 226.5,38.46 226.5,38.81 225.22,40.09 SIO_5553.37
  BOTTOM w0.102: v1(226.86,38.1) 227.42,38.66 227.42,38.78 229.93,41.29 v2(229.93,42.49) 229.93,43.59 232.47,46.13 233.51,46.13 234.37,46.99 234.37,56.82 233.23,57.96 233.23,85.7 233.57,86.03 233.57,86.97 v1(233.16,87.38) ; v1(229.78,109.09) 230.89,109.09 235.2,113.4 235.2,116.29 v1(236.38,117.47)
O_SEN_CPUFAN_R: length 21.3
  TOP w0.102: RF7.1 233.08,135.19 v1(233.08,135.13) ; RF8.2 RF9.1 235.49,119.43 234.98,119.94 234.98,120.25 v1(236.11,120.25)
  BOTTOM w0.102: v1(233.08,135.13) 233.59,134.62 v2(233.84,134.62) 234.78,133.68 234.78,129.56 236.74,127.6 236.74,120.88 v1(236.11,120.25)
O_SPEAKER: length 44.4
  TOP w0.102: v1(206.8,34.25) 206.8,34.4 206.66,34.54 206.66,35.43 206.15,35.94 RO39.2 RO169.1 207.86,36.69 207.86,39.37 208.18,39.69 SIO_5553.125 ; v1(187.23,43.31) 183.55,39.62 181.63,39.62 CA19.2
  BOTTOM w0.102: v1(187.23,43.31) 190.64,43.31 199.66,34.29 205.59,34.29 205.62,34.25 v1(206.8,34.25)
O_SUS_3V_F_ON: length 3.7
  TOP w0.102: SIO_5553.56 224.97,47.69 226.17,48.9 RO33.2 226.73,48.9 226.98,49.15 v1(226.98,49.53)
O_SUS_3V_ON: length 5.5
  TOP w0.102: v1(217.38,51.08) 218.73,51.08 219.29,51.65 SIO_5553.74 219.29,52.97 219.87,53.54 219.87,54.04 RO35.2
O_SUS_3VON: length 259.4
  TOP w0.102: v1(204.09,39.95) 204.14,40 CO20.2 205.2,40.25 CO19.2 204.82,41.53 DO1.2 ; PR30.2 18.89,72.96 19.85,73.91 31.83,73.91 v1(32.06,74.14) ; RO33.1 v1(228.13,48.9) ; v1(229.14,54.86) 227.4,54.86 222.83,59.44 221.39,59.44 220.89,58.93 220.89,57.59 RO31.2 RO35.1
  BOTTOM w0.102: v1(32.06,74.14) 32.06,73.48 38.89,66.64 45.16,66.64 45.98,65.82 54.8,65.82 55.11,65.51 70.32,65.51 72,63.84 78.98,63.84 85.21,57.6 87.13,57.6 91.13,53.6 110.96,53.6 115.37,49.19 119.71,49.19 120.61,50.09 134.26,50.09 134.8,50.63 153.64,50.63 156.33,47.94 162.43,47.94 163,48.51 169.21,48.51 173.29,52.6 176.88,52.6 177.63,51.85 188.42,51.85 200.32,39.95 v1(204.09,39.95) 204.25,39.95 205.03,39.17 209.89,39.17 210.4,39.67 216.16,39.67 218.73,42.24 221.04,42.24 222.52,43.71 223.2,43.71 228.13,48.64 v1(228.13,48.9) 228.13,49.53 v2(228.89,50.29) 229.36,50.76 229.36,54.65 v1(229.14,54.86)
O_SUS_5VON: length 7.1
  TOP w0.102: SIO_5553.73 219.69,53.04 220.94,54.28 220.94,56.63 RO167.1 221.46,57.09 221.86,57.49 v1(221.94,57.49)
  BOTTOM w0.102: v1(221.94,57.49) v2(221.04,57.49)
O_SUS_ACK_EN_R#: length 28.9
  TOP w0.102: PR382.2 234.22,55.82 234.22,54.48 232.57,52.83 227.24,52.83 v1(226.63,53.44) ; v1(223.05,50.04) 222.03,51.05 220.51,51.05 220.25,50.8 219.95,50.8 219.65,50.5 212.8,50.5 211.94,51.35 211.36,51.35 211.29,51.42 SIO_5553.94
  BOTTOM w0.102: v1(226.63,53.44) 223.22,50.04 v1(223.05,50.04)
O_TR_CPU+: length 294.3
  TOP w0.127: v1(122.51,46.05) 122.77,46.3 123.12,46.3 134.6,34.82 134.6,34.01 134.93,33.68 135.18,33.68 v1(135.44,33.42) ; v1(226.57,39.36) 226.85,39.65 226.85,39.88 226.6,40.13 CO16.1 226.64,40.47 226.64,40.8 226.26,41.18 225.59,41.18 225.08,41.69 SIO_5553.41 ; THRM_1.C THRM_1.B 7.59,80.65 7.71,80.77 8.18,80.77 9.2,79.76 10.38,79.76 C1724.1 11.02,79.76 11.34,79.76 v1(11.61,79.49)
  BOTTOM w0.127: v1(122.51,46.05) 122.82,46.35 124.22,46.35 125.11,47.24 135.36,47.24 135.96,47.84 152.49,47.84 156.01,44.32 172.88,44.32 175.39,46.83 188,46.83 199.91,34.92 217.96,34.92 221.1,38.06 v2(221.59,38.06) 221.59,38.55 222.92,39.88 223.66,39.88 224.42,40.64 226.5,40.64 226.86,40.28 226.86,39.65 v1(226.57,39.36) ; v1(11.61,79.49) 11.89,79.77 12.99,79.77 16.91,75.86 16.91,73.93 21.48,69.36 21.48,68.71 25.72,64.46 30.5,64.46 37.34,57.62 47.08,57.62 47.71,57 57.64,57 58.12,57.48 61.05,57.48 62.52,56.01 67.38,56.01 72.85,50.53 79.26,50.53 82.45,47.35 84.14,47.35 90.06,41.43 91.43,41.43 99.41,33.44 116.99,33.44 117.24,33.69 130.45,33.69 131.17,32.96 134,32.96 134.76,33.73 135.13,33.73 v1(135.44,33.42)
O_TR_CPU-: length 292.9
  TOP w0.127: v1(11.61,80.31) 11.31,80.01 11.02,80.01 C1724.2 10.38,80.01 9.3,80.01 8.29,81.03 7.71,81.03 7.59,81.15 THRM_1.E ; v1(135.44,34.24) 135.14,33.94 135.04,33.94 134.86,34.12 134.86,34.92 123.22,46.56 122.82,46.56 v1(122.51,46.87) ; v1(227.39,39.36) 227.11,39.65 227.11,39.88 227.36,40.13 CO16.2 226.36,41.44 225.69,41.44 225.04,42.09 SIO_5553.42
  BOTTOM w0.127: v1(11.61,80.31) 11.89,80.03 13.1,80.03 17.16,75.96 17.16,74.04 21.73,69.47 21.73,68.82 25.83,64.72 30.6,64.72 37.45,57.87 47.19,57.87 47.81,57.25 57.54,57.25 58.02,57.73 61.15,57.73 62.62,56.26 67.48,56.26 72.96,50.79 79.37,50.79 82.56,47.6 84.25,47.6 90.16,41.68 91.53,41.68 99.52,33.7 116.89,33.7 117.13,33.94 130.55,33.94 131.28,33.22 133.89,33.22 134.65,33.98 135.18,33.98 v1(135.44,34.24) ; v1(122.51,46.87) 122.77,46.61 124.11,46.61 125,47.5 135.25,47.5 135.85,48.1 152.6,48.1 156.12,44.58 172.78,44.58 175.29,47.09 188.1,47.09 200.02,35.17 217.85,35.17 222.11,39.43 v2(222.11,39.95) 222.63,39.95 222.81,40.13 223.55,40.13 224.32,40.89 226.6,40.89 227.11,40.39 227.11,39.65 v1(227.39,39.36)
O_TR_MB+: length 382.8
  TOP w0.127: v1(165.46,45.39) 165.46,46.54 166.53,47.6 166.53,49.99 167.09,50.55 167.09,54.96 166.02,56.03 166.02,56.87 v1(166.92,57.77) ; THRM_2.C THRM_2.B 66.52,150.56 C1723.1 65.36,151.02 65.36,151.79 64.06,153.09 58.44,153.09 v1(58.01,153.52) ; v1(34.35,81.79) 34.04,82.1 34.04,82.38 33.24,83.18 27.03,83.18 26.37,83.85 24.18,83.85 21.71,86.31 21.71,99.74 19.78,101.67 19.78,108.41 15.87,112.31 15.87,119.79 13.13,122.53 13.13,128.9 16.69,132.46 19.18,132.46 21.75,135.03 27.21,135.03 27.85,135.66 27.85,137.46 32.37,141.99 33.92,141.99 34.28,142.35 34.28,142.71 v1(34.57,142.99) ; SIO_5553.43 225.56,42.49 225.76,42.29 227.06,42.29 CO17.1 227.74,41.91 228,41.66 228,41.42 v1(227.72,41.14)
  BOTTOM w0.127: v1(58.01,153.52) 58.25,153.76 58.25,154.79 54.86,158.19 41.87,158.19 34.96,151.28 34.96,144.17 34.3,143.51 34.3,143.26 v1(34.57,142.99) ; v1(166.92,57.77) 166.55,57.4 166.13,57.4 165.84,57.69 159.22,57.69 158.55,57.02 156.09,57.02 155.49,57.62 147.97,57.62 146.87,56.51 145.29,56.51 144.27,55.5 132.89,55.5 132.1,54.71 114.99,54.71 112.46,57.23 92.67,57.23 88.65,61.25 86.78,61.25 80.48,67.55 76.22,67.55 74.93,68.84 71.07,68.84 70.78,68.55 61.14,68.55 60.87,68.29 56.21,68.29 55.94,68.55 47.16,68.55 46.31,69.4 42.17,69.4 41.01,70.56 40.1,70.56 35.77,74.89 35.77,78.44 33.94,80.27 33.94,81.51 34.07,81.63 34.2,81.63 v1(34.35,81.79) ; v1(227.72,41.14) 228,41.42 228,41.75 227.61,42.14 223.17,42.14 221.11,40.08 219.8,40.08 219.33,39.62 219.33,38.83 217.05,36.55 209.41,36.55 208.67,35.81 200.3,35.81 188.36,47.75 175.02,47.75 172.66,45.39 v1(165.46,45.39)
O_TR_MB-: length 379.7
  TOP w0.127: 68.11,151.51 68.04,151.45 C1723.2 65.82,151.69 64.17,153.34 58.87,153.34 58.75,153.47 v1(58.75,153.54) ; v1(165.97,45.9) 165.72,46.15 165.72,46.43 166.78,47.5 166.78,49.89 167.34,50.44 167.34,55.07 166.28,56.13 166.28,56.77 166.46,56.96 v1(166.92,56.96) ; v1(33.75,142.99) 34.03,142.71 34.03,142.46 33.82,142.24 32.27,142.24 27.59,137.57 27.59,135.76 27.11,135.28 21.64,135.28 19.08,132.71 16.58,132.71 12.87,129 12.87,122.42 15.62,119.68 15.62,112.21 19.52,108.3 19.52,101.57 21.46,99.63 21.46,86.2 24.07,83.59 26.26,83.59 26.93,82.93 33.13,82.93 33.79,82.27 33.79,82.04 v1(33.53,81.79) ; v1(228.53,41.14) 228.25,41.42 228.25,41.66 228.51,41.91 CO17.2 228.18,42.54 225.87,42.54 225.52,42.89 SIO_5553.44
  BOTTOM w0.127: v1(166.92,56.96) 166.73,57.15 166.02,57.15 165.74,57.44 159.33,57.44 158.66,56.77 155.98,56.77 155.38,57.36 148.08,57.36 146.98,56.26 145.39,56.26 144.38,55.25 132.99,55.25 132.2,54.46 114.88,54.46 112.36,56.98 92.56,56.98 88.55,61 86.68,61 80.37,67.3 76.12,67.3 74.83,68.59 71.18,68.59 70.89,68.3 61.24,68.3 60.98,68.03 56.11,68.03 55.84,68.3 47.05,68.3 46.21,69.15 42.06,69.15 40.9,70.31 39.99,70.31 35.52,74.78 35.52,78.34 33.69,80.17 33.69,81.63 v1(33.53,81.79) ; v1(228.53,41.14) 228.25,41.42 228.25,41.86 227.72,42.39 223.07,42.39 221.01,40.34 219.69,40.34 219.08,39.72 219.08,38.94 216.95,36.8 209.3,36.8 208.57,36.07 200.4,36.07 188.46,48.01 174.91,48.01 172.55,45.64 166.23,45.64 v1(165.97,45.9) ; v1(58.75,153.54) 58.5,153.79 58.5,154.9 54.96,158.44 41.76,158.44 34.7,151.38 34.7,144.27 34.05,143.62 34.05,143.29 v1(33.75,142.99)
O_TRST#: length 6.8
  TOP w0.102: v1(211.34,40.26) 211.17,40.09 SIO_5553.124 207.97,40.09 207.63,39.75 207.63,37.6 RO28.2
O_TXD1: length 17.6
  TOP w0.102: UO2.8 179.78,228.13 v1(179.08,227.44) CNO2.6
  BOTTOM w0.102: VGA_COM.A3 184.14,238.62 181.43,235.91 181.43,230.54 179.56,228.68 178.8,228.68 178.6,228.47 178.6,227.93 v1(179.08,227.44)
O_TXD1_R: length 250.2
  TOP w0.102: v1(190.28,226.82) 189.77,227.33 189.14,227.33 188.76,227.71 188.76,227.84 188.46,228.13 UO2.13 ; v1(206.76,50.04) 206.76,50.5 208.38,52.12 209.38,52.12 209.96,52.7 209.96,53.28 210.09,53.41 210.09,54.61 210.35,54.86 210.35,55.05 RO11.2 210.79,55.5 RO23.2 211.55,57.28 v1(211.87,57.28) ; QO2.6 201.69,47.61 202.09,48.01 202.09,48.64 202.5,49.05 v1(202.57,49.05)
  BOTTOM w0.102: v1(202.57,49.05) 203.56,50.04 v1(206.76,50.04) ; v1(211.87,57.28) 212.76,58.17 215.98,58.17 216.29,58.47 218.45,58.47 218.75,58.17 221.52,58.17 222.62,59.27 222.62,64.18 225.25,66.81 225.25,76.63 225.83,77.21 225.83,86.84 226.25,87.26 226.25,91.36 223.3,94.31 223.3,103.3 227.67,107.67 227.67,110.62 232.06,115.01 232.06,125.99 229.95,128.09 229.95,135.23 232.14,137.41 234.02,137.41 237.45,140.84 237.45,206.1 236.28,207.26 236.28,209.17 224.16,221.28 224.16,222.47 220.1,226.53 220.1,228.02 219.59,228.52 195.79,228.52 194.09,226.82 v2(191.17,226.82) v1(190.28,226.82)
O_TXD1_R_C: length 8.6
  TOP w0.102: SIO_5553.100 207.89,49.69 207.5,50.09 207.5,50.6 208.08,51.18 208.95,51.18 210.19,52.43 210.19,53.12 210.87,53.8 v1(211.18,53.8) 211.18,54.09 RO11.1
O_V5_ALW_MON: length 238.9
  TOP w0.102: SIO_5553.15 216.09,37.71 215.81,38 215.81,38.48 217.2,39.88 v1(217.2,45.44) ; v1(38.36,73.08) 32.98,73.08 32.83,72.92 20.76,72.92 16.57,68.73 15.3,68.73 14.76,69.28 RO189.2 RO52.1 10.38,71.75 9.05,71.75 8.78,72.02 QO3.6
  BOTTOM w0.102: v1(38.36,73.08) 38.46,73.08 40.36,71.18 41.26,71.18 42.42,70.02 46.59,70.02 47.44,69.18 56.2,69.18 56.47,68.91 60.61,68.91 60.88,69.18 70.52,69.18 70.82,69.47 75.19,69.47 76.48,68.18 80.74,68.18 87.04,61.87 88.91,61.87 92.92,57.86 112.72,57.86 115.21,55.37 131.48,55.37 132.27,56.16 144.05,56.16 145.04,57.15 146.63,57.15 147.44,57.97 147.44,58.37 147.95,58.88 156.59,58.88 157.05,59.33 165.76,59.33 165.92,59.49 179.22,59.49 180.14,58.57 190.5,58.57 v2(197.91,51.15) 198.65,50.42 198.65,48.35 199.83,47.17 205,47.17 205.99,48.16 211.97,48.16 214.74,45.39 217.15,45.39 v1(217.2,45.44)
O_V_IN: length 2.5
  TOP w0.102: RO21.1 226.09,44.45 v1(225.84,44.2) 225.66,44.2 225.16,43.69 SIO_5553.46
O_YELLOW#: length 24
  TOP w0.102: SIO_5553.23 219.29,35.75 218.14,34.59 218.14,28.4 218.61,27.93 v1(218.61,24.64) 218.61,22.93 219.55,21.99 QO14.2 219.55,21.61 218.28,20.34 218.28,19.35 218.54,19.1 219.49,19.1 CO54.1 220.62,18.46 220.79,18.64 221.56,18.64 221.99,18.21 RNO5.6
O_YELLOW#_CTL: length 5.8
  TOP w0.102: QO14.5 219.55,20.24 219.71,20.39 220.09,20.39 220.2,20.28 QO14.6 221.11,19.73 v1(221.9,20.53) 222.35,20.08 RNO5.5
O_YELLOW#_R: length 7.3
  TOP w0.102: PWR_SW.1 214.73,17.24 RIO8.2 217.52,20.72 218.57,21.76 QO14.3
OQ14_C: length 6.9
  TOP w0.102: v1(202.83,15.7) 202.34,15.22 QO6.6 201.9,14.83 201.76,14.69 201.76,14.28 201.86,14.18 QO6.5 202.98,14.18 203.41,14.61 203.41,16.39 203.84,16.81 RNO2.2
PCH_24M_PCICLK: length 22.3
  TOP w0.089: U4.AV19 v1(50.25,126.69)
  TOP w0.102: R6394.2 v1(33.43,125.09)
  BOTTOM w0.089: 43.23,124.61 44.1,124.61 44.88,125.39 46.42,125.39 46.92,125.88 47.71,125.88 48.14,126.31 49.88,126.31 v1(50.25,126.69)
  BOTTOM w0.102: v2(32.68,125.23) 32.82,125.09 v1(33.43,125.09) 33.43,123.65 34.3,122.78 34.96,122.78 35.31,123.14 38.51,123.14 39.99,124.61 43.23,124.61
PCH_AUD_MUTE: length 254.5
  TOP w0.089: U4.BC35 47.16,117.98 46.5,117.98 46.24,117.73 45.97,117.73 45.61,117.36 45.61,114.76 44.86,114.02 44.86,113.49 v1(44.43,113.06)
  TOP w0.102: RA8.1 191.55,31.96 v1(191.17,32.34) ; v1(40.55,108.46) 40.72,108.28 40.72,107.27 42.15,105.85 42.15,102.95 41.69,102.49 41.69,100.27 42.3,99.66 42.3,90.59 40.34,88.64 38.67,88.64 37.3,87.26 36.37,87.26 35.39,86.28 34.91,86.28 34.4,86.79 32.37,86.79 32.06,87.1 30.72,87.1 27.92,89.89 v1(27.41,89.89)
  BOTTOM w0.102: v1(40.55,108.46) 40.39,108.61 v2(40.39,109.91) 41.15,110.66 44.15,110.66 44.64,111.15 44.64,112.85 v1(44.43,113.06) ; v1(27.41,89.89) 27.31,89.79 27.28,89.79 23.5,86.01 23.5,79.83 25.39,77.94 25.39,77.28 29.52,73.15 29.52,72.63 37.81,64.33 44.02,64.33 44.84,63.51 53.66,63.51 53.97,63.2 65.25,63.2 66.14,62.31 66.53,62.31 69.03,62.31 76.37,54.97 81.07,54.97 83.54,52.49 85.58,52.49 91.97,46.1 98.2,46.1 99.5,44.79 101.99,44.79 103.25,43.54 106.3,43.54 109.15,40.69 116.71,40.69 118.28,39.12 121.25,39.12 122.01,38.35 137.03,38.35 138.01,37.37 151.74,37.37 154.01,35.1 172.52,35.1 174.36,36.94 186.57,36.94 v1(191.17,32.34)
PCH_CPU_TRIGGER_IN: length 120.9
  TOP w0.089: 51.47,139.01 51.74,138.74 51.74,138.45 53.25,136.94 53.25,134.98 U4.AL2
  TOP w0.102: 51.47,139.01 51.29,139.19 51.29,140.64 50.65,141.28 50.65,143.8 50.02,144.44 50.02,150.65 56.34,156.97 65.35,156.97 66.98,155.34 69.25,155.34 71.57,153.01 71.57,150.6 77.82,144.35 82.65,144.35 84.11,142.89 v1(84.11,142.75) ; R6613.2 126.4,169.55 122.85,166 122.85,162.56 115.33,155.04 115.33,153.92 111.53,150.11 109.42,150.11 108.26,148.95 105.47,148.95 102.63,146.1 96.3,146.1 v1(94.85,147.55)
  BOTTOM w0.102: v1(84.11,142.75) 84.19,142.75 84.61,143.17 v2(85.85,143.17) 86.27,142.75 87.87,142.75 88.53,143.41 90.95,143.41 94.85,147.31 v1(94.85,147.55)
PCH_CPU_TRIGGER_IN_R: length 20.6
  TOP w0.102: R6613.1 133.7,169.55 134.63,168.62 v1(137.02,168.62) 137.23,168.62 142.87,162.98 146.28,162.98 CPU.D1
PCH_DISPA_BCLK: length 144.7
  TOP w0.102: v1(85,136.65) 85.48,137.13 85.48,143.1 83.18,145.4 78.25,145.4 72.62,151.03 72.62,153.46 69.69,156.38 67.41,156.38 65.78,158.01 55.9,158.01 54.11,156.22 48.85,150.96 48.85,143.61 49.18,143.28 R6350.1 ; CPU.V3 148.02,150.26 145.37,150.26 144.41,151.22 141.13,151.22 138.88,153.47 127.81,153.47 123.93,149.6 123.93,143.59 120.94,140.59 120.24,140.59 119.74,140.08 117.69,140.08 115.38,137.77 114.62,137.77 112.99,136.14 108.41,136.14 107.14,134.87 v1(105.7,134.87)
  BOTTOM w0.102: v1(105.7,134.87) 105.65,134.82 101.81,134.82 100.82,135.81 99.35,135.81 v2(99.22,135.94) 98.08,135.94 96.98,137.03 96.29,137.03 93.8,134.54 93.58,134.33 91.4,134.33 90.58,133.5 87.74,133.5 87.56,133.68 85.2,133.68 84.31,134.57 84.31,135.97 v1(85,136.65)
PCH_DISPA_BCLK_R: length 10.5
  TOP w0.089: U4.AM2 52.86,134.79 52.52,135.13 52.52,135.46 52.68,135.61 52.68,136.66 50.91,138.43 50.13,138.43 49.72,138.84 49.72,139.01
  TOP w0.102: R6350.2 v1(49.18,140.84) 49.18,140.59 49.72,140.05 49.72,139.01
  BOTTOM w0.102: v2(49.18,142.43) v1(49.18,140.84)
PCH_DISPA_SDI: length 117.2
  TOP w0.089: U4.AN2 52.33,134.93 52.33,135.53 52.49,135.69 52.49,136.55 50.79,138.24 50.01,138.24 49.49,138.75 49.49,139.01
  TOP w0.102: v1(85,135) 85.45,135.46 85.45,136.73 85.71,136.98 85.71,143 85.71,143.19 83.27,145.62 78.34,145.62 72.84,151.12 72.84,153.55 69.78,156.61 67.51,156.61 65.88,158.24 55.81,158.24 53.88,156.31 48.62,151.05 48.62,143.1 48.46,142.94 48.46,140.75 49.49,139.71 49.49,139.01 ; R50.2 120.87,141.54 119.64,140.31 117.6,140.31 115.29,138 114.52,138 112.9,136.37 108.31,136.37 107.32,135.38 v1(106.21,135.38)
  BOTTOM w0.102: v1(106.21,135.38) 105.57,135.38 105.24,135.05 101.96,135.05 100.85,136.17 100.01,136.17 99.58,136.6 97.95,136.6 97.26,137.29 96.22,137.29 93.7,134.77 93.49,134.56 91.31,134.56 90.48,133.73 87.83,133.73 87.66,133.91 85.33,133.91 85,134.24 v1(85,135)
PCH_DISPA_SDI_R: length 34.6
  TOP w0.102: R50.1 121.76,142.21 v1(122.7,143.15) 123.53,143.98 123.53,149.72 127.64,153.83 139.03,153.83 141.4,151.45 144.5,151.45 145.35,150.61 CPU.U1
PCH_DISPA_SDO: length 146.3
  TOP w0.102: v1(84.36,136.65) 85,137.29 85,138.56 85.25,138.81 85.25,143 83.08,145.17 78.15,145.17 72.39,150.93 72.39,153.36 69.59,156.16 67.32,156.16 65.69,157.78 56,157.78 54.34,156.12 49.08,150.86 49.08,143.71 49.69,143.1 49.69,140.65 R6351.1 ; CPU.V2 147.31,150.06 145.25,150.06 144.45,150.86 135.9,150.86 133.72,153.03 127.89,153.03 124.17,149.31 124.17,143.49 121.04,140.36 120.34,140.36 119.81,139.83 117.76,139.83 115.48,137.54 114.71,137.54 113.09,135.92 108.5,135.92 106.95,134.37 v1(105.29,134.37)
  BOTTOM w0.102: v1(84.36,136.65) 84.08,136.37 84.08,134.47 85.1,133.45 87.46,133.45 87.64,133.27 90.67,133.27 91.5,134.1 93.67,134.1 93.89,134.32 93.89,134.32 96.35,136.78 96.88,136.78 98.79,134.87 100.87,134.87 v2(101.25,134.49) 101.35,134.59 105.06,134.59 v1(105.29,134.37)
PCH_DISPA_SDO_R: length 4.9
  TOP w0.089: U4.AM1 52.76,135.42 52.87,135.53 52.87,136.78 50.86,138.79 50.67,138.79 R6351.2
PCH_DPWROK: length 319.1
  TOP w0.089: U4.AV11 50.35,130.53 v1(50.81,130.07)
  TOP w0.102: v1(77.5,69.6) 77.5,63.87 84.62,56.76 84.62,54.1 88.27,50.44 95.18,50.44 v1(95.41,50.67) ; R6628.1 v1(222.28,32.38) RO89.1
  BOTTOM w0.089: v1(50.81,130.07) 50.38,130.51 50.02,130.51 49.61,130.91 48.52,130.91 48.19,130.58 45.96,130.58 43.23,133.31
  BOTTOM w0.102: v1(222.28,32.38) 221.4,31.5 215.81,31.5 215.62,31.32 200.32,31.32 190.28,41.35 186.28,41.35 182.82,44.81 176.43,44.81 173.23,41.61 155.69,41.61 152.07,45.22 135.97,45.22 135.05,44.3 120.89,44.3 119.22,45.97 115.96,45.97 110.32,51.61 95.97,51.61 95.41,51.05 v1(95.41,50.67) ; v1(77.5,69.6) 77.34,69.6 76.33,70.61 70.26,70.61 69.99,70.35 62.96,70.35 61.63,71.68 60.83,71.68 59.33,73.18 56.29,73.18 53.43,70.32 48.61,70.32 45.5,73.44 45.5,73.85 43.01,76.34 43.01,78.75 42.56,79.2 42.56,79.76 41.38,80.93 41.38,88.13 38.64,90.88 38.64,101.78 37.66,102.77 28.52,102.77 22.64,108.65 22.64,111.99 26.23,115.58 26.74,115.58 27.34,116.18 27.34,124.91 27.03,125.21 27.03,130.54 27.42,130.92 27.42,134.27 31.07,137.92 v2(33,137.92) 34.49,137.92 35.76,139.19 40.09,139.19 41.62,137.66 41.62,136.51 42.2,135.94 42.9,135.94 43.21,135.64 43.21,133.33 43.23,133.31
PCH_DPWROK_C: length 3.4
  TOP w0.102: RO89.2 v1(221.74,34.65) 221.39,34.99 221.39,36.07 221.29,36.17 SIO_5553.28
PCH_FVS: length 13.4
  TOP w0.089: 65.2,111.25 63.92,112.53 63.92,112.92 63.33,113.51 63.33,113.89 63.22,114 63.22,114.27 U4.L43
  TOP w0.102: 65.2,111.25 65.7,110.76 65.7,110.18 R6669.2 65.95,109.41 65.95,107.7 66.77,106.87 68.42,106.87 FVS.1
PCH_GPD0: length 12
  TOP w0.089: U4.BD13 44.93,129.62 43.87,128.55 43.19,128.55
  TOP w0.102: 43.19,128.55 40.59,128.55 39.86,127.83 37.99,127.83 37.21,128.6 v1(36.86,128.6) 36.24,129.22 R6664.2
PCH_GPD1: length 13.5
  TOP w0.089: U4.BB15 47.58,128.8 47.48,128.8 47.43,128.85 46.73,128.85 46.63,128.75 46.37,128.75 45.97,128.36 44.56,128.36 44.07,127.87 43.19,127.87
  TOP w0.102: R6435.2 36.88,125.4 37.17,125.4 38.39,126.62 39.62,126.62 40.87,127.87 43.19,127.87
PCH_GPD4: length 24.5
  TOP w0.089: U4.AW15 49.25,128.56 v1(49.84,127.97)
  TOP w0.102: v1(29.37,130.3) 28.99,130.68 R6660.1
  BOTTOM w0.089: 43.23,127.36 43.33,127.36 43.98,128 47.67,128 48.32,128.65 48.8,128.65 49.05,128.4 49.41,128.4 v1(49.84,127.97)
  BOTTOM w0.102: v1(29.37,130.3) 29.53,130.14 32.16,130.14 33.21,129.08 34.63,129.08 36.61,127.1 37.63,127.1 37.88,127.36 43.23,127.36
PCH_GPD5: length 13.6
  TOP w0.089: U4.BD15 46.82,128.56 46.45,128.56 46.05,128.17 44.64,128.17 44.11,127.64 43.19,127.64
  TOP w0.102: R6661.1 35.3,126.05 v1(35.92,125.43) 36.18,125.17 37.26,125.17 38.48,126.39 39.72,126.39 40.97,127.64 43.19,127.64
PCH_GPD6: length 15.3
  TOP w0.089: 43.19,127.41 44.15,127.41 44.72,127.98 46.13,127.98 46.53,128.37 47.02,128.37 47.17,128.52 U4.BC15
  TOP w0.102: 43.19,127.41 41.06,127.41 39.81,126.16 38.58,126.16 37.36,124.94 35.17,124.94 R6662.1
PCH_HDBCLK: length 14.3
  TOP w0.089: 44.09,134 44.45,134 46.36,132.09 46.82,132.09 46.86,132.13 47.54,132.13 47.9,131.76 48.06,131.76 U4.BA9
  TOP w0.102: v1(39.28,138.43) 38.96,138.43 R6339.2 39.38,137.38 39.38,135.34 39.77,134.95 40.64,134.95 41.59,134 44.09,134
PCH_HDRST#: length 13.5
  TOP w0.089: 44.09,133.77 44.41,133.77 46.28,131.9 46.87,131.9 U4.BD8
  TOP w0.102: 44.09,133.77 41.5,133.77 40.54,134.72 39.67,134.72 39.15,135.24 39.15,136.65 37.68,138.11 R6341.2 37.43,138.11 v1(36.99,138.56)
PCH_HDSDO: length 10.5
  TOP w0.089: U4.BB7 48.07,132.74 v1(47.62,133.19) 47.37,133.19 46.8,132.62 46.39,132.62 44.58,134.43
  TOP w0.102: R6347.2 R6346.2 41.05,135.18 41.78,134.45 44.56,134.45 44.58,134.43
PCH_HDSYNC: length 14.7
  TOP w0.089: 44.09,133.54 44.37,133.54 45.33,132.58 v1(45.33,132.08) 45.83,132.08 46.2,131.71 46.66,131.71 46.99,131.38 U4.BD9
  TOP w0.102: R6348.2 36.72,137.62 37.86,137.62 38.92,136.55 38.92,135.15 39.58,134.49 40.45,134.49 41.4,133.54 44.09,133.54
PCH_HSIN5: length 132.7
  TOP w0.089: U4.K19 v3(63.61,126.69)
  TOP w0.102: v1(95,154.17) 94.6,154.17 94.39,154.38 94.39,155.09 93.58,155.91 93.08,155.91 91.55,157.44 91.55,158.79 92.36,159.6 92.36,161.66 90.99,163.03 90.99,207.92 97.44,214.38 97.44,217.83 101.1,221.49 102.69,221.49 105.04,223.84 106.79,223.84 107.02,223.61 107.02,223.39 CL1.1
  BOTTOM w0.089: 69.88,128.45 69.85,128.45 69.85,128.45 69.25,128.45 69.16,128.54 68.41,128.54 66.27,126.41 64.97,126.41 64.77,126.21 63.43,126.21 63.34,126.3 63.34,126.42 v3(63.61,126.69)
  BOTTOM w0.102: v1(95,154.17) 94.86,154.03 94.65,154.03 94.44,154.23 93.12,154.23 92.4,153.52 91.42,153.52 90.58,152.68 89.12,152.68 86.95,150.51 85.66,150.51 82.5,147.35 81.76,147.35 79.7,145.28 79.16,145.28 78.82,144.94 78.82,144.4 v2(77.47,143.05) 76.28,141.87 76.28,136.23 74.79,134.73 74.79,130.03 73.31,128.55 70.41,128.55 70.32,128.45 69.88,128.45
PCH_HSIN5_C: length 124.3
  TOP w0.102: v3(93.01,155.01) 92.79,154.79 92.55,154.79 90.13,157.21 90.13,161.57 89.36,162.33 89.36,208.66 95.49,214.78 95.49,218.31 100.59,223.42 102.07,223.42 104.64,225.98 106.87,225.98 107.68,226.8 108.06,226.8 108.25,226.6 RTK_LAN.14 ; CL4.2 72.58,128.36 72.58,128.75 72.29,129.03 v1(72.29,129.03)
  BOTTOM w0.102: v3(93.01,155.01) 92.9,154.9 92.76,154.9 92.51,155.14 92,155.14 90.23,153.37 88.81,153.37 86.67,151.23 85.41,151.23 83.74,149.56 82.15,149.56 v2(81.4,148.81) 80.29,147.7 79.75,147.7 79.41,147.36 79.41,146.82 75.6,143 75.6,136.53 74.1,135.03 74.1,131.2 72.5,129.6 72.5,129.24 v1(72.29,129.03)
PCH_HSIN6: length 117.4
  TOP w0.089: v3(65.12,125.6) U4.G22
  TOP w0.102: v1(88.63,150.74) 88.08,150.74 87.17,151.64 81.93,151.64 80.2,153.38 80.2,156.21 79.94,156.46 79.94,157.88 79.12,158.7 78.18,158.7 72.78,164.11 72.78,167.55 65.29,175.03 56.27,175.03 51.14,180.16 51.14,180.95 50.1,181.99 50.1,188.26 49.49,188.87 49.49,190.71 48.98,191.22 48.98,193.78 49.56,194.36 49.56,195.45 49.69,195.58 49.99,195.58 50.26,195.31 CX126.1
  BOTTOM w0.089: 69.88,125.43 69.85,125.43 69.85,125.44 69.54,125.44 69.18,125.08 67.02,125.08 66.9,124.97 65.63,124.97 65.41,125.18 65.41,125.31 v3(65.12,125.6)
  BOTTOM w0.102: 69.88,125.43 70.31,125.43 71.46,126.58 71.46,127.09 72.02,127.66 73.68,127.66 75.49,129.46 79,129.46 79.69,130.15 79.69,134.16 77.73,136.12 77.73,136.84 78.11,137.22 78.11,137.71 77.73,138.09 v2(77.73,140.77) 77.73,141.32 85.89,149.48 88.28,149.48 88.63,149.83 v1(88.63,150.74)
PCH_HSIN7: length 137.6
  TOP w0.089: v3(62.84,125.59) U4.L22
  TOP w0.102: v1(92,152.02) 91.74,152.27 91.04,152.27 88.28,155.03 88.28,155.64 85.25,158.66 84.71,158.66 83.54,159.83 82.71,159.83 80.79,161.75 79.74,161.75 78.95,162.53 76.18,162.53 73.95,164.76 73.95,208.91 63.48,219.38 63.48,221.03 63.33,221.19 63.09,221.19 SLOT2.A17
  BOTTOM w0.089: 69.88,124.72 69.78,124.72 69.36,124.3 63.85,124.3 63.04,125.12 63.04,125.4 v3(62.84,125.59)
  BOTTOM w0.102: 69.88,124.72 70.58,124.72 70.9,125.04 73.01,125.04 76.06,128.09 79.6,128.09 81.82,130.31 81.82,130.8 81.44,131.18 v2(81.44,132.59) 81.44,136.6 79.87,138.18 79.87,141.47 86.5,148.11 88.9,148.11 90.48,149.69 90.48,150.22 91.17,150.9 91.17,151.97 91.4,152.2 91.81,152.2 v1(92,152.02)
PCH_HSIP5: length 132.7
  TOP w0.089: U4.L19 v3(62.84,126.69)
  TOP w0.102: v1(94.46,153.63) 94.46,154.03 94.19,154.3 94.19,155.01 93.5,155.7 93,155.7 91.35,157.35 91.35,158.88 92.15,159.68 92.15,161.58 90.79,162.94 90.79,208.01 97.24,214.46 97.24,217.91 101.02,221.69 102.61,221.69 104.95,224.04 106.66,224.04 CL2.1
  BOTTOM w0.089: v3(62.84,126.69) 63.15,126.38 63.15,126.22 63.35,126.02 64.85,126.02 65.05,126.22 66.35,126.22 67.32,127.18 68.49,128.35 69.08,128.35 69.17,128.26 69.85,128.26 69.85,128.25 69.88,128.25
  BOTTOM w0.102: v1(94.46,153.63) 94.46,153.93 94.36,154.03 93.2,154.03 92.49,153.31 91.5,153.31 90.66,152.48 89.2,152.48 87.03,150.3 85.74,150.3 82.58,147.14 81.85,147.14 v2(79.4,144.7) 78.05,143.35 78.05,142.81 77.71,142.47 77.17,142.47 76.49,141.78 76.49,136.14 74.99,134.64 74.99,129.94 73.39,128.35 70.49,128.35 70.4,128.25 69.88,128.25
PCH_HSIP5_C: length 124.3
  TOP w0.102: RTK_LAN.13 107.6,227 106.78,226.19 104.55,226.19 101.99,223.62 100.51,223.62 95.28,218.4 95.28,214.87 89.16,208.75 89.16,162.25 89.92,161.49 89.92,157.12 92.36,154.68 v3(92.36,154.36) ; CL3.2 72.78,128.36 72.78,128.75 v1(73.06,129.03)
  BOTTOM w0.102: v1(73.06,129.03) 72.85,129.03 72.7,129.18 72.7,129.51 74.3,131.11 74.3,134.95 75.8,136.45 75.8,142.92 v2(80,147.11) 81.11,148.22 81.65,148.22 81.99,148.57 81.99,149.1 82.24,149.35 83.82,149.35 85.5,151.03 86.76,151.03 88.89,153.16 90.31,153.16 92.09,154.94 92.43,154.94 92.59,154.78 92.59,154.59 v3(92.36,154.36)
PCH_HSIP6: length 117.4
  TOP w0.089: v3(65.89,125.61) U4.E22
  TOP w0.102: v1(87.79,150.17) 87.79,150.19 87.91,150.32 87.91,150.61 87.08,151.44 81.85,151.44 79.99,153.3 79.99,156.13 79.74,156.38 79.74,157.79 79.03,158.5 78.1,158.5 72.58,164.02 72.58,167.46 65.21,174.83 56.18,174.83 50.93,180.08 50.93,180.87 49.89,181.91 49.89,188.18 49.28,188.79 49.28,190.62 48.78,191.13 48.78,193.86 49.36,194.45 49.36,195.54 49.61,195.78 50.08,195.78 CX127.1
  BOTTOM w0.089: v3(65.89,125.61) 65.69,125.61 65.6,125.52 65.6,125.26 65.71,125.16 66.82,125.16 66.94,125.27 69.11,125.27 69.46,125.63 69.85,125.63 69.85,125.63 69.88,125.63
  BOTTOM w0.102: 69.88,125.63 70.23,125.63 71.25,126.66 71.25,127.18 71.94,127.86 73.6,127.86 75.4,129.67 78.92,129.67 79.48,130.23 79.48,134.08 77.53,136.03 v2(77.53,137.46) 77.53,140.13 77.15,140.51 77.15,141.02 85.81,149.68 88.2,149.68 88.43,149.91 88.43,150.25 88.19,150.5 87.92,150.5 87.79,150.36 v1(87.79,150.17)
PCH_HSIP7: length 137.6
  TOP w0.089: v3(63.6,125.54) U4.K22
  TOP w0.102: v1(92,152.78) 91.99,152.78 91.69,152.47 91.12,152.47 88.48,155.12 88.48,155.72 85.34,158.86 84.8,158.86 83.63,160.03 82.8,160.03 80.88,161.95 79.82,161.95 79.04,162.73 76.26,162.73 74.15,164.84 74.15,209 63.69,219.46 63.69,221.12 64.35,221.78 SLOT2.A16
  BOTTOM w0.089: v3(63.6,125.54) 63.44,125.54 63.23,125.33 63.23,125.2 63.93,124.49 69.28,124.49 69.71,124.92 69.85,124.92 69.86,124.93 69.88,124.93
  BOTTOM w0.102: v1(92,152.78) 92,152.59 91.81,152.41 91.32,152.41 90.97,152.05 90.97,150.99 90.28,150.3 90.28,149.78 88.81,148.31 86.42,148.31 79.66,141.55 79.66,138.09 81.24,136.52 81.24,133.21 80.86,132.83 80.86,132.35 81.24,131.96 v2(81.24,130.56) 81.24,130.02 79.51,128.3 75.97,128.3 72.92,125.25 70.82,125.25 70.5,124.93 69.88,124.93
PCH_HSON5: length 7
  TOP w0.089: U4.D22 66.84,124.97 67.07,125.19 67.4,125.19 67.49,125.27 68.3,125.27 68.56,125.53 70.34,125.53 70.67,125.86 70.67,125.87 70.69,125.89
  TOP w0.102: 70.69,125.89 71.34,126.54 72.35,126.54 72.45,126.64 72.45,126.78 CL4.1
PCH_HSON5_C: length 2.9
  TOP w0.102: RTK_LAN.18 109.65,224.88 109.23,224.46 109.23,224.3 108.41,223.48 108,223.48 CL1.2
PCH_HSON6: length 108.7
  TOP w0.089: U4.B22 67.83,124.75 68.47,124.75 68.74,125.02 70.59,125.02 70.8,125.22 71.12,125.22 71.13,125.23 71.15,125.23
  TOP w0.102: 71.15,125.23 72.14,125.23 72.37,125.46 72.37,125.6 v1(72.09,125.88) ; CX118.1 50.68,189.01 50.68,188.67 50.78,188.57 50.78,182.3 51.82,181.25 51.82,180.62 56.7,175.74 65.57,175.74 73.46,167.85 73.46,164.42 76.91,160.98 79.4,160.98 80.39,159.99 80.87,159.99 82.05,158.81 82.05,156.8 86.52,152.33 89.34,152.33 89.91,151.76 90.27,151.76 v1(90.37,151.86)
  BOTTOM w0.102: v1(90.37,151.86) 90.11,151.86 89.99,151.99 89.49,151.99 89.15,151.66 89.15,149.62 88.53,149 86.11,149 78.6,141.48 78.6,139.64 78.21,139.26 78.21,138.3 78.6,137.92 78.6,137.1 v2(79.38,136.32) 80.17,135.53 80.17,129.93 79.22,128.98 75.69,128.98 73.76,127.05 72.59,127.05 72.29,126.74 72.29,126.08 v1(72.09,125.88)
PCH_HSON7: length 152.3
  TOP w0.089: v1(71.15,123.91) 70.92,123.68 70.92,123.54 70.61,123.23 69.41,123.23 68.6,124.04 67.91,124.04 67.67,124.12 67.37,124.12 67.13,124.36 U4.C23
  TOP w0.102: v1(93.33,153.47) 92.94,153.47 92.76,153.64 90.97,153.64 89.41,155.2 89.41,160.89 88.72,161.58 86.65,161.58 85.53,162.7 84.92,162.7 83.74,163.89 80.53,163.89 79.69,164.73 78.1,164.73 77.18,163.81 76.3,163.81 74.84,165.27 74.84,209.3 66.84,217.3 66.84,221.26 65.31,222.78 63.86,222.78 62.97,221.89 59.44,221.89 58.33,220.78 56.68,220.78 56.28,220.38 55.24,220.38 55,220.62 55,220.89 CX53.1
  BOTTOM w0.102: v1(93.33,153.47) 93.33,153.2 93.67,152.87 93.67,152.41 91.17,149.91 91.17,149.41 89.18,147.42 86.81,147.42 80.55,141.17 80.55,139.52 82.51,137.57 82.51,136.77 82.89,136.39 82.89,135.9 82.13,135.14 82.13,134.59 v2(82.51,134.21) 82.51,129.87 80.04,127.41 76.37,127.41 73.32,124.36 71.19,124.36 71.02,124.19 71.02,124.05 v1(71.15,123.91)
PCH_HSON7_C: length 6.4
  TOP w0.102: CX53.2 54.97,222.62 54.97,222.93 55.18,223.14 55.79,223.14 56.14,222.78 SLOT2.B15
PCH_HSOP5: length 6.9
  TOP w0.089: U4.C22 67.3,125 67.48,125 67.56,125.08 68.38,125.08 68.64,125.34 70.41,125.34 70.81,125.73 70.82,125.73 70.83,125.74
  TOP w0.102: CL3.1 72.97,127.06 72.65,126.75 72.65,126.56 72.43,126.34 71.43,126.34 70.83,125.74
PCH_HSOP5_C: length 2.9
  TOP w0.102: RTK_LAN.17 109.25,224.77 109.02,224.54 109.02,224.38 108.32,223.68 107.99,223.68 107.79,223.88 CL2.2
PCH_HSOP6: length 108.7
  TOP w0.089: U4.A23 68.22,124.56 68.55,124.56 68.82,124.83 70.67,124.83 70.88,125.03 71.12,125.03 71.13,125.03 71.15,125.03
  TOP w0.102: 71.15,125.03 72.23,125.03 72.58,125.37 72.58,125.6 v1(72.85,125.88) ; CX119.1 50.48,189.01 50.48,188.59 50.58,188.49 50.58,182.21 51.62,181.17 51.62,180.53 56.62,175.54 65.49,175.54 73.26,167.77 73.26,164.33 76.82,160.77 79.32,160.77 80.3,159.79 80.78,159.79 81.85,158.73 81.85,156.71 86.43,152.13 89.26,152.13 89.83,151.55 v1(89.83,151.32)
  BOTTOM w0.102: v1(72.85,125.88) 72.49,126.25 72.49,126.66 72.68,126.85 73.84,126.85 75.77,128.78 79.31,128.78 80.37,129.84 80.37,135.61 79.96,136.02 79.96,136.56 79.62,136.9 79.08,136.9 78.8,137.19 78.8,138.01 78.42,138.39 78.42,138.63 v2(78.8,139.01) 78.8,141.39 86.2,148.79 88.61,148.79 89.36,149.54 89.36,151.57 89.57,151.79 89.85,151.79 89.96,151.69 89.96,151.45 v1(89.83,151.32)
PCH_HSOP7: length 152.3
  TOP w0.089: U4.B23 67.54,124.48 67.63,124.57 67.76,124.57 67.84,124.49 67.84,124.38 67.91,124.27 68.03,124.23 68.68,124.23 68.87,124.04 69.01,124.04 69.2,123.85 69.2,123.71 69.49,123.42 69.76,123.42 69.86,123.52 70.13,123.52 70.23,123.42 70.53,123.42 70.73,123.62 70.73,123.89 70.61,124.01 70.41,124.01 v1(70.31,123.91)
  TOP w0.102: v1(92.79,152.93) 92.79,153.32 92.68,153.44 90.88,153.44 89.21,155.11 89.21,160.81 88.64,161.38 86.57,161.38 85.45,162.5 84.84,162.5 83.65,163.69 80.44,163.69 79.61,164.53 78.19,164.53 77.27,163.6 76.21,163.6 74.63,165.18 74.63,209.21 66.63,217.21 66.63,221.18 65.23,222.58 63.95,222.58 63.06,221.69 59.53,221.69 58.41,220.57 56.76,220.57 56.37,220.18 55.16,220.18 54.8,220.54 54.8,220.89 CX52.1
  BOTTOM w0.102: v1(92.79,152.93) 93.32,152.93 93.47,152.78 93.47,152.5 90.97,150 90.97,149.49 89.1,147.62 86.72,147.62 80.35,141.25 80.35,139.44 82.3,137.48 v2(82.3,136.14) 82.3,135.61 81.92,135.22 81.92,133.97 82.3,133.59 82.3,129.95 79.96,127.61 76.28,127.61 73.24,124.56 71.1,124.56 70.67,124.13 70.53,124.13 v1(70.31,123.91)
PCH_HSOP7_C: length 6.4
  TOP w0.102: SLOT2.B14 58.55,223.78 58.78,223.55 58.78,223.19 58.57,222.98 56.23,222.98 55.87,223.34 55.1,223.34 54.77,223.01 54.77,222.57 CX52.2
PCH_ITP_PMODE: length 148.5
  TOP w0.089: 44.58,139.03 44.58,138.31 45.22,137.67 48.88,137.67 49.71,136.84 50.23,136.84 50.77,136.31 50.77,135.62 50.9,135.5 50.9,135.04 50.59,134.73 U4.AT2
  TOP w0.102: 44.58,139.03 44.58,145 44.86,145.28 44.86,146.69 46.84,148.67 46.84,151.82 55.04,160.02 66.62,160.02 68.24,158.39 70.52,158.39 74.65,154.26 74.65,151.83 79.08,147.4 84.14,147.4 86.51,145.03 v1(86.9,145.03) ; RS16.2 116.75,192.68 110.73,186.66 110.73,179.6 115.96,174.37 115.96,164.01 105.92,153.97 104.99,153.97 101.21,150.2 98.29,150.2 v1(97.44,149.35)
  BOTTOM w0.102: v1(86.9,145.03) 87.13,145.03 87.69,145.59 89.94,145.59 93,148.65 93,149.1 94.27,150.37 94.9,150.37 v2(95.35,149.92) 96.77,149.92 97.34,149.35 v1(97.44,149.35)
PCH_JTAG_TCK: length 224.7
  TOP w0.089: U4.AN3 52.28,134.6 52.14,134.74 52.14,135.61 52.29,135.76 52.29,136.48 50.72,138.05 49.86,138.05 49.26,138.64 49.26,139.01
  TOP w0.102: 49.26,139.01 49.26,139.62 48.23,140.66 48.23,143.51 RP8.1 47.48,144.26 47.48,145.2 47.76,145.48 47.76,146.5 48.39,147.13 48.39,151.18 55.68,158.47 65.97,158.47 67.6,156.84 69.88,156.84 73.07,153.64 73.07,151.22 78.44,145.85 83.37,145.85 85.94,143.29 85.94,142.91 85.94,135.94 v1(85.89,135.89) ; XDP_CPU.55 132.66,202.41 v1(132.64,202.43) ; v1(129.94,208.65) 129.61,208.98 128.89,208.98 126.1,211.77 115.64,211.77 112.99,209.12 112.99,201.58 105.82,194.41 105.82,189.1 105.67,188.95 103.97,188.95 103.79,188.77 103.79,188.54 103.97,188.37 105.65,188.37 105.82,188.19 105.82,187.97 105.64,187.79 103.94,187.79 103.76,187.61 103.76,187.36 103.94,187.18 105.64,187.18 105.82,187 105.82,186.75 105.64,186.57 103.94,186.57 103.76,186.39 103.76,186.14 103.94,185.96 105.64,185.96 105.82,185.78 105.82,185.53 105.64,185.35 103.94,185.35 103.76,185.17 103.76,184.92 103.94,184.74 105.64,184.74 105.82,184.56 105.82,184.31 105.64,184.13 103.94,184.13 103.76,183.95 103.76,183.7 103.94,183.52 105.64,183.52 105.82,183.34 105.82,183.09 105.64,182.91 103.94,182.91 103.76,182.73 103.76,182.48 103.94,182.3 105.64,182.3 105.82,182.12 105.82,181.87 105.64,181.69 103.94,181.69 103.76,181.51 103.76,176.45 102.6,175.29 100.84,175.29 96.1,170.54 96.1,165.15 100.59,160.65 100.59,156.12 99.35,154.87 v1(99.35,154.56)
  BOTTOM w0.102: v1(85.89,135.89) 86.42,136.42 88.01,136.42 88.32,136.73 90.03,136.73 90.64,137.34 91.7,137.34 92.31,137.95 93.15,137.95 95.41,140.21 96.17,140.21 100.43,144.46 100.43,146.82 101.57,147.96 101.57,150.69 100.74,151.51 100.74,152.66 99.86,153.54 v2(99.86,153.54) 99.35,154.05 v1(99.35,154.56) ; v1(129.94,208.65) 130.67,207.93 130.67,202.44 130.87,202.23 132.45,202.23 v1(132.64,202.43)
PCH_LPC_AD0: length 23.2
  TOP w0.089: U4.AT22 51.01,125.48 v1(51.01,125.68)
  TOP w0.102: R6375.2 31.66,121.79 v1(31.91,121.54)
  BOTTOM w0.089: v1(51.01,125.68) 50.14,124.81 47.19,124.81 46.24,123.86 45.57,123.86 45.36,124.07 44.85,124.07 43.87,123.09 43.23,123.09
  BOTTOM w0.102: 43.23,123.09 40.3,123.09 37.98,120.78 34.6,120.78 33.84,121.54 v1(31.91,121.54)
PCH_LPC_AD1: length 23.2
  TOP w0.089: v1(50.38,125.68) 50.38,125.61 U4.AV22
  TOP w0.102: R6378.2 31.39,122.99 32.24,122.99 v1(32.42,123.16)
  BOTTOM w0.089: v1(50.38,125.68) 49.7,125 47.11,125 46.16,124.05 45.68,124.05 45.48,124.26 44.76,124.26 43.82,123.32 43.23,123.32
  BOTTOM w0.102: v1(32.42,123.16) 32.6,123.16 34.75,121.01 37.33,121.01 v2(37.82,121.5) 38.19,121.87 38.75,121.87 40.2,123.32 43.23,123.32
PCH_LPC_AD2: length 24.2
  TOP w0.089: v1(51.01,126.69) U4.AT19
  TOP w0.102: R6380.2 v1(31.71,123.57)
  BOTTOM w0.089: v1(51.01,126.69) 50.49,126.16 50.22,126.16 49.97,125.91 49.97,125.55 49.63,125.2 46.94,125.2 46.63,124.89 45.12,124.89 43.77,123.55 43.23,123.55
  BOTTOM w0.102: 43.23,123.55 40.11,123.55 38.77,122.21 37.69,122.21 36.71,121.23 34.98,121.23 32.53,123.69 31.86,123.69 31.79,123.62 31.78,123.62 31.73,123.57 v1(31.71,123.57)
PCH_LPC_AD3: length 16
  TOP w0.089: 43.19,126.95 44.24,126.95 44.88,127.6 46.4,127.6 46.54,127.73 46.65,127.73 46.88,127.96 U4.BD16
  TOP w0.102: 43.19,126.95 41.25,126.95 40,125.7 38.77,125.7 37.55,124.49 34.93,124.49 v1(34.7,124.26) 34.7,123.89 R6383.2
  BOTTOM w0.102: v1(34.7,124.26) 34.53,124.08 v2(34.53,123.49)
PCH_LPC_FRAME#: length 14.2
  TOP w0.089: U4.BE16 46.33,127.79 44.8,127.79 44.19,127.18 43.19,127.18
  TOP w0.102: R6388.2 34.01,124.19 34.53,124.71 37.45,124.71 38.67,125.93 39.91,125.93 41.16,127.18 43.19,127.18
PCH_M2_SSD_CLKREQ_N: length 216.7
  TOP w0.089: 43.19,122.98 43.38,122.98 44.5,124.1 45.66,124.1 45.75,124.02 46.28,124.02 46.89,123.41 U4.BD25
  TOP w0.102: v1(87.32,131.33) 86.79,130.79 86.79,125.33 87.94,124.18 87.94,115.55 83.98,111.59 83.98,109.12 87.66,105.44 89.01,105.44 92.92,101.52 92.92,96.04 88.73,91.85 84.59,91.85 82.74,89.99 82.74,88.82 83.22,88.34 84.46,88.34 84.62,88.19 84.62,86.28 85.43,85.47 v1(85.43,78.69) ; v1(29.5,121.72) 20.53,121.72 19.86,121.04 19.86,117.19 23.42,113.63 23.42,102.96 25.18,101.2 25.18,89.71 27.65,87.24 28.23,87.24 29.71,85.76 31.32,85.76 31.96,85.13 34.08,85.13 34.67,84.54 41.06,84.54 41.29,84.77 42.2,84.77 44.59,87.16 47.55,87.16 48.75,85.96 48.75,85.12 49.44,84.43 53.02,84.43 53.25,84.2 53.51,84.2 v1(53.68,84.03) ; M.2_SSD.52 v1(100.64,131.5) ; 43.19,122.98 40.85,122.98 38.87,121.01 36.86,121.01 36.12,120.26 v1(33.57,120.26) 33.5,120.19 RX185.2
  BOTTOM w0.102: v1(33.57,120.26) 32.9,120.93 31.23,120.93 30.44,121.72 v1(29.5,121.72) ; v1(53.68,84.03) 53.68,82.29 55.84,80.12 56.98,80.12 57.21,80.35 62.13,80.35 62.73,79.76 64.12,79.76 65.06,78.82 68.09,78.82 68.45,79.17 76.56,79.17 77.48,78.26 85,78.26 v1(85.43,78.69) ; v1(87.32,131.33) 91.23,131.33 v2(91.47,131.57) 91.52,131.62 95.41,131.62 95.82,131.22 100.37,131.22 v1(100.64,131.5)
