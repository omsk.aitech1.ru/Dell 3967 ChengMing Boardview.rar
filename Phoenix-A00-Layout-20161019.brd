# Allegro board Phoenix-A00-Layout-20161019.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_DB3: length 96.9
  TOP w0.089: CPU.AH35 v1(180.51,140.09)
  L3_GND w0.089: v1(180.51,140.09) 180.73,140.31 183.43,140.31 183.73,140.61 185.68,140.61 185.94,140.87 189.18,140.87
  L3_GND w0.14: 189.18,140.87 194.65,140.87 202.12,133.41 202.12,125.2 202.53,124.79 202.8,124.79 203.19,125.18 203.46,125.18 203.65,124.99 203.65,124.72 203.26,124.33 203.26,124.06 203.45,123.87 203.72,123.87 204.11,124.26 204.38,124.26 204.57,124.07 204.57,123.8 204.18,123.41 204.18,123.14 204.37,122.95 204.64,122.95 205.03,123.34 205.3,123.34 205.49,123.15 205.49,122.88 205.1,122.49 205.1,122.22 205.29,122.03 205.56,122.03 205.95,122.42 206.22,122.42 206.41,122.23 206.41,121.96 206.02,121.57 206.02,121.3 206.21,121.11 206.48,121.11 206.87,121.5 207.14,121.5 207.33,121.31 207.33,121.04 206.94,120.65 206.94,120.38 207.13,120.19 207.4,120.19 207.79,120.58 208.06,120.58 208.25,120.39 208.25,120.12 207.86,119.73 207.86,119.46 208.05,119.27 208.32,119.27 208.71,119.66 208.98,119.66 209.17,119.47 209.17,119.2 208.78,118.81 208.78,118.54 212.86,114.46 212.86,93.37 213.77,92.46 214.16,92.46 214.41,92.2 214.41,90.88 213.93,90.4 213.93,89.85 214.41,89.36 214.41,87.5 215.26,86.65 215.26,84 214.41,83.15 214.41,82.4 213.93,81.92 213.93,80.16 214.16,79.93 214.16,79.33 DIMM2.157
M_DB4: length 97.8
  TOP w0.089: v1(180.51,142.83) CPU.AE35
  L3_GND w0.089: v1(180.51,142.83) 180.82,142.83 181.25,143.26 184.45,143.26 184.91,143.72 185.79,143.72 186.5,144.42 189.9,144.42
  L3_GND w0.14: DIMM2.150 219.69,79.57 220.45,80.33 220.45,81.76 219.88,82.34 219.88,82.99 220.07,83.19 220.07,84.24 220.36,84.53 220.36,87.16 219.88,87.65 219.88,88.2 220.36,88.68 220.36,90.44 219.51,91.29 219.51,92.18 218.8,92.89 218.8,93.68 217.99,94.49 217.99,115.77 208.51,125.25 208.51,125.52 208.87,125.87 208.87,126.14 208.68,126.33 208.41,126.33 208.05,125.98 207.78,125.98 207.59,126.17 207.59,126.44 207.95,126.79 207.95,127.06 207.76,127.25 207.49,127.25 207.13,126.9 206.86,126.9 206.23,127.53 206.23,134.29 196.09,144.42 189.9,144.42
M_DB5: length 99.1
  TOP w0.089: v1(179.6,142.83) CPU.AE34
  L3_GND w0.089: v1(179.6,142.83) 180.05,143.29 180.67,143.29 180.93,143.55 184.38,143.55 184.8,143.97 185.68,143.97 186.8,145.08 189.9,145.08
  L3_GND w0.14: DIMM2.5 220.54,84.14 220.94,84.53 220.94,85.13 220.73,85.34 220.73,86.6 221.21,87.08 221.21,89.36 220.73,89.85 220.73,90.6 219.88,91.45 219.88,92.52 219.53,92.87 219.53,93.86 218.64,94.76 218.64,116.04 214.38,120.29 214.38,120.56 214.79,120.97 214.79,121.24 214.6,121.43 214.33,121.43 213.92,121.02 213.66,121.02 213.46,121.21 213.46,121.48 213.87,121.89 213.87,122.16 213.68,122.35 213.41,122.35 213,121.94 212.74,121.94 212.54,122.13 212.54,122.4 212.95,122.81 212.95,123.08 212.76,123.27 212.49,123.27 212.08,122.86 211.82,122.86 211.62,123.05 211.62,123.32 212.03,123.73 212.03,124 211.84,124.19 211.57,124.19 211.16,123.78 210.9,123.78 210.7,123.97 210.7,124.24 211.11,124.65 211.11,124.92 210.92,125.11 210.65,125.11 210.24,124.7 209.98,124.7 209.78,124.89 209.78,125.16 210.19,125.57 210.19,125.84 206.88,129.15 206.88,134.56 196.35,145.08 189.9,145.08
M_DB6: length 98.3
  TOP w0.089: v1(179.6,141) CPU.AG34
  L3_GND w0.089: 189.9,142.88 186.56,142.88 185.86,142.18 184.95,142.18 184.61,141.84 181.06,141.84 180.67,141.46 180.28,141.46 179.82,141 v1(179.6,141)
  L3_GND w0.14: DIMM2.10 216.29,80.51 216.49,80.31 216.87,80.31 217.1,80.54 217.1,81.62 216.48,82.25 216.48,82.99 217.63,84.15 217.63,84.71 217.33,85.02 217.33,86.8 216.48,87.65 216.48,88.2 217.33,89.05 217.33,90.14 216.48,90.99 216.48,92.99 214.84,94.63 214.84,97.05 215.03,97.24 215.55,97.24 215.74,97.43 215.74,97.7 215.55,97.89 215.03,97.89 214.84,98.08 214.84,98.35 215.03,98.54 215.55,98.54 215.74,98.73 215.74,99 215.55,99.19 215.03,99.19 214.84,99.38 214.84,99.65 215.03,99.84 215.55,99.84 215.74,100.03 215.74,100.3 215.55,100.49 215.03,100.49 214.84,100.68 214.84,100.95 215.03,101.14 215.55,101.14 215.74,101.33 215.74,101.6 215.55,101.79 215.03,101.79 214.84,101.98 214.84,102.25 215.03,102.44 215.55,102.44 215.74,102.63 215.74,115.69 204.64,126.79 204.64,133.63 195.39,142.88 189.9,142.88
M_DB7: length 97.6
  TOP w0.089: v1(180.51,141) CPU.AG35
  L3_GND w0.089: v1(180.51,141) 180.67,141 181.21,141.55 184.77,141.55 185.11,141.89 185.93,141.89 186.26,142.21 189.9,142.21
  L3_GND w0.14: 189.9,142.21 195.14,142.21 204,133.36 204,130.46 203.41,129.88 203.41,127.1 215.09,115.42 215.09,109.85 214.9,109.66 214.35,109.66 214.16,109.47 214.16,109.2 214.35,109.01 214.9,109.01 215.09,108.82 215.09,108.55 214.9,108.36 214.35,108.36 214.16,108.17 214.16,107.9 214.35,107.71 214.9,107.71 215.09,107.52 215.09,107.25 214.9,107.06 214.35,107.06 214.16,106.87 214.16,106.6 214.35,106.41 214.9,106.41 215.09,106.22 215.09,105.95 214.9,105.76 214.35,105.76 214.16,105.57 214.16,105.3 214.35,105.11 214.9,105.11 215.09,104.92 215.09,104.65 214.9,104.46 214.35,104.46 214.16,104.27 214.16,104 214.35,103.81 214.75,103.81 214.94,103.62 214.94,103.35 214.75,103.16 214.35,103.16 214.16,102.97 214.16,94.26 216.11,92.3 216.11,90.88 215.63,90.4 215.63,89.85 216.11,89.36 216.11,87.5 216.96,86.65 216.96,86.02 216.11,85.17 216.11,82.37 215.44,81.71 DIMM2.155
M_DB8: length 86.6
  TOP w0.089: CPU.AL34 179.14,136.92 v1(179.6,137.38)
  L3_GND w0.089: v1(179.6,137.38) 180.05,137.83 180.69,137.83 180.7,137.84 180.7,137.84 181.32,138.46 183.74,138.46 184.17,138.89 188.62,138.89
  L3_GND w0.14: 188.62,138.89 193.89,138.89 200.17,132.6 200.17,124.4 203.77,120.8 203.77,120.53 203.49,120.25 203.49,119.98 203.68,119.79 203.95,119.79 204.23,120.07 204.5,120.07 204.69,119.88 204.69,119.61 204.41,119.33 204.41,119.06 204.6,118.87 204.87,118.87 205.15,119.15 205.42,119.15 205.61,118.96 205.61,118.69 205.33,118.41 205.33,118.14 210.92,112.56 210.92,92.78 211.38,92.32 211.38,91.25 210.53,90.4 210.53,89.85 211.38,89 211.38,87.65 211.86,87.16 211.86,85.12 212.07,84.9 212.07,84.01 211.38,83.32 211.38,82.4 211.86,81.91 211.86,80.48 211.69,80.31 211.39,80.31 211.19,80.51 DIMM2.16
M_DB9: length 85.6
  TOP w0.089: CPU.AL35 180.05,136.9 v1(180.51,137.37)
  L3_GND w0.089: 188.62,138.23 185.11,138.23 184.86,137.97 181.42,137.97 180.82,137.37 v1(180.51,137.37)
  L3_GND w0.14: 188.62,138.23 193.63,138.23 199.52,132.33 199.52,123.04 199.74,122.82 200.01,122.82 200.27,123.09 200.54,123.09 200.73,122.9 200.73,122.63 200.47,122.36 200.47,122.09 200.66,121.9 200.93,121.9 201.19,122.17 201.46,122.17 201.65,121.98 201.65,121.71 201.39,121.44 201.39,121.17 201.58,120.98 201.85,120.98 202.11,121.25 202.38,121.25 202.57,121.06 202.57,120.79 202.31,120.52 202.31,120.25 210.27,112.29 210.27,92.91 211.01,92.17 211.01,91.4 210.16,90.55 210.16,89.05 211.01,88.2 211.01,87.08 210.53,86.6 210.53,83.9 211.01,83.42 211.01,82.3 210.34,81.63 210.34,80.7 209.94,80.29 209.94,79.32 DIMM2.161
M_DB10: length 88.4
  TOP w0.089: CPU.AK32 v1(176.85,138.26)
  L3_GND w0.089: 188.62,136.68 185.93,136.68 185.81,136.79 183.04,136.79 182.72,136.47 179.36,136.47 178.91,136.92 177.59,136.92 177.33,137.19 177.33,137.79 v1(176.85,138.26)
  L3_GND w0.14: 188.62,136.68 192.98,136.68 197.98,131.68 197.98,122.3 198.28,122 198.28,121.73 198,121.45 198,121.18 198.19,120.99 198.46,120.99 198.74,121.27 199.01,121.27 199.2,121.08 199.2,120.81 198.87,120.48 198.87,120.21 199.06,120.02 199.33,120.02 199.66,120.35 199.93,120.35 200.12,120.16 200.12,119.89 199.74,119.51 199.74,119.24 199.93,119.05 200.2,119.05 200.58,119.43 200.85,119.43 201.38,118.9 201.38,118.63 200.86,118.11 200.86,117.84 201.05,117.65 201.32,117.65 201.84,118.17 202.11,118.17 208.33,111.95 208.33,106.89 207.98,106.55 207.98,106.13 208.34,105.77 208.34,105.48 207.98,105.12 207.98,104.83 208.34,104.47 208.34,104.18 207.98,103.82 207.98,103.53 208.34,103.17 208.34,102.88 207.98,102.52 207.98,102.23 208.34,101.87 208.34,101.58 207.98,101.22 207.98,100.93 208.34,100.56 208.34,100.28 207.98,99.91 207.98,99.63 208.34,99.26 208.34,98.98 207.98,98.61 207.98,98.32 208.34,97.96 208.34,97.67 207.98,97.31 207.98,97.02 208.34,96.66 208.34,96.37 207.98,96.01 207.98,95.72 208.34,95.36 208.34,95.07 207.98,94.71 207.98,94.42 208.34,94.06 208.34,93.77 207.98,93.41 207.98,91.25 207.13,90.4 207.13,89.85 207.98,89 207.98,87.65 207.98,87.64 207.98,87.45 207.13,86.6 207.13,85.17 207.42,84.87 207.42,84.13 206.94,83.65 DIMM2.21
M_DB11: length 87.7
  TOP w0.089: CPU.AL32 177.31,136.92 v1(176.86,137.36)
  L3_GND w0.089: 188.62,136.02 185.85,136.02 185.46,136.4 183.45,136.4 183.22,136.17 179.3,136.17 178.81,136.66 177.53,136.66 176.86,137.33 v1(176.86,137.36)
  L3_GND w0.14: DIMM2.166 206.09,79.01 206.76,79.68 206.76,81.96 206.28,82.44 206.28,83.66 206.76,84.15 206.76,86.75 207.61,87.6 207.61,88.85 206.76,89.7 206.76,90.55 207.61,91.4 207.61,92.27 207.02,92.86 207.02,94.4 206.66,94.75 206.66,95.05 207.02,95.4 207.02,95.86 206.74,96.14 206.74,96.51 207.02,96.79 207.02,97.16 206.74,97.44 206.74,97.81 207.02,98.09 207.02,98.46 206.74,98.74 206.74,99.11 207.02,99.39 207.02,99.76 206.74,100.04 206.74,100.41 207.02,100.69 207.02,106.5 207.68,107.16 207.68,111.68 204.81,114.55 201.3,114.55 197.33,118.53 197.33,131.42 192.73,136.02 188.62,136.02
M_DB12: length 87
  TOP w0.089: CPU.AK34 v1(178.68,138.26)
  L3_GND w0.089: 188.62,140.21 183.88,140.21 183.55,139.88 180.98,139.88 180.73,139.63 180.38,139.63 180.01,139.26 180.01,139 179.77,138.76 179.18,138.76 v1(178.68,138.26)
  L3_GND w0.14: DIMM2.14 212.89,81.85 213.08,82.03 213.08,82.99 214.05,83.97 214.05,84.96 213.72,85.29 213.72,87 213.08,87.65 213.08,88.96 212.23,89.81 212.23,90.43 213.08,91.28 213.08,92.27 212.21,93.14 212.21,113.14 209.96,115.4 209.96,115.67 210.21,115.92 210.21,116.19 210.02,116.38 209.75,116.38 209.5,116.13 209.23,116.13 209.04,116.32 209.04,116.59 209.29,116.84 209.29,117.11 201.47,124.93 201.47,133.14 194.4,140.21 188.62,140.21
M_DB13: length 86.3
  TOP w0.089: v1(180.51,138.29) 180.05,137.83 CPU.AK35
  L3_GND w0.089: 188.62,139.55 185.89,139.55 185.55,139.21 183.86,139.21 183.43,138.78 180.78,138.78 180.51,138.51 v1(180.51,138.29)
  L3_GND w0.14: 188.62,139.55 194.14,139.55 200.82,132.87 200.82,124.66 206.62,118.86 206.62,117.77 207.06,117.33 207.33,117.33 207.58,117.58 207.85,117.58 208.04,117.39 208.04,117.12 207.79,116.87 207.79,116.6 211.56,112.83 211.56,92.89 212,92.46 212.38,92.46 212.71,92.12 212.71,91.43 211.86,90.58 211.86,89.66 212.71,88.81 212.71,87.28 212.23,86.8 212.23,86.05 212.71,85.56 212.71,82.33 212.23,81.84 212.23,80.64 212.73,80.14 212.73,79.61 DIMM2.159
M_DB14: length 88.7
  TOP w0.089: CPU.AK31 v1(175.94,138.26)
  L3_GND w0.089: v1(175.94,138.26) 176.4,137.8 176.4,137.14 176.67,136.87 177.02,136.87 177.65,136.24 178.87,136.24 179.19,135.92 183.44,135.92 183.81,135.55 185.46,135.55 185.66,135.36 188.62,135.36
  L3_GND w0.14: 188.62,135.36 192.47,135.36 196.68,131.15 196.68,115.48 196.82,115.34 197.94,115.34 198.13,115.15 198.13,114.88 197.94,114.69 196.76,114.69 196.57,114.5 196.57,113.68 196.76,113.48 198.04,113.48 198.23,113.29 198.23,113.03 198.04,112.83 196.76,112.83 196.57,112.64 196.57,112.37 196.76,112.18 197.81,112.18 198,111.99 198,111.72 197.81,111.53 196.76,111.53 196.57,111.34 196.57,111.07 196.76,110.88 197.25,110.88 197.44,110.69 197.44,110.42 197.25,110.23 196.76,110.23 196.57,110.04 196.57,109.77 196.76,109.58 197.25,109.58 197.44,109.39 197.44,109.12 197.25,108.93 196.76,108.93 196.57,108.74 196.57,108.29 202.9,101.96 202.9,96.75 204.87,94.78 204.87,94.78 206.28,93.37 206.28,91.25 205.43,90.4 205.43,89.85 206.08,89.2 206.08,87.25 205.43,86.6 205.43,83.7 205.24,83.52 DIMM2.23
M_DB15: length 88.1
  TOP w0.089: CPU.AL31 v1(176.85,136.43)
  L3_GND w0.089: 188.62,134.7 186.01,134.7 185.68,135.03 179.46,135.03 179.17,135.32 179.17,135.58 178.83,135.92 177.37,135.92 v1(176.85,136.43)
  L3_GND w0.14: DIMM2.168 204.39,79.01 205.06,79.68 205.06,81.96 204.58,82.44 204.58,83.46 205.06,83.95 205.06,87.16 204.58,87.65 204.58,88.2 205.06,88.68 205.06,90.55 205.91,91.4 205.91,92.56 205.46,93.01 204.69,93.01 203.38,94.32 203.38,94.83 203.17,95.04 202.66,95.04 202.46,95.24 202.46,95.75 202.25,95.96 201.74,95.96 201.05,96.65 201.05,97.22 201.24,97.41 201.92,97.41 202.12,97.6 202.12,97.87 201.92,98.06 201.24,98.06 201.05,98.25 201.05,98.52 201.24,98.71 202.05,98.71 202.24,98.9 202.24,99.17 202.05,99.36 201.24,99.36 201.05,99.55 201.05,99.82 201.24,100.01 202.05,100.01 202.24,100.2 202.24,100.47 202.05,100.66 201.24,100.66 201.05,100.85 201.05,102.89 195.92,108.02 195.92,115.46 196.03,115.57 196.03,130.88 192.21,134.7 188.62,134.7
M_DB16: length 75.9
  TOP w0.089: CPU.AP34 v1(179.6,134.58)
  L3_GND w0.089: v1(179.6,134.58) 179.93,134.58 180.34,134.16 180.75,134.16 180.81,134.1 184.73,134.1 185.11,133.72 187.06,133.72 187.4,133.38
  L3_GND w0.14: DIMM2.170 202.69,79.01 203.36,79.68 203.36,81.46 202.88,81.94 202.88,83.52 203.36,84 203.36,86.65 202.51,87.5 202.51,88.35 203.36,89.2 203.36,90.42 202.88,90.91 202.88,92.99 199.75,96.11 199.75,102.26 194.22,107.8 194.22,125.22 194.74,125.74 194.74,130.34 192.64,132.44 188.35,132.44 187.4,133.38
M_DB17: length 74.4
  TOP w0.089: CPU.AP35 v1(180.51,133.69)
  L3_GND w0.089: 184.87,133.28 180.92,133.28 v1(180.51,133.69)
  L3_GND w0.14: 184.87,133.28 185.27,133.28 187.36,131.19 187.36,129.64 188.07,128.93 188.07,127.71 191.5,124.28 192.25,124.28 192.39,124.42 192.39,124.68 192.62,124.9 193,124.9 193.21,124.69 193.21,119.43 193.05,119.27 192.96,119.27 192.79,119.11 192.79,118.87 192.96,118.71 193.05,118.71 193.21,118.55 193.21,118.31 193.05,118.15 192.96,118.15 192.79,117.99 192.79,117.76 192.96,117.59 193.05,117.59 193.21,117.43 193.21,117.2 193.05,117.03 192.96,117.03 192.79,116.87 192.79,116.64 192.96,116.48 193.05,116.48 193.21,116.31 193.21,116.08 193.05,115.92 192.96,115.92 192.79,115.75 192.79,115.52 192.96,115.36 193.05,115.36 193.21,115.19 193.21,107.4 193.53,107.08 193.99,107.08 194.22,106.85 194.22,106.39 194.69,105.93 195.12,105.93 195.36,105.69 195.36,105.25 195.61,105.01 196.04,105.01 196.28,104.77 196.28,104.33 196.53,104.09 196.96,104.09 197.2,103.85 197.2,103.41 197.45,103.17 197.88,103.17 198.12,102.93 198.12,102.49 198.42,102.2 198.42,101.8 198.61,101.61 198.9,101.61 199.09,101.42 199.09,101.15 198.9,100.96 198.61,100.96 198.42,100.77 198.42,100.5 198.61,100.31 198.9,100.31 199.09,100.12 199.09,99.85 198.9,99.66 198.61,99.66 198.42,99.47 198.42,99.2 198.61,99.01 198.9,99.01 199.09,98.82 199.09,98.55 198.9,98.36 198.61,98.36 198.42,98.17 198.42,97.9 198.61,97.71 198.9,97.71 199.09,97.52 199.09,97.25 198.9,97.06 198.61,97.06 198.42,96.87 198.42,96.47 200.3,94.6 200.3,94.33 199.85,93.88 199.85,93.61 200.04,93.42 200.31,93.42 200.76,93.87 201.02,93.87 202.51,92.38 202.51,90.88 202.03,90.4 202.03,89.05 201.18,88.2 201.18,87.65 202.03,86.8 202.03,83.73 201.84,83.55 DIMM2.27
M_DB18: length 78
  TOP w0.089: v1(177.77,134.6) CPU.AN32
  L3_GND w0.089: 184.07,128.86 184.07,128.9 181.69,131.27 181.69,131.28 181.23,131.28 180.66,131.86 179.94,131.86 178.23,133.58 178.23,134.15 v1(177.77,134.6)
  L3_GND w0.14: 184.07,128.86 184.07,127.1 186.46,124.71 187.29,124.71 189.53,122.47 189.94,122.47 190.51,121.9 190.51,111.63 190.38,111.51 189.85,111.51 189.68,111.34 189.68,111 189.85,110.84 190.19,110.84 190.36,110.67 190.36,110.44 190.19,110.28 189.85,110.28 189.68,110.12 189.68,107.52 189.9,107.3 190.41,107.3 190.57,107.14 190.57,106.91 190.41,106.75 189.9,106.75 189.68,106.53 189.68,106.11 190.23,105.56 190.5,105.56 190.92,105.97 191.19,105.97 191.38,105.78 191.38,105.51 190.96,105.1 190.96,104.83 191.15,104.64 191.42,104.64 191.79,105 192.06,105 192.25,104.81 192.25,104.54 191.88,104.18 191.88,103.91 192.2,103.59 192.47,103.59 192.99,104.11 193.25,104.11 193.45,103.92 193.45,103.65 192.93,103.13 192.93,102.86 193.12,102.67 193.39,102.67 193.85,103.14 194.12,103.14 194.31,102.95 194.31,102.68 193.85,102.21 193.85,101.94 194.04,101.75 194.31,101.75 194.75,102.19 195.02,102.19 195.21,102 195.21,101.73 194.72,101.25 194.72,100.83 195.05,100.5 195.05,100.18 194.72,99.85 194.72,99.53 195.05,99.2 195.05,98.88 194.72,98.55 194.72,97.54 195.4,96.87 196.03,96.87 196.22,96.68 196.22,96.41 196.03,96.22 195.54,96.22 195.37,96.06 195.37,95.8 195.87,95.31 195.87,94.11 197.59,92.38 197.59,91.07 196.93,90.4 196.93,89.85 197.65,89.13 197.65,87.32 196.93,86.6 196.93,86.05 197.59,85.38 DIMM2.32
M_DB19: length 77.4
  TOP w0.089: CPU.AP32 v1(177.77,133.69)
  L3_GND w0.089: v1(177.77,133.69) 177.97,133.47 177.97,133.47 179.84,131.61 180.55,131.61 181.35,130.81 181.8,130.81 183.42,129.18 183.42,128.85
  L3_GND w0.14: 183.42,128.85 183.42,126.83 186.19,124.06 187.02,124.06 189.26,121.82 189.67,121.82 189.86,121.63 189.86,121.25 189.7,121.08 189.2,121.08 189.03,120.92 189.03,120.69 189.2,120.53 189.7,120.53 189.86,120.36 189.86,120.13 189.7,119.97 189.2,119.97 189.03,119.8 189.03,119.57 189.2,119.41 189.7,119.41 189.86,119.24 189.86,119.01 189.7,118.85 189.2,118.85 189.03,118.69 189.03,118.45 189.2,118.29 189.7,118.29 189.86,118.13 189.86,117.89 189.7,117.73 189.2,117.73 189.03,117.57 189.03,117.34 189.2,117.17 189.7,117.17 189.86,117.01 189.86,116.78 189.7,116.61 189.2,116.61 189.03,116.45 189.03,116.22 189.2,116.05 189.7,116.05 189.86,115.89 189.86,115.66 189.7,115.5 189.2,115.5 189.03,115.33 189.03,115.1 189.2,114.94 189.7,114.94 189.86,114.77 189.86,114.54 189.7,114.38 189.2,114.38 189.03,114.21 189.03,113.98 189.2,113.82 189.7,113.82 189.86,113.66 189.86,113.42 189.7,113.26 189.2,113.26 189.03,113.1 189.03,112.87 189.2,112.7 189.7,112.7 189.86,112.54 189.86,112.31 189.7,112.14 189.2,112.14 189.03,111.98 189.03,105.79 194.04,100.79 194.04,96.22 195.22,95.04 195.22,93.75 196.08,92.89 196.08,91.45 196.56,90.96 196.56,88.68 196.08,88.2 196.08,87.65 196.56,87.16 196.56,84.95 196.86,84.66 196.86,83.77 196.08,82.99 196.08,82.44 196.74,81.77 196.74,80.73 197.37,80.11 197.37,79.54 DIMM2.177
M_DB20: length 75.8
  TOP w0.089: v1(180.51,134.6) CPU.AN35
  L3_GND w0.089: v1(180.51,134.6) 185.52,134.6 186.09,134.04 188.62,134.04
  L3_GND w0.14: 188.62,134.04 188.83,134.04 189.02,133.85 189.02,133.52 189.21,133.32 189.48,133.32 189.67,133.52 189.67,133.85 189.86,134.04 190.13,134.04 190.32,133.85 190.32,133.52 190.51,133.32 190.78,133.32 190.97,133.52 190.97,133.85 191.16,134.04 191.96,134.04 192.15,133.85 192.15,133.34 192.35,133.13 192.86,133.13 195.38,130.61 195.38,124.21 195.19,124.02 195.09,124.02 194.9,123.83 194.9,123.56 195.09,123.37 195.19,123.37 195.38,123.18 195.38,122.91 195.19,122.72 195.09,122.72 194.9,122.53 194.9,122.26 195.09,122.07 195.19,122.07 195.38,121.88 195.38,121.61 195.19,121.42 195.09,121.42 194.9,121.23 194.9,120.96 195.09,120.77 195.19,120.77 195.38,120.58 195.38,120.31 195.19,120.12 195.09,120.12 194.9,119.93 194.9,119.66 195.09,119.47 195.19,119.47 195.38,119.28 195.38,119.01 195.19,118.82 195.09,118.82 194.9,118.63 194.9,118.36 195.09,118.17 195.19,118.17 195.38,117.98 195.38,117.71 195.19,117.52 195.09,117.52 194.9,117.33 194.9,117.06 195.09,116.87 195.19,116.87 195.38,116.68 195.38,115.84 194.86,115.32 194.86,108.16 200.4,102.62 200.4,96.38 204.43,92.36 204.43,91.14 203.73,90.44 203.73,89.05 202.88,88.2 202.88,87.65 203.73,86.8 203.73,85.47 203.89,85.31 203.89,83.77 203.54,83.42 DIMM2.25
M_DB21: length 76.5
  TOP w0.089: CPU.AN34 178.72,135.46 v1(178.69,135.46)
  L3_GND w0.089: 184.4,132.81 184.21,133 180.5,133 180.03,133.47 180.03,133.86 179.74,134.15 179.3,134.15 179.13,134.31 179.13,134.77 178.69,135.21 v1(178.69,135.46)
  L3_GND w0.14: DIMM2.172 200.99,80.17 201.66,80.84 201.66,81.96 201.18,82.44 201.18,83.62 201.66,84.1 201.66,86.65 200.81,87.5 200.81,88.35 201.66,89.2 201.66,90.96 201.18,91.45 201.18,92.18 200.72,92.63 199.88,92.63 198.88,93.63 198.88,93.9 199.25,94.27 199.25,94.54 199.05,94.73 198.79,94.73 198.52,94.46 198.05,94.46 197.77,94.74 197.77,101.93 192.57,107.14 192.57,108.63 192.4,108.79 192.3,108.79 192.13,108.96 192.13,109.19 192.3,109.35 192.4,109.35 192.57,109.52 192.57,109.75 192.4,109.91 192.3,109.91 192.13,110.07 192.13,110.31 192.3,110.47 192.4,110.47 192.57,110.63 192.57,110.86 192.4,111.03 192.3,111.03 192.13,111.19 192.13,111.42 192.3,111.59 192.4,111.59 192.57,111.75 192.57,111.98 192.4,112.15 192.3,112.15 192.13,112.31 192.13,112.54 192.3,112.7 192.4,112.7 192.57,112.87 192.57,113.1 192.4,113.26 192.3,113.26 192.13,113.43 192.13,113.66 192.3,113.82 192.4,113.82 192.57,113.99 192.57,114.22 192.4,114.38 192.3,114.38 192.13,114.54 192.13,122.73 187.26,127.61 187.26,128.6 186.71,129.15 186.71,130.37 185.48,131.6 185.07,131.6 184.72,131.95 184.72,132.5 184.4,132.81
M_DB22: length 78.7
  TOP w0.089: v1(176.85,134.6) CPU.AN31
  L3_GND w0.089: v1(176.85,134.6) 177.34,134.12 177.34,133.51 177.62,133.23 177.86,133.23 178.17,132.92 178.17,132.91 179.73,131.35 180.45,131.35 181.97,129.83 181.97,128.79 182.2,128.56 182.2,128.52
  L3_GND w0.14: DIMM2.34 195.89,82.11 195.71,82.29 195.71,83.15 195.89,83.33 195.89,85.38 195.23,86.05 195.23,86.6 195.71,87.08 195.71,88.35 195.89,88.53 195.89,89.18 195.23,89.85 195.23,90.4 195.71,90.88 195.71,92.08 194.57,93.22 194.57,94.77 192.49,96.85 192.49,97.47 192.68,97.66 193.16,97.66 193.35,97.85 193.35,98.12 193.16,98.31 192.68,98.31 192.49,98.5 192.49,98.77 192.68,98.96 193.16,98.96 193.35,99.15 193.35,100.48 193.06,100.77 192.79,100.77 192.34,100.32 192.07,100.32 191.88,100.51 191.88,100.78 192.33,101.23 192.33,101.5 192.14,101.69 191.87,101.69 191.42,101.24 191.15,101.24 190.96,101.43 190.96,101.7 191.41,102.15 191.41,102.42 191.22,102.61 190.95,102.61 190.28,101.94 190.01,101.94 189.82,102.13 189.82,102.4 190.49,103.07 190.49,103.34 190.3,103.53 190.03,103.53 188.93,102.43 188.66,102.43 188.47,102.62 188.47,102.89 189.57,103.99 189.57,104.26 189.38,104.45 189.11,104.45 188,103.34 187.73,103.34 187.54,103.53 187.54,103.8 188.6,104.86 188.6,105.23 188.37,105.46 188.37,121.74 186.69,123.42 185.92,123.42 182.2,127.14 182.2,128.52
M_DB23: length 77.8
  TOP w0.089: CPU.AP31 v1(176.85,133.69)
  L3_GND w0.089: 181.55,128.52 181.55,129.43 180.61,130.37 178.7,130.37 177.34,131.73 177.34,132.9 176.85,133.38 v1(176.85,133.69)
  L3_GND w0.14: 181.55,128.52 181.55,128.18 181.39,128.02 181.15,128.02 180.98,127.85 180.98,127.62 181.15,127.46 181.39,127.46 181.55,127.29 181.55,126.87 185.65,122.77 186.42,122.77 187.73,121.47 187.73,106.44 186.62,105.33 186.62,102.9 186.81,102.71 187.35,102.71 187.51,102.55 187.51,102.31 187.35,102.15 186.81,102.15 186.64,101.98 186.64,101.78 186.94,101.49 186.94,101.26 186.72,101.05 186.72,100.81 186.89,100.65 187.12,100.65 187.69,101.22 187.92,101.22 188.08,101.05 188.08,100.82 187.51,100.25 187.51,100.02 187.68,99.86 187.91,99.86 188.73,100.69 188.93,100.69 189.21,100.41 189.21,100.2 188.88,99.87 188.88,99.54 189.05,99.37 189.29,99.37 189.75,99.84 189.98,99.84 190.15,99.67 190.15,99.44 189.68,98.98 189.68,98.74 189.84,98.58 190.08,98.58 190.54,99.05 190.77,99.05 190.94,98.88 190.94,98.65 190.47,98.18 190.47,97.95 190.64,97.79 190.87,97.79 191.33,98.26 191.56,98.26 191.73,98.09 191.73,97.86 191.26,97.39 191.26,97.16 193.67,94.75 193.67,93.29 194.38,92.58 194.38,91.45 194.86,90.96 194.86,88.68 194.38,88.2 194.38,87.65 194.86,87.16 194.86,83.48 194.38,82.99 194.38,82.44 195.04,81.77 195.04,80.65 195.6,80.09 195.6,79.47 DIMM2.179
M_DB24: length 73.2
  TOP w0.089: CPU.AL29 v1(175.03,137.35)
  L3_GND w0.089: 180.3,129.29 180.3,129.31 179.63,129.98 178.52,129.98 176.42,132.07 176.42,135.09 175.48,136.02 175.48,136.89 v1(175.03,137.35)
  L3_GND w0.14: DIMM2.36 193.61,81.7 193.42,81.7 192.68,82.44 192.68,82.99 193.53,83.84 193.53,86.8 192.68,87.65 192.68,88.2 193.53,89.05 193.53,90.6 192.68,91.45 192.68,92.56 192.96,92.84 192.96,93.65 192.48,94.13 192.48,94.98 192.32,95.14 192.08,95.14 191.89,94.95 191.66,94.95 191.5,95.11 191.5,95.35 191.69,95.54 191.69,95.77 191.53,95.93 191.29,95.93 191.1,95.74 190.87,95.74 190.71,95.9 190.71,96.14 190.9,96.33 190.9,96.56 190.73,96.72 190.5,96.72 190.31,96.53 190.08,96.53 189.92,96.7 189.92,96.93 190.11,97.12 190.11,97.35 189.94,97.51 189.71,97.51 189.52,97.32 189.29,97.32 189.12,97.49 189.12,97.72 189.32,97.91 189.32,98.14 189.15,98.31 188.92,98.31 188.73,98.11 188.5,98.11 188.33,98.28 188.33,98.51 188.5,98.67 188.5,98.96 188.36,99.1 187.51,99.1 185.94,100.67 185.94,105.59 187.08,106.73 187.08,121.2 186.16,122.12 185.38,122.12 180.3,127.21 180.3,129.29
M_DB25: length 72.7
  TOP w0.089: v1(175.03,135.52) CPU.AM29
  L3_GND w0.089: v1(175.03,135.52) 175.21,135.52 175.91,134.82 175.91,131.86 178.35,129.43 178.35,129.29
  L3_GND w0.14: DIMM2.38 192.49,81.58 192.02,82.05 191.37,82.05 190.98,82.44 190.98,82.99 191.83,83.84 191.83,86.8 190.98,87.65 190.98,88.2 191.83,89.05 191.83,90.6 190.98,91.45 190.98,92 191.27,92.29 191.27,93.51 184.51,100.26 184.51,110.52 184.68,110.68 185.11,110.68 185.28,110.85 185.28,111.08 185.11,111.24 184.68,111.24 184.51,111.41 184.51,111.64 184.68,111.8 185.19,111.8 185.35,111.97 185.35,112.2 185.19,112.36 184.68,112.36 184.51,112.52 184.51,112.76 184.68,112.92 185.19,112.92 185.35,113.08 185.35,113.31 185.19,113.48 184.68,113.48 184.51,113.64 184.51,113.87 184.68,114.04 185.19,114.04 185.35,114.2 185.35,114.43 185.19,114.6 184.68,114.6 184.51,114.76 184.51,114.99 184.68,115.15 185.19,115.15 185.35,115.32 185.35,115.55 185.19,115.71 184.68,115.71 184.51,115.88 184.51,116.18 184.7,116.37 185.54,116.37 185.78,116.61 185.78,120.65 185.61,120.83 184.85,120.83 178.7,126.98 178.7,127.94 178.35,128.29 178.35,129.29
M_DB26: length 70.7
  TOP w0.089: CPU.AP29 174.57,134.12 v1(174.14,133.69)
  L3_GND w0.089: v1(174.14,133.69) 174.15,133.69 174.79,133.05 174.79,129.83 176.47,128.15 176.47,127.89
  L3_GND w0.14: DIMM2.43 188.24,82.27 188.07,82.09 187.79,82.09 187.58,82.31 187.58,83.74 188.24,84.4 188.24,84.84 187.89,85.19 187.89,85.75 188.24,86.11 188.24,86.98 187.58,87.65 187.58,88.2 188.24,88.87 188.24,90.78 187.58,91.45 187.58,93.02 187.94,93.39 187.94,93.66 187.75,93.85 187.48,93.85 187.12,93.48 186.85,93.48 186.66,93.67 186.66,93.94 187.02,94.31 187.02,94.54 186.86,94.71 186.66,94.71 186.13,94.19 185.93,94.19 185.74,94.38 185.74,94.58 186.06,94.9 186.06,95.1 185.8,95.36 185.61,95.36 184.54,94.29 184.28,94.29 184.08,94.48 184.08,94.75 184.7,95.37 184.7,95.64 184.51,95.83 184.24,95.83 183.64,95.23 183.37,95.23 183.18,95.42 183.18,95.69 183.78,96.29 183.78,96.56 183.59,96.75 183.32,96.75 182.74,96.17 182.47,96.17 182.28,96.36 182.28,96.63 182.86,97.21 182.86,97.48 182.28,98.07 182.28,98.27 182.66,98.65 182.66,98.92 182.28,99.3 182.28,118.75 181.17,119.85 181.17,121.33 176.47,126.03 176.47,127.89
M_DB27: length 69.8
  TOP w0.089: v1(174.08,132.74) CPU.AR29
  L3_GND w0.089: v1(174.08,132.74) 174.08,132.39 173.68,132 173.68,130.71
  L3_GND w0.14: DIMM2.45 186.54,83.3 186.11,83.73 186.11,85.63 186.36,85.88 186.36,87.16 185.88,87.65 185.88,88.2 186.36,88.68 186.36,90.96 185.88,91.45 185.88,92.34 185.11,93.1 183.56,93.1 182.78,93.89 182.51,93.89 181.95,93.33 181.73,93.33 181.49,93.57 181.49,93.79 182.05,94.35 182.05,94.62 181.86,94.81 181.59,94.81 180.91,94.12 180.64,94.12 180.45,94.31 180.45,94.58 181.13,95.27 181.13,95.54 180.58,96.09 180.58,107.6 179.87,108.31 179.87,109.01 180.03,109.17 180.34,109.17 180.5,109.33 180.5,109.56 180.34,109.73 180.03,109.73 179.87,109.89 179.87,110.12 180.03,110.29 180.34,110.29 180.5,110.45 180.5,110.68 180.34,110.85 180.03,110.85 179.87,111.01 179.87,111.24 180.03,111.4 180.34,111.4 180.5,111.57 180.5,111.8 180.34,111.96 180.03,111.96 179.87,112.13 179.87,112.36 180.03,112.52 180.34,112.52 180.5,112.69 180.5,112.92 180.34,113.08 180.03,113.08 179.87,113.24 179.87,113.48 180.03,113.64 180.34,113.64 180.5,113.8 180.5,114.03 180.34,114.2 180.03,114.2 179.87,114.36 179.87,114.59 180.03,114.76 180.34,114.76 180.5,114.92 180.5,115.15 180.34,115.32 180.03,115.32 179.87,115.48 179.87,115.71 180.03,115.87 180.34,115.87 180.5,116.04 180.5,116.27 180.34,116.43 180.03,116.43 179.87,116.6 179.87,116.83 180.03,116.99 180.34,116.99 180.5,117.16 180.5,117.39 180.34,117.55 180.03,117.55 179.87,117.71 179.87,117.95 180.03,118.11 180.34,118.11 180.5,118.27 180.5,118.5 180.34,118.67 180.03,118.67 179.87,118.83 179.87,120.8 174.08,126.59 174.08,128.79 173.68,129.19 173.68,130.71
M_DB28: length 72.8
  TOP w0.089: CPU.AM28 v1(174.11,136.43)
  L3_GND w0.089: 178.04,127.43 178.04,127.57 175.47,130.13 175.47,131.52 175.66,131.7 175.66,134.55 175.12,135.08 174.86,135.08 174.56,135.38 174.56,135.68 174.11,136.13 v1(174.11,136.43)
  L3_GND w0.14: DIMM2.183 191.64,81.26 190.61,82.29 190.61,83.15 191.46,84 191.46,86.65 190.61,87.5 190.61,88.35 191.46,89.2 191.46,90.45 190.61,91.3 190.61,93.25 183.83,100.03 183.83,116.91 184.02,117.1 184.93,117.1 185.12,117.29 185.12,117.56 184.93,117.75 184.02,117.75 183.83,117.94 183.83,118.21 184.02,118.4 184.95,118.4 185.12,118.57 185.12,118.88 184.96,119.04 184.42,119.04 184.28,119.18 184.28,119.46 184.45,119.62 184.91,119.62 185.07,119.78 185.07,120.01 184.91,120.18 184.45,120.18 183.72,120.9 183.01,120.9 182.74,121.18 182.74,122.02 178.04,126.72 178.04,127.43
M_DB29: length 74
  TOP w0.089: CPU.AL28 v1(174.11,137.35)
  L3_GND w0.089: 179.61,129.29 179.22,129.68 178.45,129.68 176.16,131.97 176.16,134.98 175.19,135.96 174.89,135.96 174.54,136.31 174.54,136.92 v1(174.11,137.35)
  L3_GND w0.14: 179.61,129.29 179.64,129.25 179.64,126.95 185.12,121.47 185.89,121.47 186.43,120.93 186.43,109.83 186.24,109.64 185.82,109.64 185.63,109.45 185.63,109.18 185.82,108.99 186.24,108.99 186.43,108.8 186.43,108.53 186.24,108.34 185.54,108.34 185.35,108.15 185.35,107.88 185.54,107.69 186.14,107.69 186.33,107.5 186.33,107.21 186.13,107.01 185.48,107.01 185.22,106.76 185.22,100.47 192.31,93.38 192.31,91.3 193.16,90.45 193.16,89.2 192.31,88.35 192.31,87.5 193.16,86.65 193.16,84 192.31,83.15 192.31,82.29 193.16,81.44 193.16,80.56 192.72,80.11 192.72,79.54 DIMM2.181
M_DB30: length 70
  TOP w0.089: v1(173.23,132.77) 173.58,133.13 173.65,133.21 CPU.AR28
  L3_GND w0.089: 172.8,130.71 172.8,132.34 v1(173.23,132.77)
  L3_GND w0.14: DIMM2.190 185.69,80.17 185.03,80.84 185.03,81.39 185.69,82.06 185.69,83.53 185.03,84.19 185.03,86.6 185.51,87.08 185.51,89.36 184.97,89.9 184.97,90.37 185.51,90.91 185.51,92.04 184.82,92.74 180.53,92.74 179.53,93.73 179.53,94.72 179.89,95.08 179.89,95.37 179.53,95.73 179.53,96.16 179.92,96.54 179.92,96.81 179.53,97.19 179.53,97.46 179.92,97.84 179.92,98.11 179.53,98.49 179.53,98.76 179.92,99.14 179.92,99.41 179.53,99.79 179.53,100.06 179.92,100.45 179.92,100.71 179.53,101.1 179.53,101.36 179.92,101.75 179.92,102.01 179.53,102.4 179.53,102.67 179.92,103.05 179.92,103.32 179.53,103.7 179.53,103.97 179.92,104.35 179.92,104.62 179.53,105 179.53,105.27 179.92,105.65 179.92,105.92 179.53,106.3 179.53,106.57 179.92,106.95 179.92,107.22 179.53,107.6 179.17,107.6 179.03,107.74 179.03,108.16 179.2,108.33 179.2,108.89 179.03,109.07 179.03,109.63 179.2,109.81 179.2,110.37 179.03,110.54 179.03,111.1 179.2,111.28 179.2,111.84 179.03,112.02 179.03,112.58 179.2,112.75 179.2,113.31 179.03,113.49 179.03,114.05 179.2,114.23 179.2,114.79 179.03,114.96 179.03,115.52 179.2,115.7 179.2,116.26 179.03,116.44 179.03,117 179.2,117.17 179.2,117.73 179.03,117.91 179.03,118.47 179.2,118.65 179.2,119.2 179.03,119.38 179.03,120.73 173.41,126.34 173.41,128.52 172.8,129.14 172.8,130.71
M_DB31: length 71.5
  TOP w0.089: v1(173.23,133.69) 173.65,134.12 CPU.AP28
  L3_GND w0.089: v1(173.23,133.69) 173.7,133.22 174.26,133.22 174.54,132.94 174.54,129.73 174.73,129.53 174.73,129.36
  L3_GND w0.14: 174.73,129.36 174.73,126.86 174.94,126.65 175.17,126.65 175.41,126.88 175.64,126.88 175.8,126.72 175.8,126.49 175.57,126.25 175.57,126.02 180.53,121.06 180.53,119.56 181.26,118.82 181.26,118.59 181.59,118.26 181.59,117.9 181.26,117.57 181.26,117.29 181.63,116.92 181.63,116.64 181.26,116.27 181.26,115.99 181.63,115.62 181.63,115.34 181.26,114.97 181.26,114.69 181.63,114.32 181.63,114.04 181.26,113.67 181.26,113.39 181.63,113.02 181.63,112.74 181.26,112.37 181.26,112.09 181.63,111.72 181.63,111.44 181.26,111.07 181.26,110.79 181.63,110.42 181.63,110.14 181.26,109.77 181.26,109.49 181.63,109.12 181.63,108.84 181.26,108.47 181.26,108.19 181.63,107.82 181.63,107.54 181.26,107.17 181.26,106.89 181.63,106.52 181.63,106.24 181.26,105.87 181.26,105.59 181.63,105.22 181.63,104.94 181.26,104.57 181.26,104.29 181.63,103.92 181.63,103.64 181.26,103.27 181.26,102.99 181.63,102.62 181.63,102.33 181.26,101.97 181.26,101.68 181.63,101.32 181.63,101.03 181.26,100.67 181.26,100.38 181.63,100.02 181.63,99.73 181.26,99.37 181.26,99.08 181.63,98.72 181.63,98.43 181.26,98.07 181.26,97.68 181.64,97.3 181.64,97.03 181.26,96.64 181.26,96.32 184.11,93.47 185.84,93.47 187.21,92.09 187.21,90.88 186.73,90.4 186.73,89.85 187.21,89.36 187.21,87.08 186.73,86.6 186.73,86.05 187.21,85.56 187.21,81.88 186.73,81.39 186.73,80.84 187.39,80.17 DIMM2.188
M_DB32: length 70.1
  TOP w0.089: CPU.AR12 v1(158.57,133.69)
  L3_GND w0.089: 154.59,127.58 154.59,127.71 156.71,129.83 156.71,130.46 157.85,131.6 157.85,132.67 158.57,133.39 v1(158.57,133.69)
  L3_GND w0.14: 154.59,127.58 154.59,126.49 154.06,125.96 154.06,110.74 153.71,110.4 153.44,110.4 153.24,110.6 152.97,110.6 152.78,110.41 152.78,110.14 152.98,109.94 152.98,109.67 152.79,109.48 152.52,109.48 152.32,109.68 152.05,109.68 151.86,109.49 151.86,109.22 152.06,109.02 152.06,108.75 151.87,108.56 151.6,108.56 151.42,108.75 151.15,108.75 150.96,108.56 150.96,108.29 151.14,108.1 151.14,107.83 150.95,107.64 150.68,107.64 150.52,107.8 150.25,107.8 150.06,107.61 150.06,107.34 150.22,107.18 150.22,106.91 150.03,106.72 149.76,106.72 149.6,106.88 149.33,106.88 149.14,106.69 149.14,106.42 149.3,106.26 149.3,105.99 148.68,105.37 148.68,105.1 148.88,104.9 148.88,104.63 148.69,104.44 148.42,104.44 148.22,104.64 147.95,104.64 147.76,104.45 147.76,104.18 147.96,103.98 147.96,103.71 147.77,103.52 147.5,103.52 147.3,103.72 147.03,103.72 146.84,103.53 146.84,103.26 147.04,103.06 147.04,102.79 146.85,102.6 146.58,102.6 146.38,102.8 146.11,102.8 145.92,102.61 145.92,102.34 146.12,102.14 146.12,101.87 145.93,101.68 145.66,101.68 145.46,101.88 145.19,101.88 144.39,101.08 143.4,101.08 141.32,99 141.32,93.81 139.73,92.23 139.73,91.33 140.61,90.45 140.61,89.31 139.98,88.67 139.98,87.97 139,86.99 137.82,86.99 137.43,86.6 137.43,85.17 137.24,84.99 DIMM2.97
M_DB33: length 69.8
  TOP w0.089: CPU.AP12 v1(158.57,134.6)
  L3_GND w0.089: 153.88,127.58 153.88,127.63 154.31,128.07 154.52,128.07 156.37,129.92 156.37,130.6 157.55,131.78 157.55,132.94 158.12,133.51 158.12,133.87 158.57,134.32 v1(158.57,134.6)
  L3_GND w0.14: DIMM2.242 136.39,80 137.05,80.66 137.05,80.83 137.06,80.84 137.06,81.39 137.05,81.4 137.05,81.97 136.58,82.44 136.58,84.94 137.06,85.43 137.06,86.75 138.28,87.97 138.28,88.77 139.01,89.5 139.01,90.41 138.16,91.25 138.16,92.26 138.68,92.77 139.36,92.77 140.67,94.08 140.67,99.27 145.79,104.38 146.17,104.38 146.44,104.65 146.44,105.03 146.76,105.35 147.03,105.35 147.23,105.15 147.5,105.15 147.69,105.34 147.69,105.61 147.49,105.81 147.49,106.08 153.41,112 153.41,126.23 153.88,126.7 153.88,127.58
M_DB34: length 74.1
  TOP w0.089: CPU.AM12 v1(158.57,136.43)
  L3_GND w0.089: v1(158.57,136.43) 158.25,136.43 157.78,135.96 157.49,135.96 157.23,135.69 157.23,135.18 156.4,134.35 156.4,133.28 156.25,133.13 156.25,132.28 155.34,131.37 155.34,130.61 154.37,129.65 151.55,129.65 150.92,129.02 150.92,128.71
  L3_GND w0.14: 150.92,128.71 150.92,122.68 150.22,121.99 150.22,121.17 150.41,120.98 150.79,120.98 150.99,120.79 150.99,120.52 150.79,120.33 150.41,120.33 150.22,120.14 150.22,119.87 150.41,119.68 150.87,119.68 151.06,119.49 151.06,119.22 150.87,119.03 150.41,119.03 150.22,118.84 150.22,112.01 138.45,100.24 138.45,96.49 134.51,92.55 134.51,91.45 133.66,90.6 133.66,89.3 134.51,88.45 134.51,87.6 133.66,86.75 133.66,85.9 132.81,85.05 132.81,82.44 132.14,81.77 DIMM2.247
M_DB35: length 75.1
  TOP w0.089: CPU.AL12 v1(158.57,137.35)
  L3_GND w0.089: 148.88,128.71 148.88,129.05 149.79,129.96 150.18,129.96 150.72,130.5 153.78,130.5 154.09,130.81 154.09,131.1 155.43,132.44 155.43,133.09 155.88,133.54 155.88,135.81 157.24,137.17 157.24,137.52 157.48,137.76 158.15,137.76 v1(158.57,137.35)
  L3_GND w0.14: 148.88,128.71 148.88,112.5 137.15,100.78 137.15,97.03 132.81,92.68 132.81,91.45 131.96,90.6 131.96,89.3 131.96,88.68 131.48,88.2 131.48,87.65 131.96,87.16 131.96,85.88 131.63,85.55 131.63,84.99 131.96,84.66 131.96,84 131.11,83.15 131.11,82.36 130.44,81.69 130.44,80.44 131.01,79.87 131.01,79.49 DIMM2.249
M_DB36: length 71.4
  TOP w0.089: v1(159.48,132.77) CPU.AR13
  L3_GND w0.089: v1(159.48,132.77) 159.48,132.24 157.92,130.67 157.92,129.97 155.9,127.95 155.9,127.58
  L3_GND w0.14: DIMM2.95 142.53,86.3 142.53,87.16 143.01,87.65 143.01,88.2 142.53,88.68 142.53,90.4 143.38,91.25 143.38,91.87 142.63,92.62 142.63,98.47 142.99,98.83 144.24,98.83 144.43,99.02 144.43,99.28 144.62,99.47 144.89,99.47 145.08,99.28 145.08,99.02 145.27,98.83 145.98,98.83 146.77,99.62 146.77,99.89 146.55,100.12 146.55,100.39 146.74,100.58 147.01,100.58 147.23,100.35 147.5,100.35 147.69,100.54 147.69,100.81 147.47,101.04 147.47,101.31 147.66,101.5 147.93,101.5 148.15,101.27 148.42,101.27 148.61,101.46 148.61,101.73 148.39,101.96 148.39,102.23 148.58,102.42 148.85,102.42 149.07,102.19 149.34,102.19 149.53,102.38 149.53,102.65 149.31,102.88 149.31,103.15 149.5,103.34 149.77,103.34 149.99,103.11 150.26,103.11 150.45,103.3 150.45,103.57 150.23,103.8 150.23,104.07 150.42,104.26 150.69,104.26 150.91,104.03 151.18,104.03 151.37,104.22 151.37,104.49 151.15,104.72 151.15,104.99 151.34,105.18 151.61,105.18 151.83,104.95 152.1,104.95 152.29,105.14 152.29,105.41 152.07,105.64 152.07,105.91 152.26,106.1 152.53,106.1 152.75,105.87 153.02,105.87 153.21,106.06 153.21,106.33 152.99,106.56 152.99,106.83 153.18,107.02 153.45,107.02 153.67,106.79 153.94,106.79 154.13,106.98 154.13,107.25 153.91,107.48 153.91,107.75 154.1,107.94 154.37,107.94 154.59,107.71 154.86,107.71 155.35,108.2 155.35,125.42 155.9,125.97 155.9,127.58
M_DB37: length 72.7
  TOP w0.089: CPU.AP13 v1(159.48,133.69)
  L3_GND w0.089: 155.25,127.58 155.25,127.97 157.05,129.77 157.05,130.31 159.05,132.31 159.05,133.26 v1(159.48,133.69)
  L3_GND w0.14: DIMM2.240 138.09,79.01 138.76,79.68 138.76,81.96 138.28,82.44 138.28,85.06 138.77,85.55 138.77,86.24 139.52,86.99 140.65,86.99 141.56,87.9 141.56,88.21 142.16,88.81 142.16,90.62 141.55,91.23 141.55,92.36 141.97,92.78 141.97,98.73 143.67,100.43 145.65,100.43 149.98,104.76 149.98,105.03 149.77,105.24 149.77,105.51 149.96,105.7 150.23,105.7 150.44,105.49 150.71,105.49 150.9,105.68 150.9,105.95 150.69,106.16 150.69,106.43 150.88,106.62 151.15,106.62 151.36,106.41 151.63,106.41 151.82,106.6 151.82,106.87 151.66,107.03 151.66,107.3 151.85,107.49 152.12,107.49 152.28,107.33 152.55,107.33 152.74,107.52 152.74,107.79 152.6,107.93 152.6,108.2 152.79,108.39 153.06,108.39 153.2,108.25 153.47,108.25 153.66,108.44 153.66,108.71 153.51,108.86 153.51,109.13 153.7,109.32 153.97,109.32 154.12,109.17 154.39,109.17 154.71,109.49 154.71,125.69 155.25,126.24 155.25,127.58
M_DB38: length 74.4
  TOP w0.089: CPU.AM13 v1(159.48,136.43)
  L3_GND w0.089: v1(159.48,136.43) 159.02,135.97 158.42,135.97 158.08,135.63 158.08,135.34 157.83,135.09 157.57,135.09 156.65,134.17 156.65,132.2 155.59,131.14 155.59,130.14 154.75,129.3 153.92,129.3 153.35,128.72 152.86,128.72 152.24,128.11 152.24,127.58
  L3_GND w0.14: DIMM2.102 132.99,82.03 133.18,82.22 133.18,82.99 134.03,83.84 134.03,86.6 134.88,87.45 134.88,89 134.03,89.85 134.03,90.4 134.88,91.25 134.88,92 139.1,96.22 139.1,99.97 151.82,112.7 151.82,113.29 151.63,113.48 151.07,113.48 150.88,113.67 150.88,113.94 151.07,114.13 151.63,114.13 151.82,114.32 151.82,114.59 151.63,114.78 151.07,114.78 150.88,114.97 150.88,115.24 151.07,115.43 151.63,115.43 151.82,115.62 151.82,115.89 151.63,116.08 151.07,116.08 150.88,116.27 150.88,116.54 151.07,116.73 151.63,116.73 151.82,116.92 151.82,117.19 151.63,117.38 151.2,117.38 151.01,117.57 151.01,117.84 151.2,118.03 151.63,118.03 151.82,118.22 151.82,126.83 152.24,127.25 152.24,127.58
M_DB39: length 75.5
  TOP w0.089: CPU.AL13 v1(159.48,137.35)
  L3_GND w0.089: 149.56,128.71 149.56,128.83 150.78,130.05 154.33,130.05 155.03,130.76 155.03,131.58 155.85,132.41 155.85,133.13 156.14,133.42 156.14,135.52 157.53,136.92 159.05,136.92 v1(159.48,137.35)
  L3_GND w0.14: 149.56,128.71 149.56,128.16 149.75,127.97 150.01,127.97 150.2,127.78 150.2,127.51 150.01,127.32 149.75,127.32 149.56,127.13 149.56,126.86 149.75,126.67 150.06,126.67 150.25,126.48 150.25,126.21 150.06,126.02 149.75,126.02 149.56,125.83 149.56,125.3 149.75,125.11 150.06,125.11 150.25,124.92 150.25,124.65 150.06,124.46 149.75,124.46 149.56,124.27 149.56,124 149.75,123.81 150.06,123.81 150.25,123.62 150.25,123.35 150.06,123.16 149.75,123.16 149.56,122.97 149.56,112.27 137.8,100.51 137.8,96.76 133.18,92.13 133.18,91.38 133.18,91.3 132.33,90.45 132.33,89.71 132.81,89.23 132.81,87.08 132.33,86.6 132.33,83.84 131.48,82.99 131.48,82.09 131.29,81.91 DIMM2.104
M_DB40: length 77.7
  TOP w0.089: CPU.AR10 v1(154.54,133.69)
  L3_GND w0.089: 147.23,128.71 147.63,129.11 147.63,129.53 149.53,131.43 152.58,131.43 153.47,132.32 153.79,132.32 154.07,132.6 154.07,132.93 154.54,133.4 v1(154.54,133.69)
  L3_GND w0.14: 147.23,128.71 147.23,127.61 146.68,127.07 146.48,127.07 146.29,126.87 146.29,126.61 146.48,126.42 146.68,126.42 146.87,126.22 146.87,125.96 146.68,125.76 146.48,125.76 146.29,125.57 146.29,125.31 146.48,125.11 146.68,125.11 146.87,124.92 146.87,124.65 146.68,124.46 146.45,124.46 146.26,124.27 146.26,124 146.45,123.81 146.68,123.81 146.87,123.62 146.87,123.35 146.68,123.16 146.4,123.16 146.21,122.97 146.21,122.7 146.4,122.51 146.68,122.51 146.87,122.32 146.87,122.05 146.68,121.86 146.4,121.86 146.21,121.67 146.21,121.4 146.4,121.21 146.68,121.21 146.87,121.02 146.87,120.75 146.68,120.56 146.4,120.56 146.21,120.37 146.21,120.1 146.4,119.91 146.68,119.91 146.87,119.72 146.87,119.45 146.68,119.26 146.4,119.26 146.21,119.07 146.21,118.8 146.4,118.61 146.68,118.61 146.87,118.42 146.87,118.15 146.68,117.96 146.4,117.96 146.21,117.77 146.21,117.5 146.4,117.31 146.68,117.31 146.87,117.12 146.87,116.85 146.68,116.66 146.4,116.66 146.21,116.47 146.21,116.2 146.4,116.01 146.68,116.01 146.87,115.82 146.87,115.55 146.68,115.36 146.4,115.36 146.21,115.17 146.21,114.9 146.4,114.71 146.68,114.71 146.87,114.52 146.87,114.25 146.68,114.06 146.4,114.06 146.21,113.87 146.21,113.6 146.4,113.41 146.68,113.41 146.87,113.22 146.87,112.33 135.86,101.31 135.86,97.56 131.11,92.81 131.11,91.45 130.26,90.6 130.26,89.6 129.9,89.24 129.41,88.75 129.41,87.45 128.93,86.97 128.93,83.79 129.41,83.3 129.41,82.39 128.74,81.72 DIMM2.251
M_DB41: length 78.4
  TOP w0.089: v1(155.45,134.6) CPU.AP10
  L3_GND w0.089: 147.9,128.71 147.9,129.44 148.92,130.46 150.07,130.46 150.65,131.04 153.05,131.04 153.45,131.44 153.8,131.44 154.98,132.61 154.98,134.13 v1(155.45,134.6)
  L3_GND w0.14: 147.9,128.71 147.9,128.3 148.23,127.96 148.23,127.01 148.04,126.82 147.75,126.82 147.56,126.62 147.56,126.36 147.75,126.17 148.04,126.17 148.23,125.97 148.23,125.71 148.04,125.51 147.75,125.51 147.56,125.32 147.56,125.06 147.75,124.86 148.04,124.86 148.23,124.67 148.23,124.4 148.04,124.21 147.75,124.21 147.56,124.02 147.56,123.75 147.75,123.56 148.04,123.56 148.23,123.37 148.23,123.1 148.04,122.91 147.75,122.91 147.56,122.72 147.56,122.45 147.75,122.26 148.04,122.26 148.23,122.07 148.23,121.8 148.04,121.61 147.75,121.61 147.56,121.42 147.56,121.15 147.75,120.96 148.04,120.96 148.23,120.77 148.23,120.5 148.04,120.31 147.75,120.31 147.56,120.12 147.56,119.85 147.75,119.66 148.04,119.66 148.23,119.47 148.23,119.2 148.04,119.01 147.75,119.01 147.56,118.82 147.56,118.55 147.75,118.36 148.04,118.36 148.23,118.17 148.23,117.9 148.05,117.72 148.04,117.71 147.75,117.71 147.56,117.52 147.56,117.25 147.75,117.06 148.04,117.06 148.23,116.87 148.23,116.6 148.04,116.41 147.75,116.41 147.56,116.22 147.56,115.95 147.75,115.76 148.04,115.76 148.23,115.57 148.23,115.3 148.04,115.11 147.75,115.11 147.56,114.92 147.56,114.65 147.75,114.46 148.04,114.46 148.23,114.27 148.23,114 148.04,113.81 147.75,113.81 147.56,113.62 147.56,113.35 147.75,113.16 148.04,113.16 148.23,112.97 148.23,112.77 136.51,101.05 136.51,97.29 131.48,92.26 131.48,91.51 131.48,91.3 130.63,90.45 130.63,89.05 130.17,88.59 129.78,88.2 129.78,87.08 130.42,86.44 130.42,85.72 131.07,85.08 131.07,84.29 129.78,82.99 129.78,81.94 129.59,81.76 DIMM2.106
M_DB42: length 75.2
  TOP w0.089: CPU.AR7 v1(151.79,133.69)
  L3_GND w0.089: 145,131.23 145.74,131.98 146.4,131.98 147.68,133.26 151.37,133.26 v1(151.79,133.69)
  L3_GND w0.14: DIMM2.113 123.64,83.71 123.83,83.89 123.83,86.6 124.68,87.45 124.68,88.75 123.83,89.6 123.83,90.4 124.68,91.25 124.68,92.28 132.93,100.53 132.93,102.54 142.04,111.66 142.04,112.05 141.85,112.24 141.55,112.24 141.36,112.43 141.36,112.7 141.55,112.89 141.85,112.89 142.04,113.08 142.04,113.35 141.85,113.54 141.55,113.54 141.36,113.73 141.36,114 141.55,114.19 141.85,114.19 142.04,114.38 142.04,114.65 141.85,114.84 141.55,114.84 141.36,115.03 141.36,115.3 141.55,115.49 141.85,115.49 142.04,115.68 142.04,115.95 141.85,116.14 141.55,116.14 141.36,116.33 141.36,116.6 141.55,116.79 141.85,116.79 142.04,116.98 142.04,117.25 141.85,117.44 141.55,117.44 141.36,117.63 141.36,117.9 141.55,118.09 141.85,118.09 142.04,118.28 142.04,118.55 141.85,118.74 141.55,118.74 141.36,118.93 141.36,119.2 141.55,119.39 141.85,119.39 142.04,119.58 142.04,119.85 141.85,120.04 141.55,120.04 141.36,120.23 141.36,120.5 141.55,120.69 141.85,120.69 142.04,120.88 142.04,121.15 141.85,121.34 141.55,121.34 141.36,121.53 141.36,121.8 141.55,121.99 141.85,121.99 142.04,122.19 142.04,122.45 141.85,122.64 141.55,122.64 141.36,122.84 141.36,123.1 141.55,123.3 141.85,123.3 142.04,123.49 142.04,124.45 141.66,124.83 141.66,125.1 142.04,125.48 142.04,128.28 145,131.23
M_DB43: length 74.5
  TOP w0.089: v1(150.88,133.69) CPU.AR6
  L3_GND w0.089: v1(150.88,133.69) 150.57,133.69 150.15,134.1 147.95,134.1 146.76,132.92 145.96,132.92 145.32,132.28 145.13,132.28 145.07,132.22
  L3_GND w0.14: DIMM2.258 122.79,79.01 123.46,79.68 123.46,81.96 122.98,82.44 122.98,85.02 123.46,85.51 123.46,86.75 124.31,87.6 124.31,88.6 123.46,89.45 123.46,90.55 124.31,91.4 124.31,92.83 132.28,100.8 132.28,102.81 140.54,111.07 140.54,112.01 140.32,112.23 140.32,112.55 140.65,112.88 140.65,113.2 140.32,113.53 140.32,113.85 140.65,114.19 140.65,114.51 140.32,114.84 140.32,115.16 140.65,115.49 140.65,115.81 140.32,116.14 140.32,116.46 140.65,116.79 140.65,117.11 140.32,117.44 140.32,117.76 140.65,118.09 140.65,118.41 140.32,118.74 140.32,119.06 140.65,119.39 140.65,119.71 140.32,120.04 140.32,120.36 140.65,120.69 140.65,127.8 145.07,132.22
M_DB44: length 78
  TOP w0.089: v1(154.54,134.6) CPU.AP9
  L3_GND w0.089: v1(154.54,134.6) 154.06,134.13 154.06,133.51 153.75,133.2 153.45,133.2 152.53,132.29 148.8,132.29 148.43,131.92 148.43,130.95 148.25,130.77 148.03,130.77 147.73,130.48 147.73,130.25 147.53,130.05 146.9,130.05 146.19,129.35 146.19,129.32
  L3_GND w0.14: DIMM2.108 127.89,81.86 128.08,82.05 128.08,85.5 128.56,85.98 128.56,87.16 128.08,87.65 128.08,88.33 128.61,88.86 128.61,90.64 129.41,91.45 129.41,92.03 135.21,97.83 135.21,101.58 145.55,111.92 145.55,113.13 145.36,113.32 145.05,113.32 144.86,113.51 144.86,113.78 145.05,113.97 145.36,113.97 145.55,114.16 145.55,114.43 145.36,114.62 145.05,114.62 144.86,114.81 144.86,115.08 145.05,115.27 145.36,115.27 145.55,115.46 145.55,115.73 145.36,115.92 145.05,115.92 144.86,116.11 144.86,116.38 145.05,116.57 145.36,116.57 145.55,116.76 145.55,117.03 145.36,117.22 145.05,117.22 144.86,117.41 144.86,117.68 145.05,117.87 145.36,117.87 145.55,118.06 145.55,118.33 145.36,118.52 145.05,118.52 144.86,118.71 144.86,118.98 145.05,119.17 145.36,119.17 145.55,119.36 145.55,119.63 145.36,119.82 145.05,119.82 144.86,120.01 144.86,120.28 145.05,120.47 145.36,120.47 145.55,120.66 145.55,120.93 145.36,121.12 145.05,121.12 144.86,121.31 144.86,121.58 145.05,121.77 145.36,121.77 145.55,121.96 145.55,122.23 145.36,122.42 145.05,122.42 144.86,122.61 144.86,122.88 145.05,123.07 145.36,123.07 145.55,123.26 145.55,123.53 145.36,123.72 145.05,123.72 144.86,123.91 144.86,124.18 145.05,124.37 145.36,124.37 145.55,124.56 145.55,124.83 145.36,125.02 145.05,125.02 144.86,125.21 144.86,125.48 145.05,125.67 145.36,125.67 145.55,125.86 145.55,126.72 145.22,127.05 145.22,127.37 145.55,127.7 145.55,128.68 146.19,129.32
M_DB45: length 76.6
  TOP w0.089: CPU.AR9 v1(153.62,133.69)
  L3_GND w0.089: v1(153.62,133.69) 153.58,133.69 152.44,132.55 148.13,132.55 147.35,131.78 147.35,131.01 146.24,129.9 145.85,129.9 145.74,129.78
  L3_GND w0.14: 145.74,129.78 144.18,128.22 144.18,127.72 143.99,127.53 143.78,127.53 143.59,127.33 143.59,127.07 143.78,126.87 143.99,126.87 144.18,126.68 144.18,126.42 143.99,126.22 143.78,126.22 143.59,126.03 143.59,125.76 143.78,125.57 143.99,125.57 144.18,125.38 144.18,125.11 143.99,124.92 143.78,124.92 143.59,124.73 143.59,124.46 143.78,124.27 143.99,124.27 144.18,124.08 144.18,123.81 143.99,123.62 143.78,123.62 143.59,123.43 143.59,123.16 143.78,122.97 143.99,122.97 144.18,122.78 144.18,122.51 143.99,122.32 143.78,122.32 143.61,122.15 143.59,122.13 143.59,121.86 143.78,121.67 143.99,121.67 144.18,121.48 144.18,121.21 143.99,121.02 143.78,121.02 143.59,120.83 143.59,120.56 143.78,120.37 143.99,120.37 144.18,120.18 144.18,119.91 143.99,119.72 143.78,119.72 143.59,119.53 143.59,119.26 143.78,119.07 143.99,119.07 144.18,118.88 144.18,118.61 143.99,118.42 143.78,118.42 143.59,118.23 143.59,117.96 143.78,117.77 143.99,117.77 144.18,117.58 144.18,117.15 143.8,116.77 143.8,116.5 144.18,116.12 144.18,111.47 134.56,101.85 134.56,98.1 129.29,92.82 128.47,92.82 128.08,92.43 128.08,91.25 127.23,90.4 127.23,88.68 127.71,88.2 127.71,87.08 127.23,86.6 127.23,83.48 127.71,82.99 127.71,82.44 127.04,81.77 DIMM2.253
M_DB46: length 76.5
  TOP w0.089: v1(151.79,134.6) CPU.AP7
  L3_GND w0.089: 144.61,132.68 144.7,132.77 145.24,132.77 145.8,133.32 146.55,133.32 147.58,134.36 150.39,134.36 150.6,134.14 151.33,134.14 v1(151.79,134.6)
  L3_GND w0.14: 144.61,132.68 139.63,127.7 139.63,127.35 139.99,126.99 139.99,126.7 139.63,126.34 139.63,126.05 139.99,125.69 139.99,125.4 139.63,125.04 139.63,124.75 139.99,124.39 139.99,124.1 139.63,123.74 139.63,123.45 139.99,123.09 139.99,122.8 139.63,122.44 139.63,122.15 139.99,121.79 139.99,121.5 139.63,121.14 139.63,120.37 139.44,120.18 139.01,120.18 138.82,119.99 138.82,119.72 139.01,119.53 139.44,119.53 139.63,119.34 139.63,119.07 139.44,118.88 139.01,118.88 138.82,118.69 138.82,118.42 139.01,118.23 139.44,118.23 139.63,118.04 139.63,117.77 139.44,117.58 139.01,117.58 138.82,117.39 138.82,117.12 139.01,116.93 139.44,116.93 139.63,116.74 139.63,116.47 139.44,116.28 139.01,116.28 138.82,116.09 138.82,115.82 139.01,115.63 139.44,115.63 139.63,115.44 139.63,115.17 139.44,114.98 139.01,114.98 138.82,114.79 138.82,114.52 139.01,114.33 139.44,114.33 139.63,114.14 139.63,113.7 139.25,113.32 139.25,113.05 139.63,112.67 139.63,111.08 131.63,103.07 131.63,101.07 122.98,92.42 122.98,91.25 122.13,90.4 122.13,89.85 122.13,89.45 122.98,88.6 122.98,87.45 122.13,86.6 122.13,83.71 121.94,83.53 DIMM2.115
