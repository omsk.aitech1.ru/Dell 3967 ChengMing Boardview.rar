# Allegro board Phoenix-A00-Layout-20161019.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_ACT_N: length 55.1
  TOP w0.089: 169.48,124.32 169.48,124.33 169.58,124.43 169.58,127.94 169.42,128.1 169.42,131.08 169.74,131.4 CPU.AU24
  TOP w0.165: 172.45,92.71 172.45,92.25 172.09,91.9 172.09,91.29 172.47,90.91 172.47,90.5 DIMM1.62
  TOP w0.216: 172.45,92.71 172.45,96.41 174.76,98.72 174.76,106.18 174.9,106.32 175.15,106.32 175.29,106.46 175.29,106.66 175.15,106.8 174.54,106.8 174.4,106.93 174.4,107.13 174.54,107.27 175.15,107.27 175.29,107.41 175.29,107.6 175.15,107.74 174.54,107.74 174.4,107.88 174.4,108.07 174.54,108.21 175.15,108.21 175.29,108.35 175.29,108.55 175.15,108.69 174.54,108.69 174.4,108.82 174.4,109.02 174.54,109.16 175.15,109.16 175.29,109.3 175.29,109.49 175.15,109.63 174.54,109.63 174.4,109.77 174.4,109.96 174.54,110.1 175.15,110.1 175.29,110.24 175.29,110.44 175.15,110.57 174.54,110.57 174.4,110.71 174.4,110.91 174.54,111.05 175.15,111.05 175.29,111.19 175.29,111.82 174.79,112.32 174.59,112.32 174.2,111.93 174,111.93 173.87,112.07 173.87,112.26 174.26,112.66 174.26,112.85 172.16,114.95 171.29,114.95 169.48,116.76 169.48,124.32
M_A_ALERT_N: length 50.5
  TOP w0.102: CPU.AT23 169.08,131.96 168.74,131.61 168.74,130.77 168.62,130.66 168.62,130.17 168.51,130.05 168.51,129.4 168.23,129.12 168.23,127.36 168.95,126.64 168.95,125.11 168.18,124.34 168.18,116.02 172.74,111.46 172.74,105.17 172.96,104.95 172.96,98.51 171.32,96.88 171.32,93.36 170.21,92.25 170.21,90.93 169.73,90.45 169.73,89.85 170.39,89.19 DIMM1.208
M_A_BA0: length 52.6
  TOP w0.089: 159.42,124.47 159.42,124.59 160.99,126.16 160.99,127.61 CPU.AY13
  TOP w0.165: DIMM1.81 150.84,92.24 151.32,92.71
  TOP w0.216: 151.32,92.71 151.8,93.19 152.32,93.19 156.24,97.12 156.24,97.56 156.38,97.7 156.71,97.7 156.85,97.84 156.85,98.03 156.71,98.17 156.38,98.17 156.24,98.31 156.24,98.51 156.38,98.64 156.71,98.64 156.85,98.78 156.85,98.98 156.71,99.12 156.38,99.12 156.24,99.25 156.24,99.45 156.38,99.59 156.71,99.59 156.85,99.73 156.85,99.92 156.71,100.06 156.38,100.06 156.24,100.2 156.24,100.39 156.38,100.53 156.71,100.53 156.85,100.67 156.85,100.87 156.71,101.01 156.38,101.01 156.24,101.14 156.24,101.34 156.38,101.48 156.71,101.48 156.85,101.62 156.85,101.81 156.71,101.95 156.38,101.95 156.24,102.09 156.24,102.28 156.38,102.42 156.71,102.42 156.85,102.56 156.85,102.76 156.71,102.9 156.38,102.9 156.24,103.03 156.24,103.23 156.38,103.37 156.71,103.37 156.85,103.51 156.85,103.7 156.71,103.84 156.38,103.84 156.24,103.98 156.24,104.24 156.38,104.38 156.94,104.38 157.08,104.52 157.08,104.72 156.94,104.86 156.38,104.86 156.24,105 156.24,105.19 156.38,105.33 156.94,105.33 157.08,105.47 157.08,105.67 156.94,105.81 156.38,105.81 156.24,105.95 156.24,112.65 158.01,114.42 158.01,114.62 157.78,114.85 157.78,115.05 157.92,115.19 158.11,115.19 158.35,114.95 158.54,114.95 158.68,115.09 158.68,115.29 158.45,115.52 158.45,115.72 158.59,115.86 158.78,115.86 159.01,115.62 159.21,115.62 159.42,115.83 159.42,124.47
M_A_BA1: length 54.8
  TOP w0.089: CPU.AV15 161.36,130.08 161.36,129.55 161.19,129.38 161.19,128.27 161.86,127.6 161.86,126.22 160.21,124.57 160.21,124.47
  TOP w0.165: DIMM1.224 151.69,84.99 151.88,84.81 152.23,84.81 152.39,84.97 152.39,86.8 151.69,87.5 151.69,89.16 152.37,89.84 152.37,90.93 151.86,91.44 151.86,92.01 152.26,92.41 152.61,92.41 152.92,92.71
  TOP w0.216: 152.92,92.71 157.92,97.71 157.92,106.47 157.67,106.72 157.67,106.94 157.92,107.2 157.92,107.41 157.67,107.67 157.67,107.89 157.77,107.99 157.92,108.14 157.92,108.36 157.67,108.61 157.67,108.83 157.92,109.09 157.92,109.3 157.67,109.56 157.67,109.78 157.92,110.03 157.92,110.25 157.67,110.5 157.67,110.72 157.92,110.97 157.92,111.19 157.67,111.45 157.67,111.67 157.92,111.92 157.92,112.14 157.67,112.39 157.67,112.61 157.92,112.86 157.92,113.24 160.21,115.53 160.21,124.47
M_A_BA2: length 52.9
  TOP w0.089: 169.02,124.32 169.37,124.67 169.37,127.2 169.26,127.32 168.9,127.32 168.71,127.51 168.71,128.94 169.08,129.3 CPU.AW23
  TOP w0.165: DIMM1.63 171.24,91.73 172.07,92.56 172.07,92.71
  TOP w0.216: 172.07,92.71 172.07,96.57 174.38,98.88 174.38,99.3 174.24,99.44 173.86,99.44 173.72,99.58 173.72,99.77 173.86,99.91 174.24,99.91 174.38,100.05 174.38,100.25 174.24,100.39 173.86,100.39 173.72,100.52 173.72,100.72 173.86,100.86 174.24,100.86 174.38,101 174.38,101.19 174.24,101.33 173.86,101.33 173.72,101.47 173.72,101.66 173.86,101.8 174.24,101.8 174.38,101.94 174.38,102.14 174.24,102.28 173.86,102.28 173.72,102.41 173.72,102.61 173.86,102.75 174.24,102.75 174.38,102.89 174.38,103.08 174.24,103.22 173.86,103.22 173.72,103.36 173.72,103.55 173.86,103.69 174.24,103.69 174.38,103.83 174.38,104.03 174.24,104.17 173.86,104.17 173.72,104.3 173.72,104.5 173.86,104.64 174.24,104.64 174.38,104.78 174.38,105.61 174,105.99 174,111.25 173.15,112.1 173.15,112.29 173.6,112.75 173.6,112.94 173.47,113.08 173.27,113.08 172.82,112.63 172.62,112.63 172.49,112.77 172.49,112.96 172.94,113.41 172.94,113.61 172.8,113.75 172.6,113.75 172.15,113.3 171.96,113.3 171.82,113.44 171.82,113.63 172.27,114.08 172.27,114.28 172.13,114.42 171.93,114.42 171.48,113.97 171.29,113.97 170.53,114.73 170.53,115.11 170.38,115.25 170,115.25 169.02,116.23 169.02,124.32
M_A_BG1: length 54.1
  TOP w0.089: 168.56,124.32 168.56,124.41 169.17,125.02 169.17,127 169.06,127.11 168.82,127.11 168.48,127.46 168.47,127.46 168.47,128.98 168.75,129.26 168.75,129.82 169.08,130.15 CPU.AV23
  TOP w0.165: DIMM1.207 171.23,87.91 171.23,87.25 171.46,87.02 171.86,87.02 172.14,87.3 172.14,88.46 171.24,89.36 171.24,90.28 170.56,90.96 170.56,92.01 171.1,92.54 171.1,92.56 171.26,92.71
  TOP w0.216: 171.26,92.71 171.69,93.14 171.69,96.73 173.34,98.38 173.34,104.93 173.62,105.21 173.62,105.38 173.48,105.52 173.25,105.52 173.11,105.66 173.11,105.85 173.25,105.99 173.48,105.99 173.62,106.13 173.62,106.33 173.48,106.47 173.25,106.47 173.11,106.6 173.11,106.8 173.25,106.94 173.48,106.94 173.62,107.08 173.62,107.27 173.48,107.41 173.25,107.41 173.11,107.55 173.11,107.74 173.25,107.88 173.48,107.88 173.62,108.02 173.62,108.22 173.48,108.36 173.25,108.36 173.11,108.49 173.11,108.69 173.25,108.83 173.48,108.83 173.62,108.97 173.62,109.16 173.48,109.3 173.25,109.3 173.11,109.44 173.11,109.63 173.25,109.77 173.48,109.77 173.62,109.91 173.62,110.11 173.48,110.25 173.25,110.25 173.11,110.38 173.11,110.58 173.25,110.72 173.48,110.72 173.62,110.86 173.62,111.1 168.56,116.15 168.56,124.32
M_A_CK_DN0: length 52.4
  TOP w0.102: CPU.AV18 164.51,130.11 164.16,129.76 164.16,129.36 164.4,129.13 164.58,129.13 165.03,128.68 165.03,126.84 162.85,124.66 162.85,124.56 162.77,124.48 162.77,124.47
  TOP w0.203: 162.77,124.47 162.77,113.89 161.66,112.78 161.66,112 162.26,111.4 162.26,111.07 161.66,110.46 161.66,109.86 162.26,109.26 162.26,108.93 161.66,108.33 161.66,107.72 162.26,107.12 162.26,106.79 161.66,106.19 161.66,105.58 162.26,104.98 162.26,104.65 161.66,104.05 161.66,101.56 162.07,101.15 163.06,101.15 163.28,100.94 163.28,100.63 163.06,100.41 161.66,100.41 161.25,100.01 161.25,99.42 161.66,99.02 163.06,99.02 163.28,98.8 163.28,98.49 163.06,98.28 162.07,98.28 161.66,97.87 161.66,97.04 161.44,96.83 160.74,96.83 160.33,96.42 160.33,95.84 160.74,95.43 161.44,95.43 161.66,95.21 161.66,94.9 161.44,94.69 161.07,94.69 160.66,94.28 160.66,93.7 161.07,93.29 161.44,93.29 161.66,93.07 161.66,91.8 161.5,91.64 161.13,91.64 DIMM1.75
M_A_CK_DN1: length 53.8
  TOP w0.102: 161.7,124.47 161.7,124.49 161.77,124.56 161.77,124.81 163.95,126.99 163.95,128.88 163.79,129.04 163.65,129.04 163.6,128.98 CPU.AY17
  TOP w0.165: 161.74,88.52 161.74,87.43 161.24,87.16 161.02,87.23 160.9,87.46 DIMM1.219
  TOP w0.203: 161.74,88.52 161.28,88.98 159.87,88.98 158.3,90.54 158.3,95.89 160.13,97.72 160.13,100.59 160.61,101.08 160.61,102 160.4,102.22 159.98,102.22 159.57,102.63 159.57,103.21 159.98,103.62 160.4,103.62 160.61,103.83 160.61,104.14 160.4,104.36 159.9,104.36 159.49,104.77 159.49,105.35 159.9,105.76 160.4,105.76 160.61,105.97 160.61,106.28 160.4,106.49 159.95,106.49 159.55,106.9 159.55,107.48 159.95,107.89 160.4,107.89 160.61,108.11 160.61,108.42 160.4,108.63 160.08,108.63 159.67,109.04 159.67,109.62 160.08,110.03 160.4,110.03 160.61,110.25 160.61,113.27 161.7,114.36 161.7,124.47
M_A_CK_DP0: length 52.5
  TOP w0.102: CPU.AW18 164.51,129.49 165.23,128.76 165.23,126.76 163.1,124.62 163.1,124.47
  TOP w0.203: 163.1,124.47 163.1,113.76 161.99,112.65 161.99,112.14 162.59,111.53 162.59,110.93 161.99,110.33 161.99,110 162.59,109.39 162.59,108.79 161.99,108.19 161.99,107.86 162.59,107.26 162.59,106.65 161.99,106.05 161.99,105.72 162.59,105.12 162.59,104.51 161.99,103.91 161.99,101.7 162.21,101.48 163.2,101.48 163.61,101.07 163.61,100.49 163.2,100.08 161.79,100.08 161.58,99.87 161.58,99.56 161.79,99.35 163.2,99.35 163.61,98.94 163.61,98.36 163.2,97.95 162.21,97.95 161.99,97.73 161.99,96.91 161.58,96.5 160.88,96.5 160.66,96.28 160.66,95.97 160.88,95.76 161.58,95.76 161.99,95.35 161.99,94.77 161.58,94.36 161.21,94.36 160.99,94.14 160.99,93.84 161.21,93.62 161.58,93.62 161.99,93.21 161.99,91.47 161.5,90.98 161.5,90.52 DIMM1.74
M_A_CK_DP1: length 53.8
  TOP w0.102: 162.03,124.47 162.03,124.49 161.97,124.56 161.97,124.73 164.15,126.91 164.15,128.94 164.15,128.94 164.15,128.97 163.88,129.24 163.7,129.24 163.6,129.34 CPU.AW17
  TOP w0.165: DIMM1.218 161.69,86.7 161.78,87 161.83,87.15 162.04,87.26 162.04,88.69 ; 161.98,88.75 162,88.72
  TOP w0.203: 161.98,88.75 161.42,89.31 160,89.31 158.63,90.68 158.63,95.76 160.46,97.59 160.46,100.46 160.94,100.94 160.94,102.14 160.53,102.55 160.12,102.55 159.9,102.76 159.9,103.07 160.12,103.29 160.53,103.29 160.94,103.7 160.94,104.28 160.53,104.69 160.04,104.69 159.82,104.9 159.82,105.21 160.04,105.42 160.53,105.42 160.94,105.83 160.94,106.41 160.53,106.82 160.09,106.82 159.88,107.04 159.88,107.35 160.09,107.56 160.53,107.56 160.94,107.97 160.94,108.55 160.53,108.96 160.22,108.96 160,109.18 160,109.49 160.22,109.7 160.53,109.7 160.94,110.11 160.94,113.13 162.03,114.22 162.03,124.47 ; 162,88.72 162.04,88.69
M_A_CKE0: length 52.5
  TOP w0.089: 170.31,124.32 170.31,124.36 170.06,124.61 170.06,128.6 CPU.AY24
  TOP w0.165: DIMM1.60 173.79,90.83 173.96,91 173.96,92.44 173.29,93.11 173.29,95.91 174.58,97.2 174.76,97.2 175.13,96.83 175.3,96.83 175.42,96.96 175.42,97.13 175.05,97.5 175.05,97.68 175.18,97.8 175.35,97.8 175.79,97.37 175.96,97.37 176.08,97.49 176.08,97.66 175.65,98.1 175.65,98.27 176.13,98.76 176.13,112.17 175.8,112.5 175.8,112.67 176.15,113.02 176.15,113.19 176.02,113.32 175.85,113.32 175.5,112.97 175.32,112.97 175.2,113.1 175.2,113.27 175.55,113.62 175.55,113.79 175.42,113.92 175.25,113.92 174.9,113.57 174.72,113.57 174.6,113.7 174.6,113.87 174.95,114.22 174.95,114.39 174.82,114.52 174.65,114.52 174.3,114.17 174.12,114.17 174,114.3 174,114.47 174.35,114.82 174.35,114.99 174.22,115.12 174.05,115.12 173.7,114.77 173.52,114.77 173.4,114.9 173.4,115.07 173.75,115.42 173.75,115.59 173.62,115.72 173.45,115.72 173.1,115.37 172.92,115.37 172.51,115.79 171.67,115.79 170.54,116.92 170.54,120.01 170.31,120.24 170.31,120.43 170.54,120.66 170.54,120.85 170.31,121.08 170.31,121.27 170.54,121.5 170.54,121.7 170.31,121.92 170.31,122.12 170.54,122.35 170.54,122.54 170.31,122.77 170.31,122.96 170.54,123.19 170.54,123.38 170.31,123.61 170.31,124.32
M_A_CKE1: length 53.7
  TOP w0.089: CPU.AW24 169.66,129.24 169.66,128.2 169.82,128.04 169.82,124.41 169.91,124.32
  TOP w0.165: DIMM1.203 173.06,89.51 173.06,90.73 173.62,91.3 173.62,92.13 172.88,92.87 172.88,96.15 175.72,99 175.72,99.42 175.6,99.55 175.31,99.55 175.19,99.67 175.19,99.84 175.31,99.97 175.6,99.97 175.72,100.09 175.72,100.27 175.6,100.39 175.31,100.39 175.19,100.51 175.19,100.69 175.31,100.81 175.6,100.81 175.72,100.93 175.72,101.11 175.6,101.23 175.31,101.23 175.19,101.36 175.19,101.53 175.31,101.65 175.6,101.65 175.72,101.78 175.72,101.95 175.6,102.08 175.31,102.08 175.19,102.2 175.19,102.37 175.31,102.5 175.6,102.5 175.72,102.62 175.72,102.8 175.6,102.92 175.31,102.92 175.19,103.04 175.19,103.22 175.31,103.34 175.6,103.34 175.72,103.46 175.72,103.64 175.6,103.76 175.31,103.76 175.19,103.89 175.19,104.06 175.31,104.18 175.6,104.18 175.72,104.31 175.72,104.48 175.6,104.61 175.31,104.61 175.19,104.73 175.19,104.9 175.31,105.03 175.6,105.03 175.72,105.15 175.72,105.33 175.6,105.45 175.31,105.45 175.19,105.57 175.19,105.75 175.31,105.87 175.6,105.87 175.72,105.99 175.72,112 172.34,115.38 171.47,115.38 169.91,116.94 169.91,118.07 170.11,118.28 170.11,118.49 169.91,118.7 169.91,118.92 170.11,119.12 170.11,119.34 169.91,119.54 169.91,124.32
M_A_CS_N0: length 53.6
  TOP w0.089: CPU.AW12 159.02,129.27 158.48,128.73 158.48,127.76 159.24,127 159.24,125.55 158.22,124.54 158.22,124.47
  TOP w0.165: DIMM1.84 148.29,90.75 148.12,90.92 148.12,92.31 148.55,92.74 148.55,95.68 148.93,96.06 150.1,96.06 151.87,97.84 152.05,97.84 152.27,97.62 152.44,97.62 152.57,97.75 152.57,97.92 152.35,98.14 152.35,98.32 152.47,98.44 152.65,98.44 153.33,97.77 153.5,97.77 153.63,97.89 153.63,98.07 152.95,98.74 152.95,98.92 153.07,99.04 153.25,99.04 153.95,98.34 154.13,98.34 154.25,98.46 154.25,98.64 153.55,99.34 153.55,99.52 153.67,99.64 153.85,99.64 154.55,98.94 154.73,98.94 154.85,99.06 154.85,99.24 154.15,99.94 154.15,100.12 154.27,100.24 154.45,100.24 154.69,100 154.87,100 154.99,100.12 154.99,100.3 154.75,100.54 154.75,100.72 155,100.97 155,114 158.22,117.23 158.22,124.47
M_A_CS_N1: length 54.8
  TOP w0.089: CPU.AU11 157.8,131.4 157.08,130.68 157.08,125.5 156.5,124.92 156.5,124.47
  TOP w0.165: DIMM1.89 144.04,92.17 145.85,93.98 145.85,95.99 147.59,97.72 147.59,97.9 147.38,98.1 147.38,98.28 147.51,98.4 147.68,98.4 147.89,98.2 148.06,98.2 148.19,98.32 148.19,98.5 147.89,98.79 147.89,98.97 148.02,99.09 148.19,99.09 148.49,98.8 148.66,98.8 148.79,98.92 148.79,99.1 148.49,99.39 148.49,99.57 148.62,99.69 148.79,99.69 149.09,99.4 149.26,99.4 149.39,99.52 149.39,99.7 149.09,99.99 149.09,100.17 149.22,100.29 149.39,100.29 149.69,100 149.86,100 149.99,100.12 149.99,100.3 149.69,100.59 149.69,100.77 149.82,100.89 149.99,100.89 150.29,100.6 150.46,100.6 150.59,100.72 150.59,100.9 150.29,101.19 150.29,101.37 150.42,101.49 150.59,101.49 150.89,101.2 151.06,101.2 151.19,101.32 151.19,101.5 150.89,101.79 150.89,101.97 151.02,102.09 151.19,102.09 151.49,101.8 151.66,101.8 151.79,101.92 151.79,102.1 151.49,102.39 151.49,102.57 151.62,102.69 151.79,102.69 152.09,102.4 152.26,102.4 152.39,102.52 152.39,102.7 152.09,102.99 152.09,103.17 152.22,103.29 152.39,103.29 152.69,103 152.86,103 153.27,103.4 153.27,114.72 156.5,117.94 156.5,124.47
M_A_MA0: length 53.5
  TOP w0.089: 160.59,124.47 160.59,124.66 162.06,126.14 162.06,127.69 161.39,128.35 161.39,129.2 CPU.AW15
  TOP w0.165: DIMM1.79 153.08,91.19 153.4,91.19 153.68,91.47 153.68,91.72 153.35,92.05 153.35,92.53 153.53,92.71
  TOP w0.216: 160.59,124.47 160.59,115.37 158.3,113.09 158.3,97.48 156.63,95.81 156.63,95.61 157.17,95.06 157.17,94.87 157.04,94.73 156.84,94.73 156.29,95.28 156.1,95.28 155.96,95.14 155.96,94.94 157.11,93.79 157.11,93.6 156.97,93.46 156.77,93.46 155.62,94.61 155.43,94.61 155.29,94.47 155.29,94.27 156.29,93.27 156.29,93.08 156.15,92.94 155.96,92.94 154.95,93.94 154.76,93.94 154.62,93.8 154.62,93.6 155.04,93.19 155.04,92.99 154.9,92.85 154.71,92.85 154.29,93.27 154.09,93.27 153.53,92.71
M_A_MA1: length 54.7
  TOP w0.089: 164.22,124.32 164.22,125.16 165.82,126.75 165.82,128.77 165.09,129.5 165.09,130.83 CPU.AU18
  TOP w0.165: 163.99,92.71 163.99,92.58 163.76,92.36 163.76,90.86 163.59,90.69 DIMM1.72
  TOP w0.216: 163.99,92.71 163.99,93.53 165.46,95 165.46,97.87 164.75,98.58 164.75,102.82 164.61,102.96 164.13,102.96 163.99,103.1 163.99,103.29 164.13,103.43 164.61,103.43 164.75,103.57 164.75,103.77 164.61,103.91 164.13,103.91 163.99,104.04 163.99,104.24 164.13,104.38 164.61,104.38 164.75,104.52 164.75,104.71 164.61,104.85 164.13,104.85 163.99,104.99 163.99,105.18 164.13,105.32 164.61,105.32 164.75,105.46 164.75,105.66 164.61,105.8 164.13,105.8 163.99,105.93 163.99,106.13 164.13,106.27 164.61,106.27 164.75,106.41 164.75,106.6 164.61,106.74 164.13,106.74 163.99,106.88 163.99,107.07 164.13,107.21 164.61,107.21 164.75,107.35 164.75,107.55 164.61,107.68 164.13,107.68 163.99,107.82 163.99,108.02 164.13,108.16 164.61,108.16 164.75,108.3 164.75,108.49 164.61,108.63 164.13,108.63 163.99,108.77 163.99,108.96 164.13,109.1 164.61,109.1 164.75,109.24 164.75,109.44 164.61,109.57 164.13,109.57 163.99,109.71 163.99,109.91 164.13,110.05 164.61,110.05 164.75,110.19 164.75,110.38 164.61,110.52 164.13,110.52 163.99,110.66 163.99,110.85 164.13,110.99 164.61,110.99 164.75,111.13 164.75,111.33 164.61,111.46 164.36,111.46 164.22,111.6 164.22,124.32
M_A_MA2: length 54.7
  TOP w0.089: CPU.AU17 164.1,130.9 164.63,130.9 164.85,130.68 164.85,129.45 165.61,128.68 165.61,126.84 163.84,125.06 163.84,124.32
  TOP w0.165: DIMM1.216 163.59,88.13 162.91,88.81 162.91,90.89 163.42,91.4 163.42,92.71
  TOP w0.216: 163.42,92.71 163.42,92.91 163.56,93.04 163.56,94.83 163.7,94.97 164.87,94.97 165.01,95.11 165.01,95.31 164.87,95.44 163.7,95.44 163.56,95.58 163.56,95.78 163.7,95.92 164.87,95.92 165.01,96.05 165.01,96.25 164.87,96.39 163.7,96.39 163.56,96.53 163.56,96.72 163.7,96.86 164.87,96.86 165.01,97 165.01,97.69 164.37,98.32 164.37,101.96 163.56,102.77 163.56,111.07 163.84,111.35 163.84,124.32
M_A_MA3: length 55
  TOP w0.089: 164.6,124.32 164.6,125.25 166.06,126.71 166.06,128.81 165.42,129.45 CPU.AV19
  TOP w0.165: 164.44,92.71 DIMM1.71
  TOP w0.216: 164.44,92.71 164.44,93.44 165.84,94.84 165.84,98.52 165.71,98.66 165.27,98.66 165.13,98.8 165.13,98.99 165.27,99.13 165.71,99.13 165.84,99.27 165.84,99.46 165.71,99.6 165.27,99.6 165.13,99.74 165.13,99.94 165.27,100.07 165.71,100.07 165.84,100.21 165.84,100.41 165.71,100.55 165.27,100.55 165.13,100.69 165.13,100.88 165.27,101.02 165.71,101.02 165.84,101.16 165.84,101.35 165.71,101.49 165.27,101.49 165.13,101.63 165.13,101.83 165.27,101.96 165.71,101.96 165.84,102.1 165.84,102.3 165.71,102.44 165.27,102.44 165.13,102.58 165.13,102.77 165.27,102.91 165.71,102.91 165.84,103.05 165.84,103.24 165.71,103.38 165.27,103.38 165.13,103.52 165.13,103.72 165.27,103.85 165.71,103.85 165.84,103.99 165.84,104.19 165.71,104.33 165.27,104.33 165.13,104.47 165.13,104.66 165.27,104.8 165.71,104.8 165.84,104.94 165.84,105.13 165.71,105.27 165.27,105.27 165.13,105.41 165.13,105.61 165.27,105.74 165.71,105.74 165.84,105.88 165.84,106.08 165.71,106.22 165.27,106.22 165.13,106.36 165.13,106.55 165.27,106.69 165.71,106.69 165.84,106.83 165.84,107.02 165.71,107.16 165.27,107.16 165.13,107.3 165.13,107.5 165.27,107.63 165.71,107.63 165.84,107.77 165.84,107.97 165.71,108.11 165.27,108.11 165.13,108.24 165.13,108.44 165.27,108.58 165.71,108.58 165.84,108.72 165.84,108.91 165.71,109.05 165.27,109.05 165.13,109.19 165.13,109.39 165.27,109.52 165.71,109.52 165.84,109.66 165.84,109.86 165.71,110 165.27,110 165.13,110.13 165.13,110.33 165.27,110.47 165.71,110.47 165.84,110.61 165.84,110.91 164.6,112.15 164.6,124.32
M_A_MA4: length 56.3
  TOP w0.089: 165.01,124.32 165.01,125.37 166.3,126.66 166.3,128.9 165.76,129.44 165.76,130.77 165.53,131 165.3,131 165.05,131.25 165.05,131.94 CPU.AT19
  TOP w0.165: 165.12,92.71 165.12,91.44 164.61,90.93 164.61,89.84 165.29,89.16 165.29,87.77 165.87,87.2 165.87,86.9 DIMM1.214
  TOP w0.216: 165.12,92.71 165.12,93.34 165.41,93.63 165.6,93.63 165.82,93.41 166.01,93.41 166.15,93.55 166.15,93.75 165.94,93.96 165.94,94.16 166.5,94.73 166.5,95.07 166.64,95.21 166.9,95.21 167.04,95.35 167.04,95.54 166.9,95.68 166.64,95.68 166.5,95.82 166.5,96.01 166.64,96.15 166.9,96.15 167.04,96.29 167.04,96.49 166.9,96.62 166.64,96.62 166.5,96.76 166.5,96.96 166.64,97.1 166.9,97.1 167.04,97.24 167.04,97.43 166.9,97.57 166.64,97.57 166.5,97.71 166.5,97.9 166.64,98.04 166.9,98.04 167.04,98.18 167.04,98.38 166.9,98.51 166.64,98.51 166.5,98.65 166.5,99.07 166.25,99.33 166.25,99.54 166.5,99.8 166.5,100.02 166.25,100.27 166.25,100.49 166.5,100.74 166.5,100.96 166.25,101.22 166.25,101.43 166.5,101.69 166.5,101.91 166.25,102.16 166.25,102.38 166.5,102.63 166.5,102.85 166.25,103.11 166.25,103.32 166.5,103.58 166.5,103.8 166.25,104.05 166.25,104.27 166.5,104.52 166.5,104.74 166.25,105 166.25,105.21 166.5,105.47 166.5,105.69 166.25,105.94 166.25,106.16 166.5,106.41 166.5,106.63 166.25,106.88 166.25,107.1 166.5,107.36 166.5,107.58 166.25,107.83 166.25,108.05 166.5,108.3 166.5,108.52 166.25,108.77 166.25,108.99 166.5,109.25 166.5,109.59 166.64,109.73 166.87,109.73 167.01,109.87 167.01,110.06 166.87,110.2 166.64,110.2 166.5,110.34 166.5,110.79 165.01,112.29 165.01,124.32
M_A_MA5: length 56.9
  TOP w0.089: CPU.AU20 166.34,131.1 166.1,130.86 166,130.77 166,129.52 166.54,128.98 166.54,127.01 166.81,126.74 166.81,126.13 165.39,124.71 165.39,124.32
  TOP w0.165: 165.92,92.71 165.46,92.25 165.46,91.44 166.14,90.76 DIMM1.213
  TOP w0.216: 165.39,124.32 165.39,112.52 167.42,110.49 167.42,109.22 167.28,109.08 167.05,109.08 166.91,108.94 166.91,108.75 167.05,108.61 167.28,108.61 167.42,108.47 167.42,108.28 167.28,108.14 167.05,108.14 166.91,108 166.91,107.8 167.05,107.66 167.28,107.66 167.42,107.53 167.42,107.33 167.28,107.19 167.05,107.19 166.91,107.05 166.91,106.86 167.05,106.72 167.28,106.72 167.42,106.58 167.42,106.39 167.28,106.25 167.05,106.25 166.91,106.11 166.91,105.91 167.05,105.77 167.28,105.77 167.42,105.64 167.42,105.44 167.28,105.3 167.05,105.3 166.91,105.16 166.91,104.97 167.05,104.83 167.28,104.83 167.42,104.69 167.42,104.5 167.28,104.36 167.05,104.36 166.91,104.22 166.91,104.02 167.05,103.89 167.28,103.89 167.42,103.75 167.42,103.55 167.28,103.41 167.05,103.41 166.91,103.27 166.91,103.08 167.05,102.94 167.28,102.94 167.42,102.8 167.42,102.61 167.28,102.47 167.05,102.47 166.91,102.33 166.91,102.13 167.05,102 167.28,102 167.42,101.86 167.42,101.66 167.28,101.52 167.05,101.52 166.91,101.38 166.91,101.19 167.05,101.05 167.28,101.05 167.42,100.91 167.42,100.72 167.28,100.58 167.05,100.58 166.91,100.44 166.91,100.24 167.05,100.11 167.28,100.11 167.42,99.97 167.42,99.77 167.28,99.63 167.05,99.63 166.91,99.49 166.91,99.3 167.05,99.16 167.28,99.16 167.42,99.02 167.42,98.04 167.56,97.9 168.14,97.9 168.28,97.76 168.28,97.57 168.14,97.43 167.56,97.43 167.42,97.29 167.42,97.09 167.56,96.96 168.14,96.96 168.28,96.82 168.28,96.62 168.14,96.48 167.56,96.48 167.42,96.34 167.42,94.79 166.59,93.97 166.59,93.38 165.92,92.71
M_A_MA6: length 55.6
  TOP w0.089: CPU.AV20 166.34,129.48 166.78,129.04 166.78,127.05 167.09,126.75 167.09,126.01 165.77,124.69 165.77,124.32
  TOP w0.165: DIMM1.69 166.14,92.33 166.53,92.71
  TOP w0.216: 166.53,92.71 167.1,93.28 167.94,93.28 168.69,94.03 168.69,98.31 168.55,98.45 168.14,98.45 168,98.59 168,98.78 168.14,98.92 168.55,98.92 168.69,99.06 168.69,99.25 168.55,99.39 168.14,99.39 168,99.53 168,99.73 168.14,99.86 168.55,99.86 168.69,100 168.69,100.2 168.55,100.34 168.14,100.34 168,100.48 168,100.67 168.14,100.81 168.55,100.81 168.69,100.95 168.69,101.14 168.55,101.28 168.14,101.28 168,101.42 168,101.62 168.14,101.75 168.55,101.75 168.69,101.89 168.69,102.09 168.55,102.23 168.14,102.23 168,102.37 168,102.56 168.14,102.7 168.55,102.7 168.69,102.84 168.69,103.03 168.55,103.17 168.14,103.17 168,103.31 168,103.51 168.14,103.64 168.55,103.64 168.69,103.78 168.69,103.98 168.55,104.12 168.14,104.12 168,104.26 168,104.45 168.14,104.59 168.55,104.59 168.69,104.73 168.69,104.92 168.55,105.06 168.14,105.06 168,105.2 168,105.4 168.14,105.53 168.55,105.53 168.69,105.67 168.69,105.87 168.55,106.01 168.14,106.01 168,106.14 168,106.34 168.14,106.48 168.55,106.48 168.69,106.62 168.69,106.81 168.55,106.95 168.14,106.95 168,107.09 168,107.29 168.14,107.42 168.55,107.42 168.69,107.56 168.69,107.76 168.55,107.9 168.14,107.9 168,108.03 168,108.23 168.14,108.37 168.55,108.37 168.69,108.51 168.69,108.7 168.55,108.84 168.14,108.84 168,108.98 168,109.18 168.14,109.31 168.55,109.31 168.69,109.45 168.69,109.78 168.27,110.2 168.27,110.39 168.43,110.55 168.43,110.75 168.29,110.89 168.1,110.89 167.94,110.73 167.74,110.73 165.77,112.7 165.77,124.32
M_A_MA7: length 56.6
  TOP w0.089: CPU.AU21 167.25,131.04 166.92,130.71 166.92,130.12 166.83,130.03 166.83,129.68 166.83,129.68 166.83,129.67 167.27,129.23 167.27,127.14 167.88,126.53 167.88,125.98 166.53,124.64 166.53,124.32
  TOP w0.165: 168.45,92.71 168.19,92.46 167.46,92.46 167.16,92.16 167.16,91.44 167.67,90.93 167.67,89.71 167.01,89.05 167.01,87.38 167.27,87.12 167.62,87.12 167.84,87.34 DIMM1.211
  TOP w0.216: 166.53,124.32 166.53,114.3 170.14,110.69 170.14,110.29 170,110.15 169.72,110.15 169.58,110.01 169.58,109.81 169.72,109.68 170,109.68 170.14,109.54 170.14,109.34 170,109.2 169.72,109.2 169.58,109.07 169.58,108.87 169.72,108.73 170,108.73 170.14,108.59 170.14,108.4 170,108.26 169.72,108.26 169.58,108.12 169.58,107.93 169.72,107.79 170,107.79 170.14,107.65 170.14,107.45 170,107.31 169.72,107.31 169.58,107.18 169.58,106.98 169.72,106.84 170,106.84 170.14,106.7 170.14,106.51 170,106.37 169.72,106.37 169.58,106.23 169.58,106.04 169.72,105.9 170,105.9 170.14,105.76 170.14,105.56 170,105.42 169.72,105.42 169.58,105.29 169.58,105.09 169.72,104.95 170,104.95 170.14,104.81 170.14,104.62 170,104.48 169.72,104.48 169.58,104.34 169.58,104.15 169.72,104.01 170,104.01 170.14,103.87 170.14,103.57 170,103.43 169.79,103.43 169.65,103.29 169.65,103.1 169.79,102.96 170,102.96 170.14,102.82 170.14,98.04 169.82,97.72 169.82,94.09 168.45,92.71
M_A_MA8: length 54.9
  TOP w0.089: 166.15,124.32 166.15,124.74 167.42,126.01 167.42,126.7 167.02,127.1 167.02,129.15 166.58,129.59 166.58,130.11 166.68,130.21 166.68,130.94 166.77,131.04 166.77,131.89 CPU.AT20
  TOP w0.165: 167.19,92.71 166.82,92.34 166.82,91.3 166.99,91.13 DIMM1.68
  TOP w0.216: 166.15,124.32 166.15,114.1 166.83,113.41 166.83,113.22 166.42,112.8 166.42,112.61 166.56,112.47 166.75,112.47 167.17,112.88 167.36,112.88 167.5,112.74 167.5,112.55 167.09,112.13 167.09,111.94 167.23,111.8 167.42,111.8 167.84,112.21 168.03,112.21 168.17,112.08 168.17,111.88 167.9,111.61 167.9,111.41 168.03,111.27 168.23,111.27 168.5,111.55 168.7,111.55 169.1,111.15 169.1,102.63 169.23,102.49 169.62,102.49 169.76,102.35 169.76,102.15 169.62,102.01 169.23,102.01 169.1,101.88 169.1,101.68 169.23,101.54 169.62,101.54 169.76,101.4 169.76,101.21 169.62,101.07 169.23,101.07 169.1,100.93 169.1,100.74 169.23,100.6 169.62,100.6 169.76,100.46 169.76,100.26 169.62,100.12 169.23,100.12 169.1,99.99 169.1,99.79 169.23,99.65 169.62,99.65 169.76,99.51 169.76,99.32 169.62,99.18 169.23,99.18 169.1,99.04 169.1,98.81 169.23,98.67 169.54,98.67 169.68,98.53 169.68,98.33 169.54,98.19 169.23,98.19 169.1,98.06 169.1,97.92 169.44,97.57 169.44,94.24 168.1,92.9 167.38,92.9 167.19,92.71
M_A_MA9: length 58.2
  TOP w0.089: 167.34,124.32 167.34,124.59 168.28,125.53 168.28,126.7 167.75,127.24 167.75,129.38 167.95,129.57 167.95,130.16 167.81,130.29 167.81,130.69 168.11,130.98 168.3,130.98 168.5,131.18 168.5,131.62 168.17,131.96 CPU.AT22
  TOP w0.165: DIMM1.66 168.69,89.5 168.87,89.33 169.24,89.33 169.4,89.5 169.4,90.91 168.86,91.44 168.86,92.05 169.52,92.71
  TOP w0.216: 167.34,124.32 167.34,115.81 170.55,112.6 170.55,112.41 170.14,112 170.14,111.8 170.28,111.67 170.48,111.67 170.88,112.07 171.08,112.07 171.46,111.69 171.46,111.38 171.32,111.24 171.14,111.24 171,111.1 171,110.91 171.14,110.77 171.32,110.77 171.46,110.63 171.46,110.44 171.32,110.3 171.14,110.3 171,110.16 171,109.96 171.14,109.82 171.32,109.82 171.46,109.69 171.46,109.49 171.32,109.35 171.14,109.35 171,109.21 171,109.02 171.14,108.88 171.32,108.88 171.46,108.74 171.46,108.55 171.32,108.41 171.14,108.41 171,108.27 171,108.07 171.14,107.94 171.32,107.94 171.46,107.8 171.46,107.6 171.32,107.46 171.14,107.46 171,107.32 171,107.13 171.14,106.99 171.32,106.99 171.46,106.85 171.46,106.66 171.32,106.52 171.14,106.52 171,106.38 171,106.18 171.14,106.05 171.32,106.05 171.46,105.91 171.46,105.71 171.32,105.57 171.14,105.57 171,105.43 171,105.24 171.14,105.1 171.32,105.1 171.46,104.96 171.46,104.77 171.32,104.63 171.14,104.63 171,104.49 171,104.29 171.14,104.16 171.32,104.16 171.46,104.02 171.46,103.82 171.32,103.68 171.14,103.68 171,103.54 171,103.35 171.14,103.21 171.32,103.21 171.46,103.07 171.46,102.88 171.32,102.74 171.14,102.74 171,102.6 171,102.4 171.14,102.27 171.32,102.27 171.46,102.13 171.46,101.93 171.32,101.79 171.14,101.79 171,101.65 171,101.46 171.14,101.32 171.32,101.32 171.46,101.18 171.46,100.99 171.32,100.85 171.14,100.85 171,100.71 171,100.51 171.14,100.38 171.32,100.38 171.46,100.24 171.46,100.04 171.32,99.9 171.14,99.9 171,99.77 171,99.57 171.14,99.43 171.32,99.43 171.46,99.29 171.46,99.1 171.32,98.96 171.14,98.96 171,98.82 171,98.62 171.14,98.49 171.32,98.49 171.46,98.35 171.46,98.06 170.58,97.19 170.58,93.77 169.52,92.71
M_A_MA10: length 52.6
  TOP w0.089: 159.82,124.47 161.65,126.31 161.65,127.52 160.85,128.32 CPU.AY14
  TOP w0.165: DIMM1.225 150.84,90.3 151.52,90.98 151.52,92.3 151.93,92.71
  TOP w0.216: 159.82,124.47 159.82,115.69 157.23,113.11 157.23,112.69 157.1,112.55 156.81,112.55 156.67,112.41 156.67,112.22 156.81,112.08 157.1,112.08 157.23,111.94 157.23,111.75 157.1,111.61 156.81,111.61 156.67,111.47 156.67,111.27 156.81,111.13 157.1,111.13 157.23,111 157.23,110.8 157.1,110.66 156.81,110.66 156.67,110.52 156.67,110.33 156.81,110.19 157.1,110.19 157.23,110.05 157.23,109.86 157.1,109.72 156.81,109.72 156.67,109.58 156.67,109.38 156.81,109.25 157.1,109.25 157.23,109.11 157.23,108.91 157.1,108.77 156.81,108.77 156.67,108.63 156.67,108.44 156.81,108.3 157.1,108.3 157.23,108.16 157.23,107.97 157.1,107.83 156.81,107.83 156.67,107.69 156.67,107.49 156.81,107.36 157.1,107.36 157.23,107.22 157.23,107.02 157.1,106.88 156.81,106.88 156.67,106.74 156.67,106.55 156.81,106.41 157.1,106.41 157.49,106.02 157.49,103.74 157.23,103.49 157.23,103.27 157.49,103.02 157.49,102.8 157.23,102.54 157.23,102.33 157.49,102.07 157.49,101.85 157.23,101.6 157.23,101.38 157.49,101.13 157.49,100.91 157.23,100.65 157.23,100.44 157.49,100.18 157.49,99.96 157.23,99.71 157.23,99.49 157.49,99.24 157.49,99.02 157.23,98.77 157.23,97.57 152.48,92.81 152.03,92.81 151.93,92.71
M_A_MA11: length 56.7
  TOP w0.089: 166.94,124.32 166.94,124.59 168.08,125.73 168.08,126.62 167.51,127.19 167.51,129.51 167.69,129.69 167.69,130.02 167.61,130.1 167.61,131.09 167.92,131.4 CPU.AU22
  TOP w0.165: 168.99,92.71 168.52,92.25 168.52,90.91 168.01,90.41 168.01,88.91 168.69,88.23 168.69,87.8 169.43,87.07 169.43,85.72 169.22,85.52 168.87,85.52 168.69,85.69 DIMM1.210
  TOP w0.216: 168.99,92.71 170.2,93.93 170.2,97.56 170.52,97.88 170.52,110.85 169.41,111.95 169.41,112.15 169.84,112.57 169.84,112.77 169.7,112.91 169.5,112.91 169.08,112.48 168.88,112.48 168.75,112.62 168.75,112.82 169.17,113.24 169.17,113.44 169.03,113.58 168.84,113.58 168.41,113.15 168.22,113.15 168.08,113.29 168.08,113.49 168.5,113.91 168.5,114.11 168.36,114.25 168.17,114.25 167.74,113.82 167.55,113.82 167.41,113.96 167.41,114.16 167.83,114.58 167.83,114.77 167.59,115.02 167.4,115.02 167.26,114.88 167.07,114.88 166.93,115.02 166.93,115.22 167.06,115.35 167.06,115.55 166.94,115.67 166.94,124.32
M_A_MA12: length 54.7
  TOP w0.089: 167.72,124.32 167.72,124.36 168.73,125.36 168.73,126.55 167.99,127.28 167.99,129.26 168.17,129.44 CPU.AV22
  TOP w0.165: DIMM1.65 169.54,92.19 170.06,92.71
  TOP w0.216: 170.06,92.71 170.96,93.61 170.96,97.03 171.84,97.9 171.84,98.17 171.98,98.3 172.23,98.3 172.37,98.44 172.37,98.64 172.23,98.78 171.98,98.78 171.84,98.91 171.84,99.21 171.98,99.35 172.44,99.35 172.58,99.49 172.58,99.69 172.44,99.82 171.98,99.82 171.84,99.96 171.84,100.16 171.98,100.3 172.44,100.3 172.58,100.44 172.58,100.63 172.44,100.77 171.98,100.77 171.84,100.91 171.84,101.1 171.98,101.24 172.44,101.24 172.58,101.38 172.58,101.58 172.44,101.71 171.98,101.71 171.84,101.85 171.84,102.05 171.98,102.19 172.44,102.19 172.58,102.33 172.58,102.52 172.44,102.66 171.98,102.66 171.84,102.8 171.84,102.99 171.98,103.13 172.44,103.13 172.58,103.27 172.58,103.47 172.44,103.6 171.98,103.6 171.84,103.74 171.84,103.94 171.98,104.08 172.44,104.08 172.58,104.21 172.58,104.41 172.44,104.55 171.98,104.55 171.84,104.69 171.84,105.04 171.98,105.18 172.21,105.18 172.35,105.32 172.35,105.51 172.21,105.65 171.98,105.65 171.84,105.79 171.84,105.99 171.98,106.13 172.21,106.13 172.35,106.26 172.35,106.46 172.21,106.6 171.98,106.6 171.84,106.74 171.84,106.93 171.98,107.07 172.21,107.07 172.35,107.21 172.35,107.4 172.21,107.54 171.98,107.54 171.84,107.68 171.84,107.88 171.98,108.01 172.21,108.01 172.35,108.15 172.35,108.35 172.21,108.49 171.98,108.49 171.84,108.63 171.84,108.82 171.98,108.96 172.21,108.96 172.35,109.1 172.35,109.29 172.21,109.43 171.98,109.43 171.84,109.57 171.84,109.77 171.98,109.9 172.21,109.9 172.35,110.04 172.35,110.24 172.21,110.38 171.98,110.38 171.84,110.52 171.84,110.71 171.98,110.85 172.21,110.85 172.35,110.99 172.35,111.18 172.21,111.32 171.98,111.32 171.84,111.46 171.84,111.85 167.72,115.97 167.72,124.32
M_A_MA13: length 51
  TOP w0.089: CPU.AV12 158.63,130.1 158.05,130.1 157.37,129.42 157.37,127.01 157.59,126.8 157.59,125.53 156.93,124.87 156.93,124.47
  TOP w0.165: 145.4,92.71 145.06,92.38 145.06,91.44 145.58,90.93 145.58,89.03 144.89,88.35 DIMM1.232
  TOP w0.216: 156.93,124.47 156.93,117.77 153.7,114.54 153.7,103.23 146.29,95.81 146.29,93.6 145.4,92.71
M_A_MA14: length 54.6
  TOP w0.089: 158.66,124.47 158.66,124.59 160.41,126.34 160.41,127.27 159.36,128.31 159.36,129.17 159.52,129.33 159.52,129.75 159.8,130.03 160.39,130.03 CPU.AV14
  TOP w0.165: DIMM1.228 148.83,86.86 148.83,87.17 148.4,87.6 148.4,88.14 149.02,88.76 149.02,90.89 148.46,91.44 148.46,92.09 148.83,92.46 149.49,92.46 149.74,92.71
  TOP w0.216: 149.74,92.71 150.22,93.19 150.22,95.45 150.59,95.82 150.78,95.82 151.26,95.34 151.46,95.34 151.6,95.48 151.6,95.68 151.12,96.15 151.12,96.35 151.95,97.18 154.08,97.18 155.43,98.53 155.43,113.82 158.66,117.05 158.66,124.47
M_A_MA15: length 50.1
  TOP w0.089: 157.79,124.47 157.79,124.64 159,125.84 159,126.9 158.11,127.79 CPU.AY11
  TOP w0.165: DIMM1.86 146.59,89.25 146.82,89.03 147.23,89.03 147.48,89.28 147.48,90.48 146.59,91.36 146.59,92.26 146.79,92.46 147.51,92.46 147.76,92.71
  TOP w0.216: 147.76,92.71 148.12,93.07 148.12,95.86 148.75,96.49 149.82,96.49 152.96,99.64 152.96,99.84 152.71,100.08 152.71,100.28 152.85,100.42 153.05,100.42 153.3,100.17 153.49,100.17 153.63,100.31 153.63,100.51 153.39,100.76 153.39,100.95 153.53,101.09 153.72,101.09 153.97,100.84 154.17,100.84 154.57,101.24 154.57,114.18 157.79,117.41 157.79,124.47
M_A_MA16: length 52.9
  TOP w0.089: 159.04,124.47 159.04,124.49 160.61,126.07 160.61,127.36 159.6,128.37 159.6,128.85 159.94,129.19 CPU.AW13
  TOP w0.165: 150.51,92.71 149.99,92.2 DIMM1.82
  TOP w0.216: 150.51,92.71 150.75,92.95 150.75,94.65 150.89,94.79 151.08,94.79 151.22,94.65 151.22,93.71 151.36,93.57 152.16,93.57 153.55,94.96 153.55,95.16 153.21,95.5 153.21,95.69 153.35,95.83 153.54,95.83 153.88,95.49 154.08,95.49 154.22,95.63 154.22,95.82 153.88,96.17 153.88,96.36 154.01,96.5 154.21,96.5 154.55,96.16 154.75,96.16 154.89,96.3 154.89,96.49 154.54,96.84 154.54,97.03 154.68,97.17 154.88,97.17 155.22,96.83 155.42,96.83 155.81,97.22 155.81,113.66 156.02,113.87 156.21,113.87 156.46,113.62 156.66,113.62 156.79,113.76 156.79,113.95 156.55,114.2 156.55,114.4 156.68,114.54 156.88,114.54 157.13,114.29 157.32,114.29 157.46,114.43 157.46,114.62 157.21,114.87 157.21,115.07 159.04,116.89 159.04,124.47
M_A_ODT0: length 53.2
  TOP w0.089: CPU.AW11 158.11,129.34 157.67,128.9 157.67,127.58 158.12,127.13 158.12,125.45 157.36,124.69 157.36,124.47
  TOP w0.165: DIMM1.87 145.74,92.04 146.77,93.07 146.77,95.48 148.74,97.45 148.91,97.45 149.42,96.94 149.6,96.94 149.72,97.06 149.72,97.24 149.21,97.75 149.21,97.92 149.34,98.05 149.51,98.05 150.02,97.54 150.2,97.54 150.32,97.66 150.32,97.84 149.81,98.35 149.81,98.52 149.94,98.65 150.11,98.65 150.62,98.14 150.8,98.14 150.92,98.26 150.92,98.44 150.41,98.95 150.41,99.12 150.54,99.25 150.71,99.25 151.22,98.74 151.4,98.74 151.52,98.86 151.52,99.04 151.01,99.55 151.01,99.72 151.14,99.85 151.31,99.85 151.82,99.34 152,99.34 152.12,99.46 152.12,99.64 151.61,100.14 151.61,100.38 151.92,100.68 152.23,100.68 152.38,100.83 152.38,101.14 152.52,101.28 152.83,101.28 152.98,101.43 152.98,101.74 153.19,101.96 153.37,101.96 153.75,101.57 153.93,101.57 154.05,101.7 154.05,101.87 153.67,102.26 153.67,102.43 154.13,102.9 154.13,114.36 157.36,117.59 157.36,124.47
M_A_ODT1: length 55.3
  TOP w0.089: 156.09,124.47 156.09,125.2 156.83,125.94 156.83,130.94 157.68,131.79 160.21,131.79 CPU.AU14
  TOP w0.165: 156.09,124.47 156.09,118.11 152.86,114.89 152.86,104.57 152.59,104.29 152.26,104.29 152.12,104.16 152.12,103.83 151.99,103.69 151.66,103.69 151.52,103.56 151.52,103.23 151.39,103.09 151.06,103.09 150.92,102.96 150.92,102.63 150.79,102.49 150.46,102.49 150.32,102.36 150.32,102.03 150.01,101.72 149.71,101.72 149.56,101.57 149.56,101.27 149.41,101.12 149.11,101.12 148.96,100.97 148.96,100.67 148.81,100.52 148.51,100.52 148.36,100.37 148.36,100.07 148.21,99.92 147.91,99.92 147.76,99.77 147.76,99.47 147.61,99.32 147.31,99.32 147.16,99.17 147.16,98.87 147.01,98.72 146.71,98.72 146.56,98.57 146.56,98.27 146.26,97.96 146.26,97.79 146.56,97.48 146.56,97.31 146.44,97.18 146.26,97.18 145.96,97.49 145.78,97.49 145.66,97.36 145.66,97.19 145.96,96.88 145.96,96.71 145.84,96.58 145.66,96.58 145.36,96.89 145.18,96.89 144.89,96.6 144.89,95.83 145.01,95.7 145.25,95.7 145.37,95.58 145.37,95.4 145.25,95.28 145.01,95.28 144.89,95.16 144.89,94.28 143.29,92.68 143.29,91.58 143.05,91.34 142.73,91.34 DIMM1.91
M_A_PAR: length 51.7
  TOP w0.089: 160.97,124.47 160.97,124.54 162.26,125.83 162.26,128.16 CPU.AY15
  TOP w0.165: DIMM1.222 154.89,86.32 156.92,88.35 156.92,92.05 157.58,92.71
  TOP w0.216: 157.58,92.71 157.58,96.19 158.76,97.37 158.76,98.05 158.9,98.18 159.25,98.18 159.39,98.32 159.39,98.52 159.25,98.66 158.9,98.66 158.76,98.8 158.76,110.99 158.9,111.13 159.69,111.13 159.82,111.27 159.82,111.47 159.69,111.6 158.9,111.6 158.76,111.74 158.76,111.94 158.9,112.08 159.69,112.08 159.82,112.21 159.82,112.41 159.69,112.55 158.9,112.55 158.76,112.69 158.76,113 160.97,115.21 160.97,124.47
M_A_VREF: length 8.1
  TOP w0.254: CD2.1 223.44,84.95 223.55,84.84 CD5.1 225.03,85.6 226.16,85.6 RD9.1 ; CD2.1 223.09,85 DIMM1.146 ; CD2.1 CD3.1 221.22,84.09 RD8.2
M_AB_RESET_N: length 225.9
  TOP w0.089: v1(48.09,129.01) 47.99,129.1 U4.BC14
  TOP w0.102: RD2.1 149.35,74.32 147.91,74.32 147.56,74.68 146.59,74.68 146.06,74.15 U139.1 146.05,73.6 RD1.1 144.81,71.93 147.3,69.44 147.3,67.39 146.06,66.14 v1(146.06,63.45)
  BOTTOM w0.089: 43.23,128.19 47.33,128.19 48.09,128.96 v1(48.09,129.01)
  BOTTOM w0.102: v1(146.06,63.45) 145.22,62.62 131.11,62.62 126.76,58.27 115.06,58.27 112.55,60.78 110.76,60.78 110.3,60.32 97.06,60.32 96.63,60.75 92.86,60.75 89.78,63.82 87.98,63.82 80.96,70.84 77.73,70.84 76.74,71.83 69.52,71.83 69.03,71.34 63.38,71.34 62.29,72.43 62.29,73.23 61.99,73.53 60.49,73.53 59.85,74.17 55.88,74.17 53.02,71.31 49.02,71.31 46.49,73.85 46.49,74.26 44.72,76.03 44.72,79.6 42.37,81.95 42.37,89.13 v2(40.75,90.75) 40.11,91.39 40.11,91.39 39.86,91.64 39.86,102.54 37.9,104.5 28.51,104.5 23.86,109.16 23.86,111.48 26.73,114.35 27.24,114.35 28.56,115.67 28.56,125.41 28.25,125.72 28.25,130.03 29.16,130.94 29.76,130.94 30.17,130.53 32.2,130.53 33.34,129.39 34.76,129.39 36.69,127.46 37.55,127.46 38.12,128.02 41.89,128.02 42.06,128.19 43.23,128.19
M_AB_RESET_N_R: length 5.4
  TOP w0.102: U139.4 147.36,75.17 147.56,74.98 v1(147.94,74.98) 148.45,74.98 148.56,74.87 CD1.1 149,74.87 RD2.2 RD3.2 RD4.1
M_B_ACT_N: length 62.1
  TOP w0.089: v1(173.9,124.97) 173.9,125.42 173.99,125.52 173.99,129.76 173.71,130.05 173.54,130.05 173.28,130.31 173.28,131.03 CPU.AU28
  L3_GND w0.152: 175.62,93.11 175.1,92.58 174.12,92.58 173.74,92.2 173.74,91.26 173.12,90.64 173.12,89.05 172.27,88.2 172.27,87.64 173.12,86.79 173.12,85.96 172.09,84.93 DIMM2.62
  L3_GND w0.178: 175.62,93.11 175.83,93.31 175.83,96.14 176.92,97.23 176.92,97.51 176.61,97.82 176.61,98.08 176.92,98.38 176.92,98.64 176.61,98.94 176.61,99.2 176.92,99.5 176.92,99.76 176.61,100.06 176.61,100.32 176.92,100.63 176.92,100.88 176.61,101.19 176.61,101.44 176.92,101.75 176.92,102 176.61,102.31 176.61,102.57 176.92,102.87 176.92,103.13 176.61,103.43 176.61,103.69 176.92,103.99 176.92,104.25 176.61,104.56 176.61,104.81 176.92,105.12 176.92,105.37 176.61,105.68 176.61,105.93 176.92,106.24 176.92,106.5 176.61,106.8 176.61,107.06 176.92,107.36 176.92,107.62 176.61,107.92 176.61,108.18 176.92,108.48 176.92,108.74 176.61,109.05 176.61,109.3 176.92,109.61 176.92,109.86 176.61,110.17 176.61,110.42 176.92,110.73 176.92,110.99 176.61,111.29 176.61,111.55 176.92,111.85 176.92,112.11 176.61,112.41 176.61,112.67 176.92,112.98 176.92,113.23 176.61,113.54 176.61,113.79 176.92,114.1 176.92,116.86 176.75,117.03 176.17,117.03 176,117.19 176,117.43 176.17,117.59 176.75,117.59 176.92,117.75 176.92,118.49 176.48,118.93 176.25,118.93 175.82,118.5 175.59,118.5 175.43,118.66 175.43,118.9 175.85,119.32 175.85,119.56 174.11,121.3 174.11,122.7 173.9,122.91 v1(173.9,124.97)
M_B_ALERT_N: length 56.9
  TOP w0.102: v1(172.17,117.6) 171.61,118.16 171.61,124.59 170.91,125.29 CPU.AY25
  L3_GND w0.102: DIMM2.208 170.39,79.76 171.04,80.41 171.04,81.43 170.19,82.28 170.19,85.2 171.04,86.05 171.04,86.64 170.19,87.49 170.19,89.41 169.75,89.86 169.75,90.39 170.19,90.84 170.19,92.35 173.58,95.73 173.58,97.15 175.22,98.79 175.22,112.41 173.96,113.67 173.96,115.02 172.17,116.81 v1(172.17,117.6)
M_B_BA0: length 70.7
  TOP w0.089: CPU.AL18 v1(164.05,137.35)
  L3_GND w0.089: 162.61,126.11 162.61,126.19 162.93,126.51 162.93,127.01 163.37,127.45 163.37,128.47 163.89,128.99 163.89,131.1 163.41,131.58 163.41,133.02 163.61,133.22 163.61,133.87 163.97,134.22 163.97,135.75 164.51,136.29 164.51,136.89 v1(164.05,137.35)
  L3_GND w0.152: 151.16,93.11 151.16,92.53 151.52,92.18 151.52,91.33 150.72,90.53 150.72,89.72 151.57,88.87 151.57,87.15 151.02,86.6 151.02,86.02 151.26,85.78 151.26,83.64 150.84,83.22 DIMM2.81
  L3_GND w0.178: 151.16,93.11 151.16,94.31 152.15,95.3 152.58,95.3 152.81,95.07 153.14,95.07 153.37,95.3 154.06,95.3 161.88,103.12 161.88,105.71 161.72,105.87 161.16,105.87 160.99,106.03 160.99,106.27 161.16,106.43 161.72,106.43 161.88,106.6 161.88,106.83 161.72,106.99 161.16,106.99 160.99,107.16 160.99,107.39 161.16,107.55 161.72,107.55 161.88,107.72 161.88,107.95 161.72,108.12 161.16,108.12 160.99,108.28 160.99,108.51 161.16,108.68 161.72,108.68 161.88,108.84 161.88,109.07 161.72,109.24 161.16,109.24 160.99,109.4 160.99,109.64 161.16,109.8 161.72,109.8 161.88,109.96 161.88,110.2 161.72,110.36 161.16,110.36 160.99,110.53 160.99,122.17 162.61,123.78 162.61,126.11
M_B_BA1: length 68.2
  TOP w0.089: CPU.AM18 v1(164.97,136.43)
  L3_GND w0.089: 163.67,126.7 163.67,126.75 163.91,126.99 163.91,128.19 164.51,128.78 164.51,133.83 164.19,134.15 164.19,135.65 v1(164.97,136.43)
  L3_GND w0.152: DIMM2.224 151.11,77.9 151.11,78.21 151.69,78.79 151.69,80.17 152.37,80.84 152.37,81.4 151.87,81.89 151.87,83 152.72,83.85 152.72,86.6 153.24,87.12 153.24,88.9 152.42,89.72 152.42,90.53 153.5,91.61 153.5,93.09 153.52,93.11
  L3_GND w0.178: 153.52,93.11 162.83,102.43 162.83,114.97 162.57,115.24 162.06,115.24 161.88,115.42 161.88,121.29 163.67,123.07 163.67,126.7
M_B_BA2: length 60.8
  TOP w0.089: v1(172.7,122.45) 173.01,122.76 173.01,125.27 173.44,125.7 173.44,128.32 173.32,128.44 173.32,129.24 CPU.AW28
  L3_GND w0.152: 173.33,93.11 171.92,91.7 171.92,90.9 171.42,90.4 171.42,89.84 171.97,89.3 171.97,87.52 172.8,86.69 172.8,86.07 171.74,85.01 171.74,83.22 DIMM2.63
  L3_GND w0.178: 173.33,93.11 174.43,94.21 174.43,96.8 176.07,98.44 176.07,114.12 175.74,114.44 175.74,114.68 176.4,115.33 176.4,115.56 176.23,115.72 176,115.72 175.35,115.07 175.11,115.07 174.95,115.24 174.95,115.47 175.6,116.12 175.6,116.35 175.44,116.52 175.2,116.52 174.55,115.87 174.32,115.87 173.82,116.37 173.82,116.8 173.98,116.96 174.57,116.96 174.73,117.13 174.73,117.36 174.57,117.52 173.98,117.52 173.82,117.69 173.82,117.92 173.98,118.09 174.57,118.09 174.73,118.25 174.73,118.48 174.57,118.65 173.98,118.65 173.82,118.81 173.82,119.04 173.98,119.21 174.57,119.21 174.73,119.37 174.73,119.61 174.57,119.77 173.73,119.77 173.6,119.9 173.6,121.9 173.05,122.45 v1(172.7,122.45)
M_B_BG1: length 59.3
  TOP w0.089: CPU.AY28 173.65,125.56 173.27,125.18 173.27,121.95 v1(172.91,121.59)
  L3_GND w0.152: 171.53,93.11 170.57,92.15 170.57,91.44 171.07,90.95 171.07,88.7 170.57,88.2 170.57,87.64 171.42,86.79 171.42,85.89 170.57,85.04 170.57,82.44 171.42,81.59 171.42,80.57 171.79,80.2 171.79,79.46 DIMM2.207
  L3_GND w0.178: v1(172.91,121.59) 173.13,121.36 173.13,118.85 172.85,118.57 172.85,118.28 173.13,118.01 173.13,117.72 172.85,117.44 172.85,117.16 173.13,116.88 173.13,116.42 174.71,114.85 174.71,114.61 174.42,114.32 174.42,114.09 174.58,113.92 174.81,113.92 175.11,114.22 175.34,114.22 175.62,113.94 175.62,113.56 175.32,113.25 175.32,113 175.62,112.69 175.62,98.62 173.98,96.98 173.98,95.56 173.46,95.04 173.46,94.81 173.79,94.48 173.79,94.25 173.62,94.09 173.39,94.09 173.06,94.41 172.83,94.41 172.67,94.25 172.67,94.01 172.99,93.69 172.99,93.46 172.83,93.29 172.59,93.29 172.27,93.62 172.04,93.62 171.53,93.11
M_B_CK_DN0: length 69.9
  TOP w0.102: CPU.AM21 v1(167.71,136.43)
  L3_GND w0.102: v1(167.71,136.43) 167.45,136.43 167.19,136.17 167.19,135.21 168.32,134.08 168.32,128.78 167.09,127.55 167.09,127.26 167.15,127.2 167.15,127.18
  L3_GND w0.178: DIMM2.75 161.34,82.63 161.51,82.32 161.43,82.08 161.02,81.86 160.87,81.86 160.35,82.38 160.35,83.71 157.77,86.29 157.77,92.66 159.14,94.03 159.94,94.03 160.74,94.83 160.74,95.56 165.97,100.79 165.97,103.02 166.18,103.23 166.71,103.23 167.1,103.63 167.1,104.19 166.71,104.58 166.18,104.58 165.97,104.79 165.97,105.08 166.18,105.29 167.07,105.29 167.47,105.69 167.47,106.25 167.07,106.64 166.27,106.64 166.06,106.85 166.06,107.15 166.27,107.36 167.07,107.36 167.47,107.75 167.47,108.33 167.03,108.77 167.03,109.07 167.47,109.52 167.47,110.08 167.03,110.53 167.03,110.83 167.47,111.28 167.47,111.96 165.97,113.46 165.97,120.71 167.15,121.89 167.15,127.18
M_B_CK_DN1: length 67.6
  TOP w0.102: CPU.AP21 v1(166.77,133.69)
  L3_GND w0.102: v1(166.77,133.69) 166.96,133.69 167.06,133.59 167.06,132.91 166.97,132.82 166.97,130.71 166.5,130.24 166.5,128.48 165.77,127.74 165.77,127.26 165.71,127.2 165.71,127.18
  L3_GND w0.178: DIMM2.219 160.93,78.55 161.05,78.33 161.35,78.24 161.73,78.49 161.74,78.5 161.74,79.55 161.38,79.91 159.81,79.91 156.38,83.34 156.38,93.26 158.86,95.74 158.86,96.01 164.43,101.59 164.43,108.35 164.83,108.75 165.13,108.75 165.34,108.96 165.34,109.25 165.13,109.46 164.83,109.46 164.43,109.86 164.43,110.42 164.83,110.81 165.28,110.81 165.49,111.02 165.49,111.32 165.28,111.52 164.83,111.52 164.43,111.92 164.43,121.26 165.71,122.53 165.71,127.18
M_B_CK_DP0: length 70
  TOP w0.102: CPU.AM20 v1(166.8,136.43)
  L3_GND w0.102: v1(166.8,136.43) 166.99,136.24 166.99,135.13 168.12,134 168.12,128.87 166.89,127.63 166.89,127.26 166.83,127.2 166.83,127.18
  L3_GND w0.178: DIMM2.74 161.63,81.62 161.39,81.69 161.09,81.54 160.74,81.54 160.03,82.25 160.03,83.58 157.45,86.15 157.45,92.79 159.01,94.35 159.81,94.35 160.43,94.96 160.43,95.69 165.65,100.92 165.65,103.15 166.05,103.55 166.57,103.55 166.78,103.76 166.78,104.05 166.57,104.26 166.05,104.26 165.65,104.66 165.65,105.22 166.05,105.61 166.94,105.61 167.15,105.82 167.15,106.12 166.94,106.33 166.14,106.33 165.74,106.72 165.74,107.28 166.14,107.67 166.94,107.67 167.15,107.88 167.15,108.19 166.71,108.64 166.71,109.2 167.15,109.65 167.15,109.95 166.71,110.4 166.71,110.96 167.15,111.41 167.15,111.83 165.65,113.33 165.65,120.85 166.83,122.02 166.83,127.18
M_B_CK_DP1: length 67.6
  TOP w0.102: CPU.AP22 v1(167.68,133.69)
  L3_GND w0.102: v1(167.68,133.69) 167.27,133.27 167.27,132.82 167.18,132.73 167.18,130.63 166.71,130.16 166.71,128.39 165.97,127.65 165.97,127.26 166.03,127.2 166.03,127.18
  L3_GND w0.178: 166.03,127.18 166.03,122.4 164.75,121.13 164.75,112.05 164.96,111.84 165.41,111.84 165.81,111.45 165.81,110.89 165.41,110.49 164.96,110.49 164.75,110.28 164.75,109.99 164.96,109.78 165.26,109.78 165.65,109.38 165.65,108.83 165.26,108.43 164.96,108.43 164.75,108.22 164.75,101.46 159.18,95.88 159.18,95.61 156.7,93.13 156.7,83.47 159.94,80.23 161.51,80.23 162.06,79.68 162.06,78.37 161.93,78.24 161.65,78.06 161.59,77.78 161.59,77.63 DIMM2.218
M_B_CKE0: length 58.2
  TOP w0.089: CPU.AY29 174.3,128.4 174.3,124.11 v1(174.54,123.88)
  L3_GND w0.14: v1(174.54,123.88) 174.92,123.49 174.92,121.56 175.75,120.73 175.96,120.73 176.52,121.29 176.74,121.29 176.89,121.13 176.89,120.92 176.33,120.36 176.33,120.14 176.49,119.99 176.7,119.99 177.26,120.55 177.48,120.55 177.63,120.39 177.63,120.18 177.07,119.62 177.07,119.4 177.5,118.97 177.5,93.6 176.77,92.86 175.87,92.86 175.31,92.31 175.31,91.43 174.46,90.58 174.46,89.36 173.61,88.51 173.61,87.5 174.46,86.65 174.46,85.9 173.61,85.05 173.61,82.29 172.98,81.66 172.98,80.39 173.18,80.19 173.59,80.19 173.79,80.39 DIMM2.60
M_B_CKE1: length 60.7
  TOP w0.089: v1(175.42,121.82) 174.95,122.28 174.95,123.69 175.12,123.86 175.12,127.52 174.93,127.71 174.93,130.12 CPU.AV29
  L3_GND w0.14: v1(175.42,121.82) 176.97,121.82 178.14,120.65 178.14,119.85 178.29,119.7 178.29,119.33 178.14,119.17 178.14,118.8 178.29,118.65 178.29,118.28 178.14,118.13 178.14,117.76 178.29,117.61 178.29,117.23 178.14,117.08 178.14,116.71 178.29,116.56 178.29,116.19 178.14,116.04 178.14,115.66 178.29,115.51 178.29,115.14 178.14,114.99 178.14,114.62 178.29,114.47 178.29,114.09 178.14,113.94 178.14,113.57 178.29,113.42 178.29,113.05 178.14,112.9 178.14,112.53 178.29,112.37 178.29,112 178.14,111.85 178.14,111.48 178.29,111.33 178.29,110.96 178.14,110.8 178.14,110.43 178.29,110.28 178.29,109.91 178.14,109.76 178.14,109.3 178.29,109.15 178.29,108.78 178.14,108.62 178.14,108.25 178.29,108.1 178.29,107.73 178.14,107.58 178.14,107.21 178.29,107.05 178.29,106.68 178.14,106.53 178.14,106.16 178.29,106.01 178.29,105.64 178.14,105.48 178.14,105.11 178.29,104.96 178.29,104.59 178.14,104.44 178.14,104.07 178.29,103.91 178.29,103.54 178.14,103.39 178.14,103.02 178.29,102.87 178.29,102.5 178.14,102.34 178.14,101.97 178.29,101.82 178.29,101.45 178.14,101.3 178.14,100.93 178.29,100.78 178.29,100.4 178.14,100.25 178.14,99.88 178.29,99.73 178.29,99.36 178.14,99.21 178.14,98.83 178.29,98.68 178.29,98.31 178.14,98.16 178.14,97.79 178.29,97.64 178.29,97.26 178.14,97.11 178.14,96.74 178.29,96.59 178.29,96.22 178.14,96.07 178.14,95.7 178.29,95.54 178.29,95.17 178.14,95.02 178.14,94.65 178.29,94.5 178.29,94.13 178.14,93.97 178.14,93.22 177.4,92.48 176.13,92.48 175.68,92.03 175.68,91.27 174.83,90.42 174.83,89.05 173.98,88.2 173.98,87.65 174.83,86.8 174.83,85.75 173.98,84.9 173.98,82.44 174.64,81.77 DIMM2.203
