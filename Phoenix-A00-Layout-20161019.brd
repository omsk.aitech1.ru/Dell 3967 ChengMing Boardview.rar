# Allegro board Phoenix-A00-Layout-20161019.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCH_OC#_0: length 229.2
  TOP w0.089: 55.15,111.25 56.04,112.14 56.04,112.4 56.51,112.87 56.51,113.87 56.47,113.92 56.47,114.27 56.7,114.5 U4.AD43
  TOP w0.102: RU47.1 RU147.2 136.3,27.24 131.22,32.32 v1(131.22,34.29) ; v1(19.49,82.88) 19.49,82.73 22.97,79.25 22.97,78.81 23.89,77.89 30.13,77.89 30.76,77.27 35.13,77.27 39.28,81.41 42.09,81.41 42.51,81.83 45.4,81.83 47.15,83.59 v1(47.73,83.59) ; v1(54.64,110.52) 54.64,110.74 55.15,111.25 ; v1(52.99,90.88) 55.38,90.88 56.44,91.94 XDP_PCH.10
  BOTTOM w0.102: v1(19.49,82.88) 19.7,82.67 19.7,77.97 19.83,77.84 25.99,71.68 25.99,71.19 25.99,71 37.34,59.65 39.49,59.65 40.3,58.85 41.01,58.85 41.33,58.53 47.41,58.53 47.78,58.17 57.57,58.17 58.06,58.65 61.11,58.65 62.88,56.88 67.74,56.88 73.21,51.41 79.63,51.41 82.82,48.22 84.5,48.22 90.41,42.31 91.79,42.31 99.78,34.32 116.38,34.32 116.65,34.59 130.92,34.59 v1(131.22,34.29) ; v1(54.64,110.52) 55.22,109.94 55.22,106.92 v2(55.01,106.71) 54.92,106.62 54.92,102.13 54.72,101.92 54.72,101 54.52,100.79 54.52,100.16 53.24,98.89 53.24,97.85 53.32,97.77 53.32,97.41 52.71,96.8 52.61,96.8 52.51,96.7 52.51,92.94 52.99,92.46 v1(52.99,90.88) 52.99,90.83 53.25,90.58 53.25,89.97 54.26,88.96 54.26,88.14 53.12,87 49.48,87 48.46,85.98 48.46,84.32 v1(47.73,83.59)
PCH_OC#_1: length 264
  TOP w0.089: v1(56.17,111.63) 56.55,111.63 57.06,112.15 57.06,112.66 56.89,112.83 56.89,113.87 56.98,113.96 56.98,114.33 56.95,114.36 56.95,114.93 U4.AD42
  TOP w0.102: v1(65.64,98.17) 64.88,98.93 60.03,98.93 59.74,98.64 59.74,97.88 58.93,97.08 56.95,97.08 55.63,95.76 54.92,95.76 v1(54.59,95.43) ; v1(86.72,135.15) 86.72,134.9 88.17,133.45 88.17,128.61 89.59,127.19 89.59,126.38 89.72,126.25 89.72,114.51 85.89,110.68 85.89,108.96 88.29,106.55 89.41,106.55 93.99,101.98 93.99,95.58 88.98,90.58 87.15,90.58 85.58,89 83.62,89 v1(83.35,89.28) ; v1(137.5,210.46) 132.06,215.9 132.06,217.04 129.98,219.13 129.98,224.43 v1(130.21,224.66) 130.21,227.39 RU29.1 130.78,227.97 RU26.2 ; v1(101.79,151.98) 104.6,154.79 105.58,154.79 115.15,164.35 115.15,174.03 109.91,179.26 109.91,189.64 v1(114.08,193.8) ; XDP_PCH.12 55.94,92.03 55.23,91.31 v1(54.36,91.31)
  BOTTOM w0.089: v1(56.17,111.63) 56.17,111.25
  BOTTOM w0.102: v1(83.35,89.28) 82.78,89.28 76.08,95.98 76.08,96.63 74.41,98.3 65.77,98.3 v1(65.64,98.17) ; v1(137.5,210.46) 136.43,210.46 135.47,211.43 121.01,211.43 120.27,210.69 119.4,210.69 112.22,203.52 112.22,195.66 v1(114.08,193.8) ; 56.17,111.25 56.17,109.83 56.74,109.26 56.74,107.92 56.36,107.54 56.36,106.6 55.38,105.62 55.38,103.3 55.38,101.94 55.18,101.73 55.18,100.81 54.97,100.6 54.97,99.97 54.54,99.54 54.54,98.48 55.41,97.61 55.41,96.24 v1(54.59,95.43) 54.36,95.2 v1(54.36,91.31) ; v1(86.72,135.15) 87.57,136 87.92,136 88.41,136.5 90.13,136.5 90.74,137.11 91.82,137.11 92.43,137.72 93.25,137.72 95.51,139.98 96.29,139.98 100.66,144.34 100.66,146.72 101.79,147.86 v1(101.79,151.98)
PCH_OC#_2: length 35.4
  TOP w0.089: U4.AD39 57.07,116.71 v1(57.44,116.71)
  TOP w0.102: XDP_PCH.16 54.94,92.52 53.8,91.38 RH5.2 52.1,91.9 v1(51.9,92.1)
  BOTTOM w0.089: 53.75,111.25 54.01,111.51 54.01,113.24 v2(55.31,114.54) 55.53,114.76 56.27,114.76 57.16,115.65 57.51,115.65 57.69,115.82 57.69,116.46 v1(57.44,116.71)
  BOTTOM w0.102: v1(51.9,92.1) 51.6,92.41 51.6,96.95 52.23,97.59 52.23,99.06 52.64,99.47 52.64,102.34 52.73,102.43 52.73,105.72 52.05,106.4 52.05,106.95 52.73,107.63 52.73,109.55 52.51,109.77 52.51,110.79 52.71,111 53.5,111 53.75,111.25
PCH_OC#_3: length 364.6
  TOP w0.089: 56.55,111.25 57.31,112.01 57.31,112.68 57.08,112.91 57.08,113.79 57.21,113.93 U4.AC44
  TOP w0.102: v1(56.29,95.73) 56.07,95.5 55.35,95.5 54.82,94.97 54.62,94.97 54.44,94.79 XDP_PCH.18 ; v1(16.64,84.43) 17.17,83.91 18.21,83.91 18.54,83.58 18.54,82.55 22.28,78.8 22.28,78.5 25.12,75.66 29.9,75.66 30.81,76.58 35.42,76.58 39.56,80.72 42.37,80.72 42.79,81.15 45.68,81.15 46.69,82.16 47.61,82.16 v1(47.73,82.04) ; PU20.3 92.03,251.45 PR344.1 92.68,252.53 92.62,252.59 PR345.1 v1(91.98,253.17) ; R6608.2 55.66,102.3 55.66,105.16 v1(56.17,105.66) R6607.1 55.66,106.87 55.66,110.36 56.55,111.25 ; v1(14.96,159.45) 14.58,159.45 13.95,160.07 13.7,160.07 10.81,162.96 10.81,182.14 9.79,183.16 7.11,183.16 5.29,184.98 5.29,207.21 v1(4.48,208.03)
  BOTTOM w0.102: v1(56.17,105.66) 56.17,105.54 55.66,105.03 55.66,102.64 56.83,101.47 56.83,100.76 56.29,100.23 v1(56.29,95.73) 56.29,91.24 54.9,89.84 54.9,88.13 53.31,86.54 51.82,86.54 51.08,85.79 51.08,82.79 50.27,81.99 49.21,81.99 48.47,81.25 48.12,81.25 47.73,81.64 v1(47.73,82.04) ; v1(91.98,253.17) 91.66,253.49 89.76,253.49 86.31,256.95 76.95,256.95 73.02,253.01 66.8,253.01 63.12,249.33 52.27,249.33 51.33,250.27 45.68,250.27 44.23,251.71 39.78,251.71 34.32,246.25 32.27,246.25 30.77,247.75 23.39,247.75 22.38,246.74 20.02,246.74 18.91,245.62 18.91,243.94 18.19,243.23 18.19,241.23 17.44,240.48 15.25,240.48 13.53,238.76 6.57,238.76 4.07,236.26 4.07,208.43 v1(4.48,208.03) ; v1(16.64,84.43) 16.54,84.53 16.54,85.02 15.31,86.26 11.06,86.26 6.71,90.61 6.71,96.77 12.91,102.96 12.91,110.9 13.44,111.43 13.44,124.42 11.41,126.45 11.41,137.58 14.59,140.75 14.59,149.32 15.79,150.53 v2(15.79,151.35) 15.87,151.42 15.87,158.53 v1(14.96,159.45)
PCH_OC#_4: length 170.9
  TOP w0.089: U4.Y43 59.24,114.31 59.24,113.95 59.15,113.86 59.15,113 60,112.15 60,111.42 59.83,111.25
  TOP w0.102: 59.83,111.25 59.62,111.04 59.62,110.04 59.99,109.67 59.99,108.72 59.88,108.61 59.88,107.72 59.62,107.47 59.5,107.47 59.42,107.39 59.42,103.68 v1(59.6,103.5) ; v1(77.87,79.34) 78.09,79.12 78.09,72.97 76.73,71.62 76.73,63.99 80.73,59.99 80.73,56.33 v1(85.25,51.82) ; RU134.2 RU135.1 152.13,26.47 v1(142.78,35.81)
  BOTTOM w0.102: v1(77.87,79.34) 77.77,79.34 77.1,80.01 65.13,80.01 64.55,80.59 63.08,80.59 62.48,81.19 57.22,81.19 55.43,82.98 55.43,86.02 55.84,86.42 55.84,89.39 58.22,91.78 58.22,95.89 58.84,96.51 58.84,99.22 60.31,100.69 60.31,102.79 v1(59.6,103.5) ; v1(142.78,35.81) 142.49,35.52 139.22,35.52 136.84,37.9 117.21,37.9 115.95,39.16 v2(115.95,39.82) 115.55,40.23 108.96,40.23 106.11,43.08 103.06,43.08 101.81,44.34 99.31,44.34 98.01,45.64 91.78,45.64 85.61,51.82 v1(85.25,51.82)
PCH_OC#_5: length 44.6
  TOP w0.089: U4.Y41 58.74,115.29 58.74,115 58.66,114.92 58.66,113.3 58.77,113.19 58.77,112.59 59.22,112.14 v1(59.22,112.01)
  TOP w0.102: RU69.1 55.66,74.57 55.85,74.76 RU68.1 CU13.1 55.85,78.3 55.28,78.87 v1(55.28,81.41)
  BOTTOM w0.089: v1(59.22,112.01) 59.22,111.43 59.04,111.25
  BOTTOM w0.102: v1(55.28,81.41) 55.28,81.56 54.74,82.09 54.74,86.3 55.15,86.71 55.15,89.67 57.54,92.06 57.54,97.21 57.51,97.23 57.51,101.76 57.08,102.19 57.08,104.06 v2(57.67,104.64) 58.28,105.25 58.28,110.49 59.04,111.25
PCH_PCIE_RCOMP: length 3.8
  TOP w0.152: U4.B18 68.33,127.12 68.75,127.53 70.68,127.53 R6465.1
PCH_PECI_R: length 9.5
  TOP w0.089: 52.36,138.2 52.36,138.11 53.44,137.02 53.44,135.17 53.61,135 53.61,134.71 53.37,134.47 U4.AL3
  TOP w0.102: R6582.1 R6408.1 51.21,141.51 51.85,140.87 v1(51.85,139.45) 52.29,139 CO51.1 52.36,138.2
PCH_PRDY_N: length 197.8
  TOP w0.089: v1(50.58,133.48) 50.97,133.86 U4.AT4
  TOP w0.102: v1(48.17,154.43) 48.17,155.44 54.37,161.65 65.89,161.65 68.51,159.03 70.78,159.03 75.28,154.52 75.28,152.1 79.34,148.04 84.85,148.04 86.31,146.58 86.6,146.58 87.41,145.77 87.41,144.77 87.54,144.64 v1(87.54,143.81) ; R148.2 121.33,192.44 121.72,192.05 v1(121.88,192.05) ; v1(124.95,208.79) 123.35,208.79 122.69,209.45 115.79,209.45 114.49,208.14 114.49,200.98 107.5,193.99 107.5,177.77 112.63,172.64 112.63,165.23 104.5,157.1 103.65,157.1 98.25,151.7 97.02,151.7 96.19,150.88 95.98,150.88 94.96,149.86 v1(94.52,149.86)
  BOTTOM w0.089: 49.41,137.95 49.41,135.56 50.76,134.21 50.76,133.65 v1(50.58,133.48)
  BOTTOM w0.102: v1(121.88,192.05) 121.04,192.05 120.69,192.39 118.75,192.39 117.61,193.53 117.61,201.93 119.87,204.19 119.87,205.18 122.03,207.34 123.04,207.34 124.49,208.79 v1(124.95,208.79) ; v1(87.54,143.81) 87.76,144.04 90.69,144.04 93.3,146.66 93.3,147.5 94.52,148.72 v1(94.52,149.86) ; 49.41,137.95 49.41,139.13 48.64,139.9 47.26,139.9 46.82,140.34 46.82,142.47 45.48,143.81 45.48,146.28 48.17,148.97 v1(48.17,154.43)
PCH_PREQ_N: length 153.7
  TOP w0.089: 44.18,139.03 44.18,138.45 45.14,137.48 48.8,137.48 49.66,136.63 50.18,136.63 50.58,136.23 50.58,135.53 50.71,135.41 50.71,135.15 50.54,134.98 50.5,134.98 50.31,134.8 50.31,134.46 U4.AT3
  TOP w0.102: v1(98.08,149.35) 98.52,149.8 101.42,149.8 103.95,152.32 106.77,152.32 107.21,152.77 107.21,154.03 116.82,163.64 116.82,174.73 111.59,179.96 111.59,186.31 117.67,192.39 117.67,193.58 118.73,194.64 119.24,194.64 119.5,194.39 120.25,194.39 R149.2 ; v1(86.9,145.67) 86.52,145.67 84.38,147.81 79.25,147.81 75.05,152 75.05,154.43 70.69,158.8 68.41,158.8 66.78,160.43 54.87,160.43 46.44,151.99 46.44,148.84 44.46,146.86 44.46,145.45 44.18,145.17 44.18,139.03
  BOTTOM w0.102: v1(98.08,149.35) 98.08,149.45 v2(97.21,150.32) 96.76,150.77 94.1,150.77 92.59,149.27 92.59,148.82 89.77,146 87.46,146 87.13,145.67 v1(86.9,145.67)
PCH_RSMRST#: length 16
  TOP w0.089: v1(48.8,131.37) 48.8,130.94 U4.BA11
  TOP w0.102: R6418.1 v1(40.29,140.72)
  BOTTOM w0.089: v1(48.8,131.37) 46.93,131.37 44.2,134.11 44.07,134.11 43.44,134.74 43.44,135.86 43.23,136.07
  BOTTOM w0.102: 43.23,136.07 42.91,136.39 42.91,138 40.29,140.61 v1(40.29,140.72)
PCH_STRAP_BBS: length 22.4
  TOP w0.089: v3(51.22,120.98) 50.76,121.44 U4.AT29
  TOP w0.102: R74.2 v1(34.2,115.19) R75.1
  BOTTOM w0.089: 43.23,117.78 44.45,117.78 45.44,118.77 46.21,118.77 46.55,118.43 47.76,118.43 48.55,119.21 49.14,119.21 49.43,119.51 50.15,119.51 51.22,120.59 v3(51.22,120.98)
  BOTTOM w0.102: v1(34.2,115.19) 35.59,116.59 36.96,116.59 37.94,117.56 v2(39.92,117.56) 40.5,118.15 42.17,118.15 42.53,117.78 43.23,117.78
PCH_STRAP_ESPI_EN: length 15.6
  TOP w0.089: U4.BA40 49.05,115.88 v1(49.08,115.85)
  TOP w0.102: v1(47.4,110.62) 46.9,110.11 46.9,106.74 R72.1 R71.1
  BOTTOM w0.089: 47.68,111.25 48.37,111.94 48.37,112.42 47.96,112.83 47.96,113.36 47.66,113.66 47.28,113.66 46.77,114.17 46.77,115.44 v2(46.78,115.46) 47.53,116.2 48.72,116.2 v1(49.08,115.85)
  BOTTOM w0.102: v1(47.4,110.62) 47.68,110.9 47.68,111.25
PCH_STRAP_EXI_N: length 308.2
  TOP w0.089: v1(51.01,122.23) 51.01,122.33 U4.AT27
  TOP w0.102: v1(81.76,58.07) 81.76,59.29 76.96,64.09 76.96,71.08 v1(77.88,72.01) ; Q3.S v1(223.55,26.42) ; R77.1 v1(34.2,116.2) RA12.2
  BOTTOM w0.089: 43.23,118.01 44.41,118.01 45.36,118.96 46.31,118.96 46.65,118.62 47.68,118.62 48.47,119.4 49.06,119.4 49.36,119.7 50.07,119.7 50.74,120.38 50.74,121.93 51.01,122.2 v1(51.01,122.23)
  BOTTOM w0.102: v1(77.88,72.01) 77.53,72.36 68.62,72.36 68.23,72.75 65.97,72.75 65.53,72.3 63.17,72.3 62.82,72.65 62.82,73.45 62.21,74.07 60.71,74.07 60.07,74.7 53.39,74.7 52.81,74.12 51.7,74.12 50.99,73.41 50.99,72.3 50.53,71.84 49.25,71.84 47.02,74.07 47.02,74.49 45.26,76.25 45.26,79.82 42.91,82.17 42.91,89.45 43.57,90.11 43.57,101.88 41.05,104.39 v2(40.42,104.39) 39.65,105.17 28.6,105.17 24.44,109.33 24.44,111.31 24.97,111.84 27.1,111.84 28.4,113.13 31.12,113.13 v1(34.2,116.2) 34.81,116.81 36.86,116.81 38.36,118.31 39.7,118.31 39.76,118.37 42.26,118.37 42.63,118.01 43.23,118.01 ; v1(81.76,58.07) 84.76,55.08 86.66,55.08 93.05,48.69 96.25,48.69 97.59,50.04 109.67,50.04 115.31,44.4 118.56,44.4 120.24,42.72 135.69,42.72 136.41,42.01 138.47,42.01 139.5,40.98 145.25,40.98 146.28,42.01 150.1,42.01 151.06,41.05 153.17,41.05 154.21,40 173.85,40 177.09,43.24 182.17,43.24 185.63,39.78 187.41,39.78 195.92,31.27 195.92,26.19 200.82,21.29 210.99,21.29 212.82,23.11 218.68,23.11 221.99,26.42 v1(223.55,26.42)
PCH_STRAP_GPP_B18: length 16.9
  TOP w0.089: 43.19,120.62 44.42,120.62 45.59,121.8 U4.BD28
  TOP w0.102: 43.19,120.62 40.27,120.62 39.53,119.89 36.99,119.89 36.61,119.51 v1(36.61,117.4) 35.96,117.4 R80.1 35.28,116.71 34.01,116.71 R79.2
PCH_STRAP_GPP_H12: length 11.1
  TOP w0.089: 43.19,113.07 RA59.2 43.51,113.39 44.16,113.39 44.67,113.9 44.67,114.1 45.42,114.84 45.42,117.44 45.89,117.92 46.17,117.92 46.49,118.25 U4.BD35
  TOP w0.102: R81.2 40.85,113.02 v1(40.85,112.29) 41.02,112.29 41.24,112.52 42.64,112.52 43.19,113.07
PCH_STRAP_TLS: length 10.7
  TOP w0.089: U4.BB41 47.96,115.08 v1(48.13,115.08)
  TOP w0.102: R69.1 48.04,106.74 48.04,109.03 R70.1 48.23,110.49 v1(48.42,110.49)
  BOTTOM w0.089: v1(48.13,115.08) v2(48.13,114.01) 48.24,113.9 48.24,112.9 48.7,112.45 48.7,111.25
  BOTTOM w0.102: v1(48.42,110.49) 48.7,110.77 48.7,111.25
PCH_WAKE#: length 216.5
  TOP w0.089: 43.19,128.78 43.83,128.78 44.86,129.81 46.72,129.81 46.77,129.85 47.08,129.85 47.32,129.62 U4.BC13
  TOP w0.102: v1(29.37,149.35) 31.91,151.89 31.91,155.96 30.23,157.63 30.23,159.23 25.28,164.19 16.63,164.19 15.86,164.95 15.86,197.69 14.97,198.58 14.97,205.68 15.76,206.47 15.76,221.59 16.04,221.87 16.04,224.28 16.54,224.79 17.81,224.79 18.48,224.12 20.23,224.12 20.9,224.79 22.82,224.79 24.09,226.06 25.18,226.06 26.47,224.76 28.42,224.76 28.77,225.11 38.11,225.11 38.97,224.25 40.24,224.25 41.03,225.03 43.47,225.03 44.66,226.22 45.22,226.22 47.16,224.28 50.06,224.28 50.7,223.65 52.26,223.65 53.12,224.51 v1(53.22,224.51) 53.35,224.64 54.74,224.64 57.56,227.46 58.86,227.46 SLOT2.B11 ; v1(51.34,210.57) RK9.1 ; v1(17.18,130.56) 17.7,131.08 22.17,131.08 22.46,130.78 23.32,130.78 25.02,132.49 28.48,132.49 30.64,130.33 32.73,130.33 33.31,130.91 34.54,130.91 R6544.1 35.99,130.24 38.17,128.05 39.77,128.05 40.5,128.78 43.19,128.78
  BOTTOM w0.102: v1(29.37,149.35) 28.22,149.35 27.44,148.58 26.7,148.58 22.94,144.82 22.94,144.18 23.17,143.95 23.17,142.62 16.73,136.18 16.73,131 v1(17.18,130.56) ; v1(53.22,224.51) 52.92,224.21 52.92,220.39 51.21,218.69 51.21,218.18 50.81,217.77 50.81,211.1 v1(51.34,210.57)
PCI_CLKREQ#: length 15.6
  TOP w0.102: BRIDGE.D11 56.01,193.81 56.01,193.8 v1(56,193.79) ; v1(55.02,182.75) 55.02,182.44 RK27.2
  BOTTOM w0.102: v1(55.02,182.75) v2(56.09,183.82) 56.09,185.23 55.63,185.69 54.77,185.69 54.26,186.2 54.26,187.42 55.02,188.18 55.02,190.37 54.26,191.13 54.26,192.06 v1(56,193.79)
PCI_FBCLK: length 6.5
  TOP w0.102: RK6.2 57.94,187.26 57.94,188.85 57.54,189.26 v1(57.54,189.74) 57.54,190.7 56.78,191.46 56.78,192.22 BRIDGE.B11
PCI_REQ2#: length 6.2
  TOP w0.102: RK47.1 59.6,187.6 v1(59.45,187.75) 59.45,190.51 58.8,191.17 BRIDGE.A8
  BOTTOM w0.102: v2(58.68,187.21) 59.23,187.75 v1(59.45,187.75)
PCI_REQ3#: length 10.5
  TOP w0.102: BRIDGE.C8 59.18,193.02 59.18,191.4 v1(59.48,191.1) 59.73,190.85 59.73,188.16 60.1,187.79 60.1,184.98 RK48.1
  BOTTOM w0.102: v1(59.48,191.1) v2(59.48,191.92)
PCI_REQ4#: length 10.7
  TOP w0.102: RK46.1 59.09,184.98 59.09,187.32 58.68,187.74 v1(58.68,190.48) 58.38,190.78 58.38,193.02 BRIDGE.C9
  BOTTOM w0.102: v1(58.68,190.48) 59.39,189.76 v2(59.44,189.76)
PCI_REQ5#: length 6.2
  TOP w0.102: BRIDGE.A12 55.6,191.28 v1(56.17,190.71) 56.55,190.33 RK38.1
  BOTTOM w0.102: v1(56.17,190.71) 56.13,190.71 v2(55.56,191.29)
PCIAUX_GATE_R: length 5.9
  TOP w0.102: RO100.2 213.33,56.39 RO3.1 RO7.1 v1(213.63,53.89) 212.86,53.89 212.09,53.13 SIO_5553.92
PCIE_RCOMP_R: length 4.2
  TOP w0.152: U4.C17 67.31,127.22 67.48,127.39 68.22,127.39 68.64,127.8 71,127.8 R6465.2
PCIE_SLOT2_PRSNT_N: length 182.6
  TOP w0.089: U4.AR24 v1(51,124.22)
  TOP w0.102: v1(25.05,116.08) 25.18,116.08 26.45,114.81 v1(26.45,112.9) ; v1(73.06,173.35) 73.46,173.76 73.46,208.51 67.31,214.66 65.22,214.66 RX165.2 63.1,216.78 63.1,218.6 60.92,220.78 SLOT2.B17 ; v1(30.54,144.04) 30.97,143.61 30.97,142.77 30.54,142.34 30.54,141.39 26.96,137.81 v1(26.96,135.89) ; v1(67.74,168.39) 67.34,168.78 65.75,168.78 62.78,171.75 59.17,171.75 55.8,168.38 52.35,168.38 51.36,167.39 50.24,167.39 48.46,165.61 46.23,165.61 44.25,163.63 42.37,163.63 v1(39.02,160.27)
  BOTTOM w0.089: 43.23,119.71 44.27,119.71 45.4,120.84 45.61,120.84 47.17,122.39 49.72,122.39 51,123.67 v1(51,124.22)
  BOTTOM w0.102: v1(39.02,160.27) 39.02,159.76 32.19,152.92 32.19,147.54 31.02,146.37 31.02,145.34 30.54,144.86 v1(30.54,144.04) ; v1(26.96,135.89) 26.42,135.35 26.42,131.65 25.92,131.15 25.92,124.75 26.22,124.44 26.22,117.25 v1(25.05,116.08) ; 43.23,119.71 40.46,119.71 39.3,118.54 38.06,118.54 37.52,118.01 36.36,118.01 36.1,117.75 34.09,117.75 30.64,114.3 27.97,114.3 26.58,112.9 v1(26.45,112.9) ; v1(73.06,173.35) 71.03,173.35 68.61,170.94 68.61,169.27 v1(67.74,168.39)
PCIR: length 40.7
  TOP w0.102: BRIDGE.A1 64.4,191.72 63.91,191.24 63.91,190.32 64.27,189.96 67.06,189.96 67.85,190.75 CK53.1 RK42.1 69.31,191.26 70.52,191.26 70.85,191.59 70.85,195.28 71.46,195.89 71.46,205.05 69.38,207.14 67.34,207.14 65.69,205.49 CK54.1 65.69,204.65 v1(65.77,204.57) ; BRIDGE.K3 63.19,199.39 63.19,199.39 v1(63.19,199.39)
  BOTTOM w0.102: v1(65.77,204.57) 65.56,204.36 65.56,201.1 v2(65.36,200.91) 65.51,200.77 65.51,200.14 65.02,199.65 64.88,199.65 64.13,198.91 63.67,198.91 63.19,199.39 63.19,199.39 v1(63.19,199.39)
PCLK66_SEL: length 10.2
  TOP w0.102: BRIDGE.B12 55.6,192.33 55.98,191.95 55.98,191.62 57.02,190.57 57.02,188.01 v1(57.42,187.61) 57.02,187.21 57.02,185.01 RK22.2
  BOTTOM w0.102: v2(56.77,187.05) 56.86,187.05 v1(57.42,187.61)
PD_USB2_VBUSSENSE: length 9.8
  TOP w0.089: U4.AD10 56.48,131 v1(56.12,130.76)
  TOP w0.102: R6331.1 v1(57.06,138.18)
  BOTTOM w0.089: v2(57.4,136.81) 57.7,136.51 57.7,135.53 57.02,134.84 57.02,131.65 v1(56.12,130.76)
  BOTTOM w0.102: v1(57.06,138.18) 57.06,137.16 v2(57.4,136.81)
PDB: length 7.9
  TOP w0.102: RA36.2 RA8.2 191.55,29.73 RA22.1 191.1,29.29 RA21.1 190.6,27.89 190.03,27.89 189.3,27.17 v1(189.3,26.38) 189.3,26.06 188.87,25.63 UA1.47
PECI_REQUEST: length 295.7
  TOP w0.089: 43.19,126.73 44.28,126.73 44.96,127.41 46.48,127.41 46.62,127.54 46.73,127.54 46.86,127.67 47.65,127.67 47.91,127.41 U4.BB17
  TOP w0.102: v1(217.97,40.51) 217.97,40.41 217.81,40.26 217.81,38.13 218.09,37.84 SIO_5553.20 ; 43.19,126.73 41.35,126.73 40.1,125.48 38.86,125.48 37.64,124.26 35.32,124.26 34.93,123.87 34.93,123.49 34.5,123.06 34.5,122.8 R6403.2 33.5,121.8 32.88,121.8 32.19,121.11 21.06,121.11 20.47,120.51 20.47,117.44 24.03,113.89 24.03,103.21 25.79,101.45 25.79,90.02 27.52,88.29 27.97,88.29 28.3,87.96 v1(28.3,87.71)
  BOTTOM w0.102: v1(28.3,87.71) 28.3,87.29 26.62,85.61 26.62,82.57 27.72,81.47 27.72,80.47 29.9,78.29 29.9,77.49 31.61,75.79 31.61,73.61 38.8,66.42 45.01,66.42 45.83,65.6 54.7,65.6 55.02,65.28 70.23,65.28 71.9,63.61 78.88,63.61 85.12,57.38 87.04,57.38 91.04,53.37 110.86,53.37 115.28,48.96 119.84,48.96 120.74,49.86 134.36,49.86 134.89,50.4 153.55,50.4 156.87,47.08 163.6,47.08 164.81,48.29 169.3,48.29 173.39,52.37 176.78,52.37 177.54,51.62 188.25,51.62 200.35,39.52 204.36,39.52 204.94,38.94 209.99,38.94 210.5,39.45 216.9,39.45 v1(217.97,40.51) 218.47,41.02 v2(218.47,41.15)
PEGICOMP_MCP: length 7.5
  TOP w0.102: CPU.L7 v1(152.7,155.65) 154.24,155.65 154.47,155.42 154.47,154.91 156.88,152.5 157.22,152.5 R6289.2
PLTRST: length 24.1
  TOP w0.089: U4.BB27 47.8,122.56 46.77,122.56 46.61,122.72 45.79,122.72 v1(45.37,122.3)
  TOP w0.102: 29.37,117.78 BH1.2 ; 29.37,117.78 29.37,117.86 29.07,118.16 28.34,118.16 R6655.2 ; 29.37,117.78 29.75,118.16 30.25,118.16 C1629.1 31.85,119.19 v1(31.91,119.13)
  BOTTOM w0.089: 43.23,120.93 44.38,120.93 45.37,121.92 v1(45.37,122.3)
  BOTTOM w0.102: v1(31.91,119.13) 32.04,119.13 32.19,118.97 34.17,118.97 34.96,119.76 38.79,119.76 40.21,121.18 42.2,121.18 42.45,120.93 43.23,120.93
PLTRST#_SD_LPC: length 325.6
  TOP w0.102: v1(18.02,85.06) 19,84.08 19,82.74 22.74,78.99 22.74,78.69 25.31,76.12 29.42,76.12 v1(30.01,76.71) ; SIO_5553.52 225.2,46.09 225.24,46.13 229.68,46.13 v1(229.9,46.35) 230.16,46.61 RO187.2 ; RB27.1 14.89,152.02 15.27,151.64 v1(15.27,148.84) 14.96,148.53 RB28.1
  BOTTOM w0.102: v1(229.9,46.35) 229.52,45.97 226.98,45.97 v2(226.86,45.85) 225.69,45.85 223.32,43.48 222.61,43.48 221.01,41.88 220.1,41.88 217.43,39.22 210.6,39.22 210.09,38.71 204.84,38.71 204.26,39.29 200.25,39.29 188.15,51.39 177.44,51.39 176.69,52.15 173.48,52.15 169.39,48.06 164.9,48.06 163.7,46.85 156.77,46.85 153.45,50.17 134.99,50.17 134.45,49.63 120.84,49.63 120.07,48.86 119.94,48.73 115.18,48.73 110.77,53.15 90.95,53.15 86.94,57.15 85.02,57.15 78.79,63.38 71.81,63.38 70.13,65.05 54.92,65.05 54.61,65.37 45.74,65.37 44.92,66.19 38.71,66.19 31.38,73.52 31.38,75.34 v1(30.01,76.71) ; v1(15.27,148.84) 15.17,148.74 15.17,140.69 11.87,137.39 11.87,126.64 13.91,124.6 13.91,111.22 13.42,110.72 13.42,104.62 21.39,96.64 21.39,90.6 18.02,87.22 v1(18.02,85.06)
PLTRST#_SD_LPC_DEBUG: length 6.6
  TOP w0.102: LPC_DEBUG.3 8.96,153.03 v1(12.31,153.03) CB2.1 RB27.2
PLTRST#_SD_LPC_TCM: length 9
  TOP w0.102: v1(15.76,148.23) 15.84,148.15 RB28.2 ; UF2.18 20.75,153.18 v1(20.48,152.91)
  BOTTOM w0.102: v1(20.48,152.91) 19.78,152.91 18.85,151.98 18.85,151.61 16.97,149.73 16.97,149.12 16.09,148.23 v1(15.76,148.23)
PLTRST_IN_CPU#: length 137
  TOP w0.089: 53.12,138.07 53.12,137.99 53.63,137.48 53.63,135.25 53.8,135.08 53.8,134.96 U4.AK2
  TOP w0.102: v1(96.05,149.1) 96.05,149.4 96.43,149.78 96.65,149.78 97.47,150.61 101.04,150.61 104.81,154.38 105.75,154.38 115.55,164.18 115.55,174.2 110.32,179.43 110.32,188.96 R6575.1 RH2.2 ; v1(83.44,141.94) 83.42,141.94 82.12,143.24 77.35,143.24 70.46,150.13 70.46,152.55 68.78,154.22 66.52,154.22 64.91,155.83 56.77,155.83 51.14,150.19 51.14,144.9 53.12,142.92 53.12,138.07
  BOTTOM w0.102: v1(83.44,141.94) 84.41,141.94 v2(84.74,141.6) 85.07,141.94 88.27,141.94 88.93,142.6 91.29,142.6 95.92,147.23 95.92,148.97 v1(96.05,149.1)
PLTRST_N: length 562.2
  TOP w0.102: v1(26.32,116.71) 26.64,116.4 R6655.1 27.77,116.4 28.72,115.44 ; v1(48.29,167.51) 49.61,168.83 50.76,168.83 51.75,169.82 54.85,169.82 56.47,171.45 56.47,173.04 52.46,177.05 50.06,177.05 49.03,178.07 49.03,180.96 48.37,181.62 48.37,185.85 47.33,186.89 47.33,189.67 46.74,190.25 46.74,191.65 47.66,192.56 47.66,193.74 45.91,195.5 v1(45.91,195.81) 45.91,196.86 46.54,197.5 48.33,197.5 49.21,198.37 52.36,198.37 52.6,198.13 54.05,198.13 54.39,197.79 56,197.79 BRIDGE.H11 ; v1(123.85,57.04) 124.33,57.04 134.5,46.86 146.59,46.86 v1(146.97,46.48) ; v1(41.05,154.31) 36.63,158.72 36.63,161.11 37.4,161.88 v1(37.95,161.88) ; RF32.1 33.12,101.41 v1(32.42,100.71) 31.78,100.71 31.28,101.22 QF1.D ; v1(109.76,224.31) 109.76,224.31 109.86,224.41 109.86,224.64 110.05,224.83 RTK_LAN.19 ; v1(38.93,87.63) 39.18,87.88 40.6,87.88 43.01,90.29 43.01,100.04 42.4,100.65 42.4,101.08 42.88,101.56 RS22.1 ; v1(211.62,33.88) 211.62,33.96 212.5,34.85 RO13.1 213.08,35.56 214.92,35.56 215.69,36.34 SIO_5553.14 ; U1.1 43.74,254.14 42.71,253.11 42.71,251.08 v1(44.48,249.3)
  BOTTOM w0.102: v1(41.05,154.31) 40.88,154.31 37.07,150.49 37.07,142.01 34.45,139.39 30.46,139.39 27.89,136.82 27.89,136.19 26.65,134.95 26.65,131.8 26.65,131.79 26.65,131.56 26.14,131.05 26.14,124.84 26.45,124.54 26.45,116.81 26.35,116.71 v1(26.32,116.71) 21.77,112.16 21.77,108.42 28.16,102.03 30.34,102.03 31.14,101.23 31.9,101.23 v1(32.42,100.71) 32.9,101.19 34.34,101.19 36.67,98.86 36.67,92.89 37.9,91.66 37.9,88.66 v1(38.93,87.63) 40.44,86.13 40.44,85.35 41.15,84.64 41.15,80.84 42.33,79.66 42.33,79.11 42.78,78.65 42.78,76.25 45.27,73.76 45.27,73.34 48.52,70.09 53.53,70.09 56.39,72.95 59.24,72.95 60.74,71.45 61.53,71.45 62.87,70.11 70.08,70.11 70.35,70.38 75.96,70.38 77.21,69.14 81.26,69.14 87.57,62.83 89.37,62.83 93.4,58.8 113.09,58.8 114.66,57.23 119.18,57.23 119.89,56.51 123.33,56.51 v1(123.85,57.04) ; v1(45.91,195.81) 45.91,196.04 46.29,196.43 46.29,203.86 46.52,204.09 46.52,221.16 48.26,222.9 48.26,226.25 46.18,228.32 46.18,247.6 v2(45.45,248.33) v1(44.48,249.3) 45.22,250.04 51.24,250.04 52.18,249.1 63.21,249.1 66.9,252.78 73.11,252.78 77.05,256.72 86.22,256.72 92.24,250.7 95.66,250.7 98.03,248.34 98.03,228.35 99.96,226.42 105.88,226.42 106.21,226.09 106.74,226.09 107.94,224.89 109.25,224.89 109.76,224.38 v1(109.76,224.31) ; v1(146.97,46.48) 147.48,46.99 152.05,46.99 155.58,43.46 173.3,43.46 175.82,45.98 183.44,45.98 186.8,42.62 190.68,42.62 200.16,33.15 207.99,33.15 208.56,33.71 211.44,33.71 v1(211.62,33.88) ; v1(48.29,167.51) 48.67,167.13 48.67,161.21 48.44,160.98 47.03,160.98 46.65,161.37 40.79,161.37 39.94,162.21 38.58,162.21 38.24,161.88 v1(37.95,161.88)
PMDOWN: length 137.2
  TOP w0.089: 54.47,138.07 54.47,137.52 54.2,137.25 54.2,135.71 54.41,135.5 54.41,135.12 U4.AH2
  TOP w0.102: R6580.1 135.99,176.66 134.68,176.66 134.35,176.99 134.35,178.08 133.94,178.49 131.65,178.49 130.92,177.75 130.35,177.75 129.69,177.1 124.87,177.1 121.07,173.31 121.07,162.94 113.8,155.66 113.8,154.56 110.88,151.64 108.79,151.64 107.62,150.47 104.82,150.47 102,147.65 v1(98.79,147.65) ; v1(83.35,137.8) 83.35,138.56 83.22,138.68 83.22,140.34 81.54,142.02 76.85,142.02 69.24,149.63 69.24,152.05 68.28,153.01 66.01,153.01 64.41,154.61 57.32,154.61 55.65,152.95 52.36,149.65 52.36,145.44 54.36,143.43 54.36,141 54.52,140.84 54.52,138.58 54.47,138.53 54.47,138.07
  BOTTOM w0.102: v1(98.79,147.65) 98.59,147.45 v2(98.59,146.56) 98.59,146.54 92.3,140.26 91.19,140.26 90.62,140.26 89.96,139.6 86.88,139.6 85.89,138.61 84.16,138.61 v1(83.35,137.8)
PMDOWN_CPU: length 24.5
  TOP w0.102: CPU.D8 v3(152.71,162.95) ; R6580.2 RH3.2 137.19,175.39 v1(137.45,175.13)
  BOTTOM w0.102: v1(137.45,175.13) 137.45,174.5 139.25,172.69 139.94,172.69 145.47,167.17 146.95,167.17 147.37,166.75 149.59,166.75 150.06,166.28 v2(150.78,166.28) 151.56,166.28 152.66,165.18 152.66,163 v3(152.71,162.95)
PMSYNC#: length 156.6
  TOP w0.102: v1(96.43,147.95) 96.93,148.46 99.33,148.46 99.69,148.11 101.89,148.11 104.65,150.88 107.46,150.88 108.62,152.04 110.71,152.04 113.39,154.73 113.39,155.83 120.63,163.07 120.63,173.44 124.73,177.55 129.56,177.55 130.18,178.16 130.75,178.16 131.48,178.89 134.11,178.89 134.75,178.25 134.75,177.7 v1(135.29,177.16) ; R6581.2 53.96,139.94 53.96,143.26 51.95,145.27 51.95,149.82 55.25,153.12 57.15,155.02 64.58,155.02 66.18,153.41 68.45,153.41 69.64,152.21 69.64,149.8 77.02,142.42 81.71,142.42 83.73,140.41 v1(83.73,140.33) ; CPU.E8 v3(152.71,162.04)
  BOTTOM w0.102: v1(96.43,147.95) 96.43,147.83 96.86,147.4 96.86,146.59 91.75,141.48 89.39,141.48 88.73,140.82 86.16,140.82 85.35,140 84.06,140 v1(83.73,140.33) ; v1(135.29,177.16) 136.18,176.28 137.89,176.28 138.69,175.47 138.69,174.94 139.13,174.5 139.54,174.1 141.25,174.1 v2(147.73,167.62) 150.68,167.62 152.86,165.43 152.86,163.41 153.14,163.13 153.14,163.11 153.15,163.1 153.15,162.47 v3(152.71,162.04)
PMSYNC#_R: length 5.3
  TOP w0.089: 54.01,138.07 54.01,138.07 54.01,135.64 54.22,135.42 54.22,134.18 U4.AJ4
  TOP w0.102: 54.01,138.07 R6581.1
POL1_SDA: length 22.8
  TOP w0.102: RG13.2 148.19,232.22 v1(148.64,231.78) 148.64,230.33 RG14.1 148.46,229.46 148.89,229.46 150.68,227.67 RTK_VGA.22 ; EEPROM_G.5 160.74,226.95 157.18,230.5 v1(156.62,230.5)
  BOTTOM w0.102: v1(156.62,230.5) 154.9,230.5 152.84,232.57 v2(150.68,232.57) 150.4,232.57 149.99,232.97 148.93,232.97 148.64,232.68 v1(148.64,231.78)
POL2_SCL: length 28.5
  TOP w0.102: RTK_VGA.23 150.18,227.85 148.8,229.23 147.67,229.23 RG12.1 147.62,230.33 147.62,231.76 v1(147.61,231.78) 147.16,232.22 RG11.2 ; EEPROM_G.6 162.34,225.68 162.72,226.06 162.72,227.08 162.21,227.58 160.43,227.58 157.01,231.01 v1(156.24,231.01)
  BOTTOM w0.102: v1(156.24,231.01) 155.42,231.01 v2(154.64,231.79) 153.64,232.79 151.34,232.79 150.94,233.2 148.24,233.2 147.61,232.56 v1(147.61,231.78)
PQ7_G: length 3.4
  TOP w0.102: PR348.2 18.89,74.63 19.02,74.75 PC21.1 18.7,75.18 v1(18.07,74.55) 17.88,74.74 PR26.2
PQ7_G_R: length 16.8
  TOP w0.254: v1(15.15,70.82) 15.15,71.4 15.83,72.09 17.32,72.09 PR30.1 PR348.1 ; PQ2.3 22.4,67.76 21.34,68.81 20.26,68.81 PQ7.G 15.45,67.69 15.02,68.12 v1(15.02,68.33)
  BOTTOM w0.254: v1(15.02,68.33) 14.76,68.59 v2(14.76,69.72) 14.76,70.43 v1(15.15,70.82)
PQ9_G: length 7.3
  TOP w0.102: v1(16.29,75.56) 15.59,76.26 PQ9.G 15.59,77.58 16.01,78 16.75,78 PD2.2 17.53,77.6 17.88,77.25 PC22.1 PR25.1
PQ11_GATE: length 3
  TOP w0.508: PR35.2 7.27,209.87 PC30.1 8.16,208.85 PR36.2 v1(8.29,208.15)
PQ11_GATE_R: length 7.7
  TOP w0.508: 9.49,209.87 10,209.87 10.19,210.06 12.1,210.06 v1(12.59,210.55) 13.05,211.01 PQ13.3 ; 9.49,209.87 PQ11.G ; 9.49,209.87 PR36.1
  BOTTOM w0.508: v1(12.59,210.55) v2(12.59,211.5)
PQ16_D1: length 9.1
  TOP w0.102: v1(227.38,73.28) PQ16.D
  TOP w0.203: PQ16.D 224.87,73.81 222.14,73.81 221.37,73.04 PQ19.S1 220.14,73.79 PR347.2
PQ18A_BASE: length 2.4
  TOP w0.254: PQ20.2 152.69,65.98 PR57.1 152.18,66.42 151.75,66.85 v1(151.75,67.03)
PQ18B_BASE: length 5.6
  TOP w0.102: v1(153.7,64.13) 153.7,63.36 PQ20.6 153.34,63.49 153.2,63.63 152.81,63.63 152.69,63.5 PQ20.5 152.69,62.61 152.31,62.23 151.48,62.23 PR54.1
PQ19_D1: length 4.4
  TOP w0.102: PQ19.D1 223.41,73.04 223.55,72.9 223.55,72.63 223.31,72.39 PQ19.G2 222.25,72.39 221.9,72.04 v1(221.9,71.37) 221.9,70.8 PR41.2
PQ21_G1: length 3.6
  TOP w0.102: PR65.1 PC57.2 96.17,66.36 v1(96.17,65.53) 96.11,65.47 95.03,65.47
PQ21B_D1:
  vias: v1(98.46,63.5)
PQ23_GATE: length 4.5
  TOP w0.508: PQ23.G 98.33,97.37 97.01,98.69 v1(95.92,98.69) 95.85,98.76 PR78.1
PQ24B_D: length 4.6
  TOP w0.102: PQ24.D2 98.06,101.41 98.27,101.61 PC73.1 PR77.2 97,101.47 96.68,101.16 v1(96.68,100.86) 96.68,100.14 PR78.2
PQ24B_G: length 5.1
  TOP w0.254: PR76.2 100.49,98.3 v1(99.6,97.41) 99.36,97.65 PQ24.D1 99.36,99.43 99.17,99.62 98.89,99.62 98.71,99.44 PQ24.G2
PQ42A_D1: length 3.9
  TOP w0.102: PR353.2 61.39,72.95 v1(61.43,72.95) 61.62,73.14 62.72,73.14 62.82,73.24 62.82,73.69 62.72,73.79 62.26,73.79
PQ42A_G1: length 5.2
  TOP w0.102: v1(63.41,72.97) 63.41,73.41 63.79,73.79 65.18,73.79 65.57,73.41 PC261.1 66.02,73.99 66.45,74.42 66.45,74.47 66.53,74.55 PR320.1
PQ47_C: length 7.5
  TOP w0.102: v1(122.56,156.9) 122.64,156.82 122.64,155.85 121.98,155.19 PQ47.C 120.49,155.19 120.44,155.22 119.45,156.21 PR212.2 118.46,155.19 PQ46.G
PQ47_G: length 3.2
  TOP w0.102: PR213.2 119.6,151.68 v1(119.22,152.06) 119.51,152.06 PQ47.B
  BOTTOM w0.102: v2(118.43,151.92) 118.56,152.06 v1(119.22,152.06)
PQ49B_GATE: length 4.3
  TOP w0.102: PQ49.G2 104.05,141.1 103.92,141.22 PR216.2 103.42,141.22 103.16,140.96 v1(103.16,140.74) 103.4,140.5 PQ49.D1
  BOTTOM w0.102: v1(103.16,140.74) 103.15,140.75 v2(102.14,140.75)
PQ53_G1: length 7
  TOP w0.102: v1(54.26,35.05) 54.14,35.18 PD8.1 53.14,34.07 PR245.1
  BOTTOM w0.102: v1(57.95,35.43) 57.33,36.05 v2(56.01,36.05) 55.26,36.05 v1(54.26,35.05)
PQ54_G: length 4.5
  TOP w0.102: PC315.1 v1(113.7,30.48)
  TOP w0.508: PR383.2 112.36,29.98 PC315.1 112.86,31.13 PR246.2
  BOTTOM w0.102: v1(113.7,30.48) v2(114.62,30.48)
PQ55_G: length 3.6
  TOP w0.102: PQ55.D1 118.46,38.62 v1(118.25,38.42) ; PQ55.D1 PQ55.G2 ; PQ55.D1 119.16,39.69 PR243.2
  BOTTOM w0.102: v1(118.25,38.42) 117.63,38.42 v2(117.49,38.56)
PQ55B_D: length 29.4
  TOP w0.102: PQ55.D2 117.62,36.83 120,36.83 120.38,37.21 PR244.2 121.38,36.7 122.33,36.7 v1(126.91,32.13) ; PR383.1 114.15,30.23 114.15,30.92 v1(113.32,31.75)
  BOTTOM w0.102: v1(126.91,32.13) 126.78,32 123.12,32 v2(122.73,31.62) 122.34,32 117.89,32 117.64,31.75 v1(113.32,31.75)
PQ57A_D1: length 4.7
  TOP w0.102: PR252.2 52.04,32.26 51.02,32.26 PR250.1 49.69,32.77 v1(49.56,32.89) PQ57.D
PQ57B_G2: length 6.2
  TOP w0.102: v1(51.77,35.18) PD8.2 50.81,34.38 PC321.1 PR245.2 51.53,32.77 PR250.2
  BOTTOM w0.102: v1(51.77,35.18) v2(51.77,36.05)
PQ71_D1:
  vias: v1(9.96,41.3)
PQ72A_B1: length 3.5
  TOP w0.102: PR388.1 229.97,60.31 v1(230.46,60.81)
  TOP w0.254: PQ72.2 230.09,58.8 PR388.1
PQ72B_B1: length 6.3
  TOP w0.254: PR22.1 PR17.2 233.36,60.54 PQ72.6 232.91,59.45 232.76,59.3 232.76,58.94 232.9,58.8 PQ72.5 v1(234.63,58.8) 235.75,58.8 PQ76.C
PQ72B_C1: length 6.8
  TOP w0.102: PR391.1 228.44,57.85 v1(227.74,58.55)
  TOP w0.254: PR391.1 PR34.1 230.33,58.15 PQ72.3 231.74,58.15 232,57.9 PR317.1 232,56.01 PR392.2
PQ72B_E1: length 1.1
  TOP w0.254: PR389.2 v1(233.73,55.16)
PQ76_B1: length 3.4
  TOP w0.102: PR361.1 236.57,63.26 v1(235.9,63.93)
  TOP w0.254: PR361.1 236.82,62.23 PQ76.B
PQ79_C: length 3.8
  TOP w0.102: PR387.2 103.98,64.13 v1(104.43,64.13) 105.06,63.5 PQ79.5 105.82,63.5 105.95,63.37 105.95,62.95 105.85,62.85 PQ79.6
PQ79_G: length 2.8
  TOP w0.102: PQ79.2 106.59,63.5 106.33,63.75 v1(106.33,64.13) 106.27,64.2 PR386.2
PU21_Y: length 2.2
  TOP w0.102: v1(5.68,46.11) PR337.1 5.68,44.91 PU21.4
PV_RTCEXT: length 6.9
  TOP w0.254: v1(43.98,119.19) C1644.1 ; v1(48.3,121.99) 48.36,122.05 48.36,122.68 U4.BA26
  BOTTOM w0.254: v1(48.3,121.99) 47.64,121.99 v2(46.57,120.92) 46.22,120.57 45.52,120.57 44.14,119.19 v1(43.98,119.19)
PWRBTN_OUT#: length 680.5
  TOP w0.089: U4.AT13 v1(50.35,129.06)
  TOP w0.102: v1(215.87,21.97) CO56.1 RIO3.1 ; RS18.1 43,102.59 42.17,101.77 42.17,100.55 42.78,99.94 42.78,90.38 40.57,88.18 38.86,88.18 37.49,86.8 37.26,86.8 36.18,85.72 35.14,85.72 34.38,86.49 32.27,86.49 31.88,86.87 30.62,86.87 28.16,89.33 v1(27.77,89.33) ; v1(27.66,148.17) 27.66,149.34 28.67,150.34 29,150.34 29.93,151.28 29.93,154.16 29.04,155.05 29.04,158.62 v1(27.11,160.55) 24.67,162.99 16.07,162.99 14.66,164.4 14.66,197.2 13.3,198.56 RB5.1 ; v1(134.91,212.09) 134.91,211.45 137.78,208.58 137.78,207.59 138.46,206.91 138.46,204.77 137.78,204.09 137.78,192.83 136.36,191.41 132.65,191.41 131.69,190.46 129.94,190.46 129.67,190.72 125.36,190.72 R92.1 ; R6438.2 33.93,130.24 v1(33.69,130.48) 33.31,130.1 30.26,130.1 28.53,131.83 C1763.1 28.1,131.83 27.51,131.23 24.09,131.23 23.41,130.56 v1(18.78,130.56) ; v1(41.56,161.8) 42.93,163.17 44.44,163.17 46.42,165.15 48.65,165.15 50.43,166.93 51.55,166.93 52.54,167.92 55.99,167.92 59.36,171.3 62.59,171.3 65.56,168.33 66.84,168.33 69.94,165.23 v1(71.15,165.23) ; v1(228,29.59) 228,30.73 227.18,31.55 227.18,34.42 225.46,36.14 225.46,38.48 225.04,38.89 SIO_5553.34
  BOTTOM w0.089: v1(50.35,129.06) 49.91,129.5 48.86,129.5 48.39,129.98 44.23,129.98 44.12,130.09 43.58,130.09 43.23,129.74
  BOTTOM w0.102: v1(27.11,160.55) 29.28,162.71 40.65,162.71 v1(41.56,161.8) ; v1(71.15,165.23) 77.88,171.96 77.88,224.41 78.39,224.92 79.46,224.92 80.17,225.63 80.8,225.63 80.93,225.49 81.64,225.29 82.57,225.29 83.05,225.68 83.18,225.81 83.98,225.81 85.12,224.66 87,224.66 90.22,221.45 90.22,219.87 94.06,216.02 94.06,214.6 95.13,213.54 107.26,213.54 109.88,210.92 120.18,210.92 120.91,211.66 134.48,211.66 v1(134.91,212.09) ; v1(228,29.59) 228,28.83 224.62,25.45 221.34,25.45 217.86,21.97 v1(215.87,21.97) 212,21.97 211.08,21.06 200.73,21.06 195.69,26.1 195.69,31.18 189.47,37.4 174.17,37.4 172.33,35.56 154.2,35.56 151.93,37.83 138.2,37.83 137.22,38.81 122.2,38.81 121.43,39.57 118.47,39.57 116.9,41.15 109.34,41.15 106.49,43.99 103.44,43.99 102.18,45.25 99.69,45.25 98.39,46.55 92.16,46.55 85.77,52.94 83.73,52.94 81.26,55.42 76.56,55.42 69.22,62.76 66.72,62.76 66.72,62.76 66.33,62.76 65.44,63.66 54.16,63.66 53.84,63.97 45.03,63.97 44.21,64.79 38,64.79 29.98,72.81 29.98,74.05 25.94,78.1 25.55,78.1 23.73,79.92 23.73,85.86 27.2,89.33 v1(27.77,89.33) 27.97,89.53 27.97,90.68 27.39,91.26 26.75,91.26 24.77,93.24 24.77,98.01 16.72,106.06 16.72,115.32 18.12,116.72 18.12,117.6 17.74,117.98 17.74,125.02 18.78,126.06 v1(18.78,130.56) 19.25,131.03 19.25,137.8 23.4,141.95 23.4,144.04 23.17,144.27 23.17,144.7 26.64,148.17 v1(27.66,148.17) ; v1(33.69,130.48) 36.01,130.48 37,129.49 38.85,129.49 39.71,128.63 41.64,128.63 42.76,129.74 43.23,129.74
PWRBTN_OUT#_C: length 11
  TOP w0.102: SW_FVS.1 211.87,21.67 213.36,20.18 RIO2.2 RIO3.2 214.86,19.53 213.58,18.25 PWR_SW.2
PWRGD_140MS: length 311.8
  TOP w0.102: v1(101.63,101.85) 101.63,102.34 100.39,103.58 92.71,103.58 89.51,106.78 89.14,106.78 87.05,108.86 87.05,110.99 90.18,114.12 90.18,126.44 90.05,126.57 90.05,127.38 88.63,128.8 88.63,132.53 88.63,133.8 87.41,135.02 87.41,135.81 88.3,136.7 88.3,141.84 89.38,142.93 89.38,145.41 87.08,147.72 86.79,147.72 85.33,149.18 79.82,149.18 76.43,152.57 76.43,155 71.26,160.17 68.98,160.17 66.36,162.79 53.78,162.79 46.1,155.11 v1(45.92,155.11) ; SIO_5553.57 222.85,48.09 v1(222.64,47.88) ; v1(149.04,55) 147.63,56.41 136.58,56.41 134.76,58.24 134.76,61.23 129.47,66.52 129.47,67.41 v1(129.19,67.69) ; v1(40.93,145.67) 40.93,145.86 PR8.1 PC1.1 RX200.2 RX202.2
  BOTTOM w0.102: v1(40.93,145.67) 41.18,145.92 41.18,148.03 41.87,148.72 41.87,150.65 43.47,152.25 43.8,152.25 45.92,154.37 v1(45.92,155.11) ; v1(222.64,47.88) 222.32,47.88 219.12,44.68 212.45,44.68 212.02,45.11 210.96,45.11 208.93,47.14 206.63,47.14 203.73,44.25 201.98,44.25 200.61,45.62 199.29,45.62 196.76,48.15 196.76,51.18 195.79,52.15 192.93,52.15 189.05,56.03 178.43,56.03 177.62,56.85 171.79,56.85 171.03,56.08 171.03,55.23 167.59,51.79 157.11,51.79 154.19,54.71 149.34,54.71 v1(149.04,55) ; v1(101.63,101.85) 101.43,101.65 101.43,99.47 101.92,98.98 101.92,98.98 102.12,98.79 102.12,96.95 96.59,91.43 96.59,82.78 96.02,82.21 96.02,76.8 96.77,76.05 99.54,76.05 101.93,73.66 110.05,73.66 112.67,71.04 113.37,71.04 113.73,71.41 127.14,71.41 129.19,69.35 v1(129.19,67.69)
PWRGD_140MS_R: length 19.8
  TOP w0.089: U4.AW11 49.46,130.53 49.94,131.01 v1(50.17,131.01)
  TOP w0.102: RX200.1 42.86,143.68 42.86,142.2 RX201.1 42.32,140.92 v1(42.45,140.79)
  BOTTOM w0.089: v1(50.17,131.01) 49.41,131.77 46.8,131.77 44.25,134.32 44.13,134.32 43.67,134.78 43.67,136.42 43.23,136.86
  BOTTOM w0.102: 43.23,136.86 43.14,136.96 43.14,138.13 42.33,138.94 42.32,138.94 v2(42.32,140.01) 42.32,140.67 v1(42.45,140.79)
QS10_B: length 2
  TOP w0.102: RS162.2 149.11,40.87 v1(149,40.77) 148.32,40.08 QS10.B
QS10_E: length 3.1
  TOP w0.102: RS222.2 148.38,41.81 QS10.E 148.08,41.74 v1(147.1,40.77)
R_USB3_N3: length 201.3
  TOP w0.089: U4.AG8 55.77,131.87 v1(56.12,131.52)
  TOP w0.102: RU13.1 130.67,235.01 LU4.1 131.2,234.48 131.2,234.16 v1(130.9,233.86)
  BOTTOM w0.089: 55.11,137.95 55.11,137.93 55.1,137.93 55.1,137.8 55.7,137.2 55.7,131.91 55.57,131.78 55.57,131.51 55.68,131.4 56,131.4 v1(56.12,131.52)
  BOTTOM w0.102: v1(130.9,233.86) 131.21,233.86 131.32,233.97 131.32,234.33 131.21,234.44 130.75,234.44 129.66,233.35 129.66,232.81 129.32,232.47 128.78,232.47 v2(127.83,231.52) 127.54,231.23 127.54,223.22 125.71,221.39 116.86,221.39 116.56,221.08 114.3,221.08 111.73,223.66 109.5,223.66 108.95,224.21 107.65,224.21 106.46,225.4 104.39,225.4 104.07,225.72 99.68,225.72 96.6,228.8 96.6,235.76 92.84,239.52 78.14,239.52 73.59,234.98 73.59,229.91 69.15,225.47 69.15,222.69 71.05,220.78 71.05,203.88 72.78,202.16 72.78,177.19 71.46,175.87 69.9,175.87 62.97,168.94 62.97,164.11 61.07,162.2 61.07,146.23 59.57,144.73 59.57,143.65 57.74,141.83 57.74,140.48 56.68,139.42 56.18,139.42 55.11,138.35 55.11,137.95
R_USB3_N7: length 195.5
  TOP w0.089: U4.AB3 58.28,134.7 58.28,135.47 59.87,137.06 59.87,137.54 59.88,137.55 59.88,137.57
  TOP w0.102: v1(134.23,233.86) 133.94,234.14 133.94,234.48 LU35.2 134.25,234.79 RU10.1 ; 59.88,137.57 59.88,142.89 60.31,143.32 60.31,144.2 61.09,144.98 61.09,146.88 61.2,146.99 61.58,146.99 v1(61.63,146.94)
  BOTTOM w0.102: v1(134.23,233.86) 133.99,233.63 133.99,233.32 133.08,232.41 132.15,232.41 128.28,228.54 128.28,222.91 126.07,220.7 117.15,220.7 116.84,220.4 114.02,220.4 111.44,222.97 109.21,222.97 108.66,223.52 107.35,223.52 106.15,224.71 103.88,224.71 103.68,224.9 99.5,224.9 95.21,229.2 95.21,231.86 94.83,232.24 94.83,232.73 95.21,233.11 v2(95.21,234.75) 95.21,235.91 92.28,238.84 85,238.84 83.75,237.59 80.17,237.59 79.23,238.53 78.16,238.53 75.22,235.59 75.22,231.72 74.76,231.27 74.76,229.06 73.63,227.92 73.63,221.6 71.74,219.71 71.74,204.2 73.49,202.45 73.49,176.86 71.79,175.16 70.16,175.16 63.81,168.81 63.81,163.9 61.76,161.85 61.76,149.53 62.44,148.84 62.44,147.44 62.14,147.14 61.83,147.14 v1(61.63,146.94)
R_USB3_P3: length 201.3
  TOP w0.089: U4.AG10 55.54,131.22 55.24,131.52 v1(55.04,131.52)
  TOP w0.102: v1(131.74,233.86) 131.4,234.19 131.4,234.48 LU4.2 131.94,235.01 RU15.1
  BOTTOM w0.089: 54.9,137.95 54.9,137.93 54.91,137.93 54.91,137.72 55.51,137.12 55.51,131.99 v1(55.04,131.52)
  BOTTOM w0.102: 54.9,137.95 54.9,138.44 56.09,139.62 56.6,139.62 57.54,140.56 57.54,141.91 59.37,143.74 59.37,144.81 60.87,146.31 60.87,162.29 62.77,164.19 62.77,169.03 69.82,176.07 71.37,176.07 72.58,177.27 72.58,202.07 70.85,203.8 70.85,220.7 68.94,222.61 68.94,225.55 73.39,230 73.39,235.06 78.05,239.73 92.93,239.73 96.81,235.85 96.81,228.88 99.77,225.92 104.16,225.92 104.47,225.6 106.54,225.6 107.74,224.41 109.03,224.41 109.58,223.86 111.81,223.86 114.38,221.28 116.47,221.28 116.78,221.59 125.63,221.59 127.34,223.3 127.34,231.19 127.25,231.28 127.25,231.77 127.59,232.11 128.13,232.11 v2(129.07,233.05) 130.67,234.65 131.29,234.65 131.52,234.42 131.52,234.07 v1(131.74,233.86)
R_USB3_P7: length 195.4
  TOP w0.089: 59.67,137.57 59.67,137.55 59.68,137.54 59.68,137.14 58.08,135.55 58.08,134.94 58,134.86 U4.AB2
  TOP w0.102: v1(133.44,233.88) 133.74,234.19 133.74,234.48 LU35.1 133.44,234.79 RU12.1 ; 59.67,137.57 59.67,142.97 60.1,143.4 60.1,144.28 60.89,145.07 60.89,146.96 v1(61.63,147.7)
  BOTTOM w0.102: v1(61.63,147.7) 61.63,147.5 61.79,147.35 62.06,147.35 62.24,147.52 62.24,148.76 61.55,149.45 61.55,161.93 63.61,163.99 63.61,168.89 70.08,175.36 71.7,175.36 73.29,176.94 73.29,202.37 71.53,204.12 71.53,219.79 73.42,221.68 73.42,228.01 74.56,229.14 74.56,231.35 75.01,231.81 75.01,235.67 78.08,238.73 79.31,238.73 80.25,237.79 83.67,237.79 84.91,239.04 92.36,239.04 95.41,235.99 95.41,235.37 95.79,234.99 95.79,234.5 95.41,234.12 v2(95.41,232.49) 95.41,229.29 99.59,225.11 103.77,225.11 103.96,224.92 106.24,224.92 107.43,223.72 108.75,223.72 109.3,223.17 111.53,223.17 114.1,220.6 116.76,220.6 117.06,220.9 125.98,220.9 128.07,222.99 128.07,228.63 132.06,232.61 132.99,232.61 133.79,233.41 133.79,233.71 133.61,233.88 v1(133.44,233.88)
REFCLK_SEL: length 9.7
  TOP w0.102: BRIDGE.B13 55.18,192.22 55.18,191.05 55.63,190.59 55.63,189.9 v1(55.96,189.57) 55.96,185.12 56.55,184.53 RK11.2
  BOTTOM w0.102: v1(55.96,189.57) 55.96,188.88 v2(55.85,188.77)
REGOUT:
  vias: v1(114.84,221.92)
RGNDA: length 9.5
  TOP w0.203: v1(230.56,184.73) 231.06,185.23 PR153.2 PR157.2 231.24,186.44 230.61,186.44 229.85,187.2 229.59,187.2 PC106.1 228.73,188.05 228.02,188.05 PC105.1 226.6,189.04 226.16,189.04 225.85,189.34 PU7.32
RING2: length 1.7
  TOP w0.203: 181.94,24.72 182.23,24.43 UA1.17
  TOP w0.254: 181.06,24.79 181.14,24.72 181.94,24.72
  vias: v1(177.71,25.53)
RING2_J:
  vias: v1(172.37,26.62) v1(173.01,26.62) v1(185.2,4.53) v1(185.2,3.89) v1(187.23,4.53) v1(187.23,3.89)
RING#: length 266.3
  TOP w0.089: U4.AN43 51.85,114.27 51.85,111.63 51.47,111.25
  TOP w0.102: v1(35.95,86.21) 36.77,87.03 37.39,87.03 38.77,88.41 40.48,88.41 42.55,90.48 42.55,99.85 41.94,100.46 41.94,102.34 43.62,104.01 44.99,104.01 46.39,102.62 47.58,102.62 48.19,102.01 49.64,102.01 49.87,102.23 49.87,102.67 49.74,102.8 49.74,104.83 50.33,105.41 50.33,110.11 51.47,111.25 ; SIO_5553.75 218.89,53.81 218.35,54.36 v1(218.35,55.12) 218.35,56.13 218.98,56.77 R508.2
  BOTTOM w0.102: v1(35.95,86.21) 35.85,86.1 v2(35.85,85.09) 35.85,79.91 36.94,78.82 36.94,75.87 40.75,72.06 41.36,72.06 42.68,70.74 47.2,70.74 48.07,69.86 53.62,69.86 56.48,72.72 59.14,72.72 60.64,71.22 61.44,71.22 62.78,69.89 70.18,69.89 70.44,70.15 75.86,70.15 77.11,68.91 81.17,68.91 87.47,62.6 89.28,62.6 93.31,58.57 113,58.57 114.57,57 119.08,57 120,56.08 130.11,56.08 131.02,56.99 143.75,56.99 144.48,57.72 144.48,59.4 145.19,60.1 146.88,60.1 147.42,59.56 155.66,59.56 156.16,60.07 165.45,60.07 165.68,60.29 179.72,60.29 180.73,59.28 191.95,59.28 195.11,56.13 195.11,54.99 195.99,54.1 196.91,54.1 199.38,51.63 199.38,48.59 200.08,47.89 204.64,47.89 206.36,49.6 207.43,49.6 207.6,49.43 208.97,49.43 212.17,52.63 216.97,52.63 217.84,53.49 217.84,54.61 v1(218.35,55.12)
RSDATA_OUT: length 294.9
  TOP w0.102: R6347.1 40.42,136.97 40.42,138.3 37.42,141.3 37.42,144.08 34.79,146.71 30,146.71 23.09,139.8 20.03,139.8 17.18,136.95 17.18,136.4 v1(17.43,136.14) ; UA1.5 186.18,32.21 186.47,32.5 186.47,33.23 v1(186.98,33.74)
  BOTTOM w0.102: v1(186.98,33.74) 186.39,33.15 184.7,33.15 184.37,33.47 182.95,33.47 182.65,33.17 174.25,33.17 173.67,32.59 172.42,32.59 172.12,32.28 170.98,32.28 170.39,32.87 152.54,32.87 152.12,32.44 137.92,32.44 135.54,34.82 116.55,34.82 116.29,34.55 99.87,34.55 91.88,42.54 90.51,42.54 84.6,48.45 82.91,48.45 79.72,51.64 73.31,51.64 67.84,57.11 62.98,57.11 61.21,58.88 57.96,58.88 57.48,58.39 47.87,58.39 47.51,58.76 41.43,58.76 41.11,59.08 40.39,59.08 39.59,59.88 37.43,59.88 26.22,71.1 26.22,71.78 19.93,78.07 19.93,87.84 22.31,90.22 22.31,97.02 14.33,105 14.33,110.34 15.07,111.08 15.07,119.83 16.82,121.58 16.82,125.76 17.64,126.57 17.64,132.38 16.96,133.06 16.96,135.67 v1(17.43,136.14)
RTK_RSET_R: length 6
  TOP w0.102: RTK_LAN.31 113.17,228.2 113.32,228.35 114.41,228.35 115.17,229.11 117.06,229.11 RL33.2 117.32,228.66 116.95,228.3 116.95,228.22 v1(116.92,228.19)
S_GPI_BRD_REV0: length 16.7
  TOP w0.089: v1(59.6,118.23) 59.94,118.23 U4.U36
  TOP w0.102: v1(59.44,107.9) 59.45,107.89 59.45,107.74 RS124.1 58.45,106.74 58.45,105.47 RS127.2
  BOTTOM w0.089: 61.63,111.25 61.63,112.2 60.93,112.9 60.93,113.74 60.23,114.44 60.23,114.94 60.36,115.06 v2(60.36,116.28) 60.36,117.47 v1(59.6,118.23)
  BOTTOM w0.102: v1(59.44,107.9) 60.38,108.84 60.61,108.84 61.63,109.85 61.63,111.25
S_GPI_BRD_REV1: length 12.9
  TOP w0.089: 62.64,111.25 62.64,111.56 61.54,112.67 61.54,113.02 61.63,113.11 61.63,113.79 61.76,113.93 U4.P44
  TOP w0.102: RS129.2 RS123.1 ; RS123.1 63.28,104.84 63.28,106.81 63.05,107.04 63.05,109.9 62.8,110.16 62.8,110.5 62.64,110.65 62.64,111.25 ; RS123.1 63.88,104.33 v1(64.39,104.85)
S_MFG_MODE_OR: length 237.5
  TOP w0.089: U4.BC23 47.32,124.82 46.79,124.82 46.07,125.53 44.2,125.53 44.15,125.58 43.19,125.58
  TOP w0.102: R6649.2 41.31,124.59 v1(41.82,125.09) 42.3,125.58 43.19,125.58 ; v1(151.16,35.94) 151.16,40.37 RS162.1 ; v1(31.15,125.48) 26.81,125.48 25.95,124.61 22.1,124.61 20.86,125.86 18.81,125.86 17.05,124.09 17.05,122.65 18.77,120.93 18.77,116.48 22.15,113.1 22.15,102.68 24.09,100.74 24.09,88.72 v1(24.54,88.26)
  BOTTOM w0.102: v1(151.16,35.94) 150.42,36.69 145.77,36.69 144.15,35.06 139.03,35.06 136.65,37.44 117.02,37.44 114.69,39.77 108.77,39.77 105.92,42.62 102.87,42.62 101.62,43.88 99.13,43.88 97.85,45.16 91.61,45.16 85.7,51.07 83.99,51.07 80.78,54.28 76.08,54.28 68.74,61.62 66.25,61.62 65.86,61.62 64.97,62.51 53.68,62.51 53.37,62.83 44.39,62.83 43.57,63.65 37.53,63.65 28.84,72.34 28.84,72.87 22.89,78.81 22.89,87.38 23.4,87.88 24.29,87.88 24.54,88.14 v1(24.54,88.26) ; v1(31.15,125.48) 31.83,126.16 32.75,126.16 33.21,125.7 33.94,125.7 35.46,124.18 37.73,124.18 38.26,124.71 38.77,125.22 v2(40.27,125.22) 41.69,125.22 v1(41.82,125.09)
S_PCIAUX_GATE: length 239
  TOP w0.089: 61.32,111.25 60.61,111.96 60.61,112.35 60.56,112.4 60.56,113.33 59.97,113.92 U4.V44
  TOP w0.102: RO3.2 213.33,55.56 212.5,56.39 v1(212.5,56.77) ; v1(45.37,96.39) 45.6,96.62 49.12,96.62 49.78,95.96 52.46,95.96 53.17,96.67 55.25,96.67 56.57,97.99 58.55,97.99 58.82,98.26 58.82,99.1 60.21,100.48 62.03,100.48 63.13,101.57 63.13,104.23 R68.2 61.96,105.4 61.96,110.62 61.32,111.25
  BOTTOM w0.102: v1(45.37,96.39) 45.17,96.19 45.17,86.71 46.57,85.31 46.57,84.71 46.13,84.27 46.13,82.82 45.52,82.22 45.52,80.85 46.17,80.2 46.17,79.42 47.24,78.36 47.88,78.36 48.98,79.45 53.25,79.45 56.55,76.15 60.02,76.15 60.25,75.92 61.66,75.92 63.33,74.25 65.69,74.25 66.27,73.66 68.64,73.66 69.02,73.28 80.35,73.28 83.14,70.49 84.16,70.49 85.65,69 85.65,67.22 88.29,64.58 90.1,64.58 93.1,61.58 97.01,61.58 97.51,61.08 109.91,61.08 110.44,61.62 112.79,61.62 115.37,59.03 126.44,59.03 130.79,63.38 144.57,63.38 145.98,64.79 146.64,64.79 147.63,65.79 154.21,65.79 154.97,66.55 v2(158.86,66.55) 159.37,66.55 160.08,65.83 178.32,65.83 182.02,62.13 194.34,62.13 198.43,58.04 200.15,58.04 201.31,56.87 205.23,56.87 205.34,56.77 v1(212.5,56.77)
S_PME#: length 157.9
  TOP w0.089: U4.BD17 46.69,127.34 46.56,127.22 45.04,127.22 44.32,126.5 43.19,126.5
  TOP w0.102: v1(30.01,147.83) 30.01,148.82 32.27,151.08 32.27,155.98 30.46,157.79 30.46,159.32 25.37,164.41 16.72,164.41 16.09,165.05 16.09,197.79 15.4,198.48 15.4,205.79 15.98,206.38 15.98,219.15 16.67,219.84 18.07,219.84 18.83,219.07 20.35,219.07 21.12,219.84 23.02,219.84 23.78,219.07 25.18,219.07 25.48,218.77 RK53.1 26.13,218.81 RK30.1 ; 43.19,126.5 41.44,126.5 40.19,125.25 38.96,125.25 37.74,124.03 37,124.03 R6352.2 35.96,124.03 35.42,124.03 35.16,123.77 35.16,123.4 34.73,122.97 34.73,122.33 34.12,121.72 33.8,121.72 33.65,121.57 32.98,121.57 32.28,120.88 21.57,120.88 v1(21.21,120.52)
  BOTTOM w0.102: v1(21.21,120.52) v2(21.21,122.19) 21.12,122.29 21.12,136.94 26.64,142.46 26.75,142.58 26.75,145.11 29.47,147.83 v1(30.01,147.83)
S_PSWD_CLR: length 234.2
  TOP w0.089: v1(60.98,116.77) 60.59,116.39 U4.U39
  TOP w0.102: v1(152.05,35.94) 152.7,36.59 RS159.2 152.7,42.79 P1.1 ; v1(57.03,82.55) 56.68,82.2 55.99,82.2 55.59,82.6 53.99,82.6 53.74,82.85 51.47,82.85 50.32,81.7 49.28,81.7 48.52,82.46 48.52,83.48 47.98,84.02 47.26,84.02 45.3,82.06 42.41,82.06 41.99,81.64 39.18,81.64 35.04,77.5 30.87,77.5 30.24,78.13 24.27,78.13 v1(23.91,78.49)
  BOTTOM w0.089: v1(60.98,116.77) 61.37,116.37 61.37,114.43 61.12,114.17 61.12,112.98 61.88,112.22 61.88,111.25
  BOTTOM w0.102: v1(152.05,35.94) 151.08,36.92 145.68,36.92 144.05,35.29 139.12,35.29 136.74,37.67 117.12,37.67 114.79,40 108.86,40 106.02,42.85 102.97,42.85 101.71,44.11 99.22,44.11 97.94,45.38 91.71,45.38 85.8,51.3 84.09,51.3 80.88,54.51 76.18,54.51 68.84,61.85 66.34,61.85 65.95,61.85 65.06,62.74 53.78,62.74 53.47,63.06 44.55,63.06 43.73,63.88 37.63,63.88 29.07,72.44 29.07,72.96 23.91,78.12 v1(23.91,78.49) ; v1(57.03,82.55) 57.03,82.86 55.94,83.95 55.94,85.88 56.29,86.23 56.29,88.7 59.49,91.9 59.49,95.02 61.63,97.16 61.63,105.04 61.32,105.35 61.32,106.23 61.63,106.54 61.63,106.78 61.96,107.11 61.96,111.18 61.88,111.25
S_SLP_S5#_SIO: length 28.9
  TOP w0.102: RO24.2 205.52,38.1 207.17,39.75 207.17,40.13 207.93,40.89 SIO_5553.122 209.81,40.89 210.09,41.17 210.09,41.66 v1(214.66,46.23) ; RO22.2 222.41,55.63 222.87,56.08 v1(222.87,56.14)
  BOTTOM w0.102: v1(222.87,56.14) 222.87,56.08 220.94,54.15 220.94,53.93 219.76,52.76 218.19,52.76 216.71,51.27 216.71,50.71 216.14,50.14 215.58,50.14 214.66,49.23 v1(214.66,46.23)
S_USB3_HDR_DET#: length 9.2
  TOP w0.089: U4.N42 62.06,114.73 62.06,114.61 62,114.54 62,113.9 62.1,113.79 62.1,113.28 62.39,112.99 62.39,112.27 63.1,111.56 63.1,111.25
  TOP w0.102: 63.1,111.25 v1(63.1,110.95) 63.28,110.77 63.28,107.25 RU46.2
