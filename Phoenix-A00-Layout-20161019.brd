# Allegro board Phoenix-A00-Layout-20161019.brd (continued)
## Nets (continued)
PDB: RA8.2 RA21.1 RA22.1 RA36.2 UA1.47(PDB)
PECI_REQUEST: R6403.2 SIO_5553.20((NH_CPURST) GP005/NPECI_REQUEST) U4.BB17(GPP_A12_BMBUSY_N)
PEGICOMP_MCP: CPU.L7(PEG_RCOMP) R6289.2
PLTRST: BH1.2(A) C1629.1 R6655.2 U4.BB27(GPP_B13_PLTRST_N)
PLTRST#_SD_LPC: RB27.1 RB28.1 RO187.2 SIO_5553.52(NPCI_RST_2/GP027)
PLTRST#_SD_LPC_DEBUG: CB2.1 LPC_DEBUG.3 RB27.2
PLTRST#_SD_LPC_TCM: RB28.2 UF2.18(LRESET#)
PLTRST_IN_CPU#: R6575.1 RH2.2 U4.AK2(PLTRST_CPU_N)
PLTRST_N: BH1.4(Y) BRIDGE.H11(PERST#) QF1.D(DRAIN) R6655.1 RF32.1 RO13.1 RS22.1 RTK_LAN.19(PERSTB) SIO_5553.14(NLRESET) U1.1(A)
PMDOWN: R6580.1 U4.AH2(PM_DOWN)
PMDOWN_CPU: CPU.D8(PM_DOWN) R6580.2 RH3.2
PMSYNC#: CPU.E8(PM_SYNC) R6581.2
PMSYNC#_R: R6581.1 U4.AJ4(PM_SYNC)
POL1_SDA: EEPROM_G.5(SDA) RG13.2 RG14.1 RTK_VGA.22(POL1_SDA)
POL2_SCL: EEPROM_G.6(SCL) RG11.2 RG12.1 RTK_VGA.23(POL2_SCL)
PQ7_G: PC21.1 PR26.2 PR348.2
PQ7_G_R: PQ2.3(GATE) PQ7.G(GATE) PR30.1 PR348.1
PQ9_G: PC22.1 PD2.2(ANODE) PQ9.G(GATE) PR25.1
PQ11_GATE: PC30.1 PR35.2 PR36.2
PQ11_GATE_R: PQ11.G(GATE) PQ13.3(GATE) PR36.1
PQ16_D1: PQ16.D(DRAIN) PQ19.S1 PR347.2
PQ18A_BASE: PQ20.2(BASE) PR57.1
PQ18B_BASE: PQ20.5(BASE) PQ20.6(COLLECTOR) PR54.1
PQ19_D1: PQ19.D1 PQ19.G2 PR41.2
PQ21_G1: PC57.2 PQ21.G(GATE) PR65.1
PQ21B_D1: PQ21.D(DRAIN) PQ22.D1 PQ22.G2 PR61.2
PQ23_GATE: PQ23.G(GATE) PR78.1
PQ24B_D: PC73.1 PQ24.D2 PR77.2 PR78.2
PQ24B_G: PQ24.D1 PQ24.G2 PR76.2
PQ42A_D1: PQ78.D1 PQ78.G2 PR353.2
PQ42A_G1: PC261.1 PQ78.G1 PR320.1
PQ47_C: PQ46.G(GATE) PQ47.C(COLLECTOR) PR212.2
PQ47_G: PQ47.B(BASE) PR213.2
PQ49B_GATE: PQ49.D1 PQ49.G2 PR216.2
PQ53_G1: PC316.2 PD8.1(CATHODE) PQ53.4(G) PR245.1
PQ54_G: PC315.1 PR246.2 PR383.2
PQ55_G: PQ55.D1 PQ55.G2 PR243.2
PQ55B_D: PQ55.D2 PR244.2 PR383.1
PQ57A_D1: PQ57.D(DRAIN) PR250.1 PR252.2
PQ57B_G2: PC321.1 PD8.2(ANODE) PR245.2 PR250.2
PQ71_D1: PC340.1 PD6.1(A) PQ71.D(DRAIN) PR336.2 PU21.2(A)
PQ72A_B1: PQ72.2(BASE) PR388.1
PQ72B_B1: PQ72.5(BASE) PQ72.6(COLLECTOR) PQ76.C(COLLECTOR) PR17.2 PR22.1
PQ72B_C1: PQ72.3(COLLECTOR) PR34.1 PR317.1 PR391.1 PR392.2
PQ72B_E1: PQ72.4(EMITTER) PR317.2 PR382.1 PR389.2
PQ76_B1: PQ76.B(BASE) PR361.1
PQ79_C: PQ79.5(BASE) PQ79.6(COLLECTOR) PR387.2
PQ79_G: PQ79.2(BASE) PR386.2
PU21_Y: PR337.1 PU21.4(Y)
PV_RTCEXT: C1644.1 U4.BA26(DCPRTC)
PWRBTN_OUT#: C1763.1 CO56.1 R92.1 R6438.2 RB5.1 RIO3.1 RS18.1 SIO_5553.34(NPWRBTN/GP015) U4.AT13(GPD3_PWRBTN#)
PWRBTN_OUT#_C: PWR_SW.2(S1) RIO2.2 RIO3.2 SW_FVS.1
PWRGD_140MS: PC1.1 PR8.1 RX200.2 RX202.2 SIO_5553.57(PWR_GOOD_3V/GP033)
PWRGD_140MS_R: RX200.1 RX201.1 U4.AW11(PCH_PWROK)
QS10_B: QS10.B(BASE) RS162.2
QS10_E: QS10.E(EMITTER) RS222.2
R_USB3_N3: LU4.1 RU13.1 U4.AG8(USB2N3)
R_USB3_N7: LU35.2 RU10.1 U4.AB3(USB2N7)
R_USB3_P3: LU4.2 RU15.1 U4.AG10(USB2P3)
R_USB3_P7: LU35.1 RU12.1 U4.AB2(USB2P7)
REFCLK_SEL: BRIDGE.B13(REFCLK125_SEL) RK11.2
REGOUT: CL41.1 LL2.1 RL36.1 RTK_LAN.24(REGOUT)
RGB_IMPEDANCE: PAD1.1
RGNDA: PC105.1 PC106.1 PR153.2 PR157.2 PU7.32(RGNDA)
RING2: IO_FBI8.1 RA72.2 UA1.17(MIC2-L(PORT-F-L)/RING)
RING2_J: CA119.1 DA5.2(IO2) F_AUDIO.3 IO_FBI8.2
RING#: R508.2 SIO_5553.75(GP041/NIO_PME) U4.AN43(GPP_C23_UART2_CTS_N)
RSDATA_OUT: R6347.1 UA1.5(SDATA-OUT)
RTK_RSET_R: RL33.2 RTK_LAN.31(RSET)
S_GPI_BRD_REV0: RS124.1 RS127.2 U4.U36(GPP_G4_FAN_TACH_4)
S_GPI_BRD_REV1: RS123.1 RS129.2 U4.P44(GPP_G5_FAN_TACH_5)
S_MFG_MODE_OR: R6649.2 RS162.1 U4.BC23(GPP_B3_CPU_GP2)
S_PCIAUX_GATE: R68.2 RO3.2 U4.V44(GPP_F23)
S_PME#: R6352.2 RK30.1 RK53.1 U4.BD17(GPP_A11_PME_N)
S_PSWD_CLR: P1.1 RS159.2 U4.U39(GPP_G10_FAN_PWM_2)
S_SLP_S5#_SIO: RO22.2 RO24.2 SIO_5553.122(NSLP_S5/GP066)
S_USB3_HDR_DET#: RU46.2 U4.N42(GPP_G11_FAN_PWM_3)
SATA_LED#: RIO10.1 RNO2.3 U4.AD44(GPP_E8_SATALED_N) XDP_PCH.35(OBSDATA_B3)
SATA_RXN0: CSA3.1 U4.G35(SATA_RXN0B / PERN13)
SATA_RXN0_C: CSA3.2 SATA0.5(B-)
SATA_RXN1: CSA11.1 U4.D39(SATA_RXN1B / PERN14)
SATA_RXN1_C: CSA11.2 SATA1.5(B-)
SATA_RXN2: CSA7.1 U4.F41(SATA_RXN2 / PERN15)
SATA_RXN2_C: CSA7.2 SATA2.5(B-)
SATA_RXN3: CM3.2 U4.D43(SATA_RXN3 / PERN16)
SATA_RXP0: CSA4.1 U4.E35(SATA_RXP0B / PERP13)
SATA_RXP0_C: CSA4.2 SATA0.6(B+)
SATA_RXP1: CSA12.1 U4.E37(SATA_RXP1B / PERP14)
SATA_RXP1_C: CSA12.2 SATA1.6(B+)
SATA_RXP2: CSA8.1 U4.E41(SATA_RXP2 / PERP15)
SATA_RXP2_C: CSA8.2 SATA2.6(B+)
SATA_RXP3: CM4.2 U4.E42(SATA_RXP3 / PERP16)
SATA_TXN0: CSA2.1 U4.C36(SATA_TXN0B / PETN13)
SATA_TXN0_C: CSA2.2 SATA0.3(A-)
SATA_TXN1: CSA10.1 U4.B38(SATA_TXN1B / PETN14)
SATA_TXN1_C: CSA10.2 SATA1.3(A-)
SATA_TXN2: CSA6.1 U4.B39(SATA_TXN2 / PETN15)
SATA_TXN2_C: CSA6.2 SATA2.3(A-)
SATA_TXN3: CM2.2 U4.A41(SATA_TXN3 / PETN16)
SATA_TXP0: CSA1.1 U4.B36(SATA_TXP0B / PETP13)
SATA_TXP0_C: CSA1.2 SATA0.2(A+)
SATA_TXP1: CSA9.1 U4.C38(SATA_TXP1B / PETP14)
SATA_TXP1_C: CSA9.2 SATA1.2(A+)
SATA_TXP2: CSA5.1 U4.A39(SATA_TXP2 / PETP15)
SATA_TXP2_C: CSA5.2 SATA2.2(A+)
SATA_TXP3: CM1.2 U4.A40(SATA_TXP3 / PETP16)
SATAGP0: R85.2 R90.2 RS13.1 U4.AG36(GPP_E0_SATAXPCIE0_SATAGP0)
SATAGP0_R: RS13.2 XDP_PCH.4(OBSFN_C0)
SATAGP1: R91.2 R98.2 U4.AG35(GPP_E1_SATAXPCIE1_SATAGP1) XDP_PCH.9(OBSDATA_A0)
SATAGP2: R99.2 R101.2 U4.AG39(GPP_E2_SATAXPCIE2_SATAGP2) XDP_PCH.11(OBSDATA_A1)
SATAGP3: R100.2 R103.2 U4.AD35(GPP_F0_SATAXPCIE3_SATAGP3) XDP_PCH.28(OBSDATA_D0)
SATAGP4: R104.2 R108.2 RP26.1 U4.AD31(GPP_F1_SATAXPCIE4_SATAGP4) XDP_PCH.30(OBSDATA_D1)
SATAGP5: R105.2 R109.2 RS14.1 U4.AD38(GPP_F2_SATAXPCIE5_SATAGP5)
SATAGP5_R: RS14.2 XDP_PCH.34(OBSDATA_D2)
SATAGP6: R6603.2 R6604.2 RS17.1 U4.AC43(GPP_F3_SATAXPCIE6_SATAGP6)
SATAGP6_R: RS17.2 XDP_PCH.36(OBSDATA_D3)
SATAGP7: R6605.2 R6606.2 U4.AB44(GPP_F4_SATAXPCIE7_SATAGP7) XDP_PCH.6(OBSFN_C1)
SD4_WAKE: RP25.1 U4.AE44(GPP_E7_CPU_GP1) XDP_PCH.33(OBSDATA_B2)
SER_IRQ: R6586.2 SIO_5553.127(SER_IRQ) U4.BA17(GPP_A6_SERIRQ)
SER_SENCE#: R663.2 U4.L44(GPP_G22) WF_BT_USB.10
SERIRQ: BRIDGE.N8(SERIRQ) RK36.2
SERVICE_MODE_1: P3.1 RS161.2
SIO_24M_CLOCKI: R6393.1 RB11.1
SIO_24M_CLOCKI_LPC: R6615.1 RF76.2 RF177.2 UF3.1(CLKIN)
SIO_24M_PCICLK: R6394.1 SIO_5553.16(PCICLK)
SIO_24M_TCM: RF177.1 RF179.1 UF2.22(LCLK)
SIO_CAP1: CO18.1 SIO_5553.128(CAP1)
SIO_CLOCKI: RF76.1 RF176.2 RF178.2 SIO_5553.7(CLOCKI)
SIO_GP004: RO19.2 SIO_5553.68(NSUS_WARN/GP004)
SIO_GP010: RO4.2 SIO_5553.25(SMBDAT2/GP010)
SIO_GP011: RO8.2 SIO_5553.26(SMBCLK2/GP011)
SIO_GP016: R6523.1 SIO_5553.36(NPROCHOT_IN/NPROCHOT_OUT/GP016)
SIO_GP026: RO166.2 SIO_5553.51(NPCI_RST_1/GP026)
SIO_GP071: RO2.2 SIO_5553.126((NSLP_M) GP071/NIO_SMI)
SIO_PCIAUX_G: QS11.G1 RO100.1
SIO_PECI_R: RO12.2 SIO_5553.31(PECI_READY/LVSMB_DAT1)
SIO_PWRGD: RO174.1 SIO_5553.123(PWRGD_PS)
SIO_QO1A_B: QO1.2(BASE) RO168.2
SIO_QO1B_B: QO1.5(BASE) RO171.1 RO172.2
SIO_QO2A_B: QO2.2(BASE) RO43.2
SIO_QO2B_B: QO2.5(BASE) RO44.2 RO45.1
SIO_QO3A_B: QO3.2(BASE) QO3.3(COLLECTOR) RO46.2
SIO_QO3B_B: QO3.5(BASE) RO50.2 RO53.1
SIO_QO4A_B: QO4.2(BASE) RO48.1 RO170.2
SIO_QO4B_B: QO4.5(BASE) RO51.2 RO54.1
SIO_QO5A_B: QO5.2(BASE) QO5.3(COLLECTOR) RO55.2
SIO_QO5B_B: QO5.5(BASE) RO56.2 RO57.1
SIO_RSMRST#: R89.1 R6418.2 R6531.1 SIO_5553.58(NRSMRST)
SIO_SLP_S4#_R: QS11.G2 RO102.2
SIO_SLP_SUS: RO81.2 SIO_5553.71(NSLP_SUS)
SIO_SLP_WLAN_N_R: QV72.G(GATE) RO118.2
SLEEVE: IO_FBI7.1 QA4.D(DRAIN) RA73.2 UA1.18(MIC2-R(PORT-F-R)/SLEEVE)
SLEEVE_J: CA118.1 DA5.1(IO1) F_AUDIO.4 IO_FBI7.2
SLP_A#: R6662.2 RB10.2 RO2.1
SLP_S0_N: TPS1.1(TP) U4.BC26(GPP_B12_SLP_S0_N)
SLP_S3#: PQ4.G1 PQ49.G1 R6660.2 RB8.2 SIO_5553.121(NSLP_S3)
SLP_S4#: PQ19.G1 PQ22.G1 PQ24.G1 PQ55.G1 R6661.2 RB3.1 RO22.1 RO102.1 SIO_5553.69(NSLP_S4) U139.2(B)
SLP_S5#: RB9.2 RO7.2 RO24.1 U4.BA13(GPD10_SLP_S5#)
SLP_SUS#: PD2.1(CATHODE) PR25.2 PR276.2 PR320.2 R6423.2 RO81.1
SLP_SUS#_PCH: R6423.1 U4.BB13(SLP_SUS_N)
SLP_SUS_FET_R: PQ9.D(DRAIN) PR24.2 PR26.1
SLP_WLAN_N: RO118.1 U4.AV13(GPD9_SLP_WLAN_N)
SMB_DDR4_CLK: DIMM1.141(SCL) DIMM2.141(SCL) RG3.2 RO26.2 SIO_5553.81(SCLK/GP123) XDP_CPU.53(SCL)
SMB_DDR4_DATA: DIMM1.285(SDA) DIMM2.285(SDA) RG4.2 RO25.2 SIO_5553.79(SDAT/GP121) XDP_CPU.51(SDA)
SMBCLK: RK10.2 RK51.2 RO163.2 RX19.1 RX175.1 SIO_5553.80(SCLK_1/GP122) U4.AW44(GPP_C0_SMBCLK)
SMBDATA: RK19.2 RK52.2 RO80.2 RX20.1 RX176.1 SIO_5553.78(SDAT_1/GP120) U4.BB43(GPP_C1_SMBDATA)
SML1CLK_PCH: RO8.1 RS90.2 U4.AW42(GPP_C6_SML1CLK)
SML1DATA_PCH: RO4.1 RS89.2 U4.AW45(GPP_C7_SML1DATA)
SPI_CS#: SPI1.1(CS#) SPI_1.1(CS#) U4.BD31(SPI0_CS0#)
SPI_IO2: R102.1 R6518.1 RA13.1 RF24.1 U4.BC29(SPI0_IO2)
SPI_IO3: R83.1 RA14.1 RF23.1 U4.BD30(SPI0_IO3)
SPI_MISO: R78.1 RA11.1 RF60.1 RF61.1 U4.BE30(SPI0_MISO)
SPI_MOSI: R82.1 R93.1 RA10.1 RF18.1 RF21.1 U4.BB29(SPI0_MOSI)
SPI_SCK: RF16.1 RF17.1 U4.BC31(SPI0_CLK)
SPI_TPM_CS2#: RF43.1 RF56.2 U4.AT31(SPI0_CS2#)
SPI_VDD1: CF22.2 RF54.1 RF55.1 UF1.8(VDD1)
SPI_VDD3: CF23.1 RF62.1 UF1.22(VHIO2)
SPKR: CA20.2 R20.1 R114.1 RA9.2
SRTCRST#_ICH: C1630.1 R6425.1 U4.BB10(SRTCRST_N)
SSD_SATA_DEVSLP3: RM5.1 U4.AB41(GPP_F5_DEVSLP3)
SUS_PWR_ACK#: PR12.2 PR391.2 U4.BB19(GPP_A15_SUSACK_N)
SUS_STAT_N: R19.1 U4.BC18(GPP_A14_SUS_STAT_N_ESPI_RST_N)
SUS_WARN#: PR12.1 R6663.1 RH6.1 RO19.1
SUSCLK_PCH: R6442.1 RF176.1 U4.AN15(GPD8_SUSCLK)
SUSCLK_SIO: R3.1 R6442.2 SIO_5553.19(CLK32)
SW_TPM: RS235.2 RS236.1 U4.BC33(GPP_H5_SRCCLKREQ11_N)
SYS_FAN_+12V: QF2.E(EMITTER) RF4.1 RF15.1 RF180.1
SYSTEM_FAN22: CF5.1 CF7.1 CF14.1 CF110.1 FAN_SYS.2(POWER) QF2.C(COLLECTOR) RF4.2 RF14.2
SYSTEM_FAN23: DF1.1(ANODE) FAN_SYS.3(GROUND) RF1.2 RF2.2
TCM_SIO_24M_TCM_R: CF109.1 RF179.2 UF3.3(Y0)
TCM_SIO_CLOCKI_R: CF108.1 RF178.1 UF3.8(Y1)
TCM_UF3_PIN2: RF77.2 UF3.2(1G)
THERMTRIP#_PCH: R6434.1 U4.AJ3(THERMTRIP_N)
TMIN_SHIFT: Q3.D(DRAIN) RO36.2 RO179.2 SIO_5553.33((TMIN_SHIFT) GP014)
TONSET_R: PC89.1 PR118.2 PR119.1
TONSETA: PR121.2 PU7.43(TONSETA)
TONSETA_R: PC90.1 PR120.2 PR121.1
TP_AJ24: CPU.AJ24(VCCEOPIO_SENSE) TPS72.1(TP)
TP_AK21: CPU.AK21(VCCOPC_SENSE) TPS8.1(TP)
TP_AK22: CPU.AK22(VSSOPC_EOPIO_SENSE) TPS9.1(TP)
TP_APU_RSVD_AC37: CPU.AC37(RSVD[7]) TPS29.1(TP)
TP_APU_RSVD_AU9: CPU.AU9(RSVD[3]) TPS25.1(TP)
TP_APU_RSVD_AU10: CPU.AU10(RSVD[6]) TPS28.1(TP)
TP_APU_RSVD_AU39: CPU.AU39(RSVD[5]) TPS27.1(TP)
TP_APU_RSVD_AU40: CPU.AU40(RSVD[4]) TPS26.1(TP)
TP_APU_RSVD_AV39: CPU.AV39(RSVD_TP[8]) TPS21.1(TP)
TP_APU_RSVD_AW38: CPU.AW38(RSVD_TP[9]) TPS22.1(TP)
TP_APU_RSVD_B39: CPU.B39(RSVD[2]) TPS24.1(TP)
TP_APU_RSVD_C40: CPU.C40(RSVD[22]) TPS101.1(TP)
TP_APU_RSVD_D15: CPU.D15(RSVD[20]) TPS99.1(TP)
TP_APU_RSVD_J11: CPU.J11(RSVD[17])
TP_APU_RSVD_J13: CPU.J13(RSVD[16])
TP_APU_RSVD_J14: CPU.J14(RSVD[15]) TPS96.1(TP)
TP_APU_RSVD_J15: CPU.J15(RSVD[14]) TPS95.1(TP)
TP_APU_RSVD_J17: CPU.J17(RSVD[1])
TP_APU_RSVD_J19: CPU.J19(RSVD[21])
TP_APU_RSVD_K10: CPU.K10(RSVD[13]) TPS94.1(TP)
TP_APU_RSVD_K11: CPU.K11(RSVD[12])
TP_APU_RSVD_K12: CPU.K12(RSVD[11]) TPS103.1(TP)
TP_APU_RSVD_K13: CPU.K13(RSVD[10])
TP_APU_RSVD_L10: CPU.L10(RSVD[9]) TPS30.1(TP)
TP_APU_RSVD_L12: CPU.L12(RSVD[8]) TPS102.1(TP)
TP_APU_RSVD_TP_AV1: CPU.AV1(RSVD_TP[1]) TPS14.1(TP)
TP_APU_RSVD_TP_AW2: CPU.AW2(RSVD_TP[0]) TPS13.1(TP)
TP_APU_RSVD_TP_H11: CPU.H11(RSVD_TP[7]) TPS20.1(TP)
TP_APU_RSVD_TP_H12: CPU.H12(RSVD_TP[6]) TPS19.1(TP)
TP_APU_RSVD_TP_J7: CPU.J7(RSVD_TP[5])
TP_APU_RSVD_TP_J8: CPU.J8(RSVD_TP[4])
TP_APU_RSVD_TP_K8: CPU.K8(RSVD_TP[3]) TPS105.1(TP)
TP_APU_RSVD_TP_L8: CPU.L8(RSVD_TP[2])
TP_APU_ZVM#: CPU.AC38(ZVM#) TPS44.1(TP)
TP_BPM#2: CPU.G14(BPM#[2]) TPS42.1(TP)
TP_BPM#3: CPU.H14(BPM#[3]) TPS43.1(TP)
TP_EDP_DISP: CPU.D14(EDP_DISP_UTIL) TPS45.1(TP)
TP_F36: CPU.F36(VSSGTX_SENSE) TPS110.1(TP)
TP_F37: CPU.F37(VCCGTX_SENSE) TPS109.1(TP)
TP_GPP_D4_ISH_I2C2_SDA: TPS128.1(TP) U4.AM44(GPP_D4_ISH_I2C2_SDA)
TP_GPP_D14_ISH_UART0_TXD: TPS129.1(TP) U4.AK44(GPP_D14_ISH_UART0_TXD)
TP_GPP_D18_DMIC_DATA1: TPS130.1(TP) U4.AJ38(GPP_D18_DMIC_DATA1)
TP_GPP_D19_DMIC_CLK0: TPS131.1(TP) U4.AJ35(GPP_D19_DMIC_CLK0)
TP_GPP_H15_SML3ALERT_N: TPS132.1(TP) U4.BB36(GPP_H15_SML3ALERT_N)
TP_GPP_H18_SML4ALERT_N: TPS133.1(TP) U4.BC36(GPP_H18_SML4ALERT_N)
TP_PCH_B19: TPS127.1(TP) U4.B19(PETN2 / USB3TN8)
TP_PCH_B20: TPS123.1(TP) U4.B20(PETN3 / USBTN9)
TP_PCH_C19: TPS126.1(TP) U4.C19(PETP2 / USB3TP8)
TP_PCH_C20: TPS122.1(TP) U4.C20(PETP3 / USBTP9)
TP_PCH_E17: TPS125.1(TP) U4.E17(PERN2 / USB3RN8)
TP_PCH_G17: TPS124.1(TP) U4.G17(PERP2 / USB3RP8)
TP_PCH_K17: TPS120.1(TP) U4.K17(PERP3 / USB3RP9)
TP_PCH_L17: TPS121.1(TP) U4.L17(PERN3 / USB3RN9)
TP_PCH_RSVD0: TPS73.1(TP) U4.BE2(RSVD<0>)
TP_PCH_RSVD1: TPS74.1(TP) U4.BD1(RSVD<1>)
TP_PCH_RSVD2: TPS75.1(TP) U4.AR22(RSVD<2>)
TP_PCH_RSVD3: TPS76.1(TP) U4.AN29(RSVD<3>)
TP_PCH_RSVD4: TPS77.1(TP) U4.AG15(RSVD<4>)
TP_PCH_RSVD5: TPS78.1(TP) U4.AG14(RSVD<5>)
TP_PCH_RSVD6: TPS79.1(TP) U4.AF17(RSVD<6>)
TP_PCH_RSVD7: TPS80.1(TP) U4.AE17(RSVD<7>)
TP_PCH_RSVD8: TPS81.1(TP) U4.AB13(RSVD<8>)
TP_PCH_RSVD9: TPS82.1(TP) U4.W13(RSVD<9>)
TP_PCH_RSVD10: TPS83.1(TP) U4.U13(RSVD<10>)
TP_PCH_RSVD11: TPS84.1(TP) U4.R27(RSVD<11>)
TP_PCH_RSVD12: TPS85.1(TP) U4.R24(RSVD<12>)
TP_PCH_RSVD13: TPS86.1(TP) U4.P31(RSVD<13>)
TP_PCH_RSVD14: TPS87.1(TP) U4.P29(RSVD<14>)
TP_PCH_RSVD15: TPS88.1(TP) U4.P27(RSVD<15>)
TP_PCH_RSVD16: TPS89.1(TP) U4.P24(RSVD<16>)
TP_PCH_RSVD17: TPS90.1(TP) U4.N31(RSVD<17>)
TP_PCH_RSVD18: TPS91.1(TP) U4.N29(RSVD<18>)
TP_PCH_TP4: TPS70.1(TP) U4.AN17(TP4)
TP_PCH_TP5: TPS71.1(TP) U4.AR19(TP5)
TP_SIO_GP054: SIO_5553.106(GP054) TPS5.1(TP)
TPM_BADD: RF30.1 UF1.6(GPIO3/BADD)
TPM_CLK: RF37.2 UF1.19(LCLK/SCLK)
TPM_CS2_LFRAM#_R: RF28.2 UF1.20(L\F\R\A\M\E\/S\C\S\)
TPM_PP: RF25.2 RF26.1 UF1.4(PP)
TPM_QF1_G: QF1.G(GATE) RF33.2
TPM_RST_N: QF1.S(SOURCE) RF32.2 RF34.1 UF1.17(L\R\E\S\E\T\/S\P\I\_\R\S\T\/S\R)
TPM_SERIRQ: RF29.2 UF1.27(SERIRQ)
TPM_SPIIRQ: RF27.2 RF45.1
TPM_TCM_CS: RS233.2 RS234.1 U4.BA33(GPP_H6_SRCCLKREQ12_N)
TPM_VDD2: CF24.2 RF53.2 UF1.14(VHIO1)
TSEN: PR163.1 PRT3.2 PU7.1(TSEN)
TSEN_R1: PR159.1 PRT3.1
TSEN_R2: PR162.1 PR163.2
TSENA: PR164.2 PRT4.2 PU7.42(TSENA)
TSENA_R1: PR165.1 PRT4.1
TSENA_R2: PR164.1 PR166.2
U_USB1N_R: F_USB3.2(D-_1) LU36.2 RU54.2 UU9.4(I/O_3)
U_USB1P_R: F_USB3.3(D+_1) LU36.1 RU55.2 UU9.6(I/O_4)
U_USB2N_R: F_USB3.11(D-_2) LU37.1 RU58.2 UU9.3(I/O_2)
U_USB2P_R: F_USB3.12(D+_2) LU37.2 RU59.2 UU9.1(I/O_1)
U_USB3N_R: LU4.4 RU13.2 SSUSB_R.2(D-_1) UU3.1(I/O_1)
U_USB3P_R: LU4.3 RU15.2 SSUSB_R.3(D+_1) UU3.3(I/O_2)
U_USB4N_R: LU2.2 NIC_USB.6(D-(2)) RU120.1 UU1.4(I/O_3)
U_USB4P_R: LU2.1 NIC_USB.7(D+(2)) RU5.1 UU1.6(I/O_4)
U_USB5N_R: LU1.1 NIC_USB.2(D-(1)) RU3.1 UU1.3(I/O_2)
U_USB5P_R: LU1.2 NIC_USB.3(D+(1)) RU4.1 UU1.1(I/O_1)
U_USB6N_R: LU23.4 RU62.2 UU13.1(I/O_1) WF_BT_USB.3
U_USB6P_R: LU23.3 RU63.2 UU13.3(I/O_2) WF_BT_USB.5
U_USB7N_R: LU35.3 RU10.2 SSUSB_R.11(D-_2) UU3.6(I/O_4)
U_USB7P_R: LU35.4 RU12.2 SSUSB_R.12(D+_2) UU3.4(I/O_3)
U_USB8N_R: LU24.3 RU67.2 UU13.6(I/O_4) WF_BT_USB.4
U_USB8P_R: LU24.4 RU66.2 UU13.4(I/O_3) WF_BT_USB.6
UEFI_S: R6668.2 U4.N43(GPP_G18_NMI_N) UEFI.1
USB2_ID: R6602.1 U4.AG2(USB2_ID)
USB3_RXDN1: F_USB3.5(STDA_SSRX-_1) U4.B7(USB3RN1) UU26.2(CH2) UU26.9(NC2)
USB3_RXDN2: F_USB3.14(STDA_SSRX-_2) U4.C8(USB3RN2) UU10.2(CH2) UU10.9(NC2)
USB3_RXDN3: SSUSB_R.5(STDA_SSRX-_1) U4.B10(USB3RN3) UU7.2(CH2) UU7.9(NC2)
USB3_RXDN4: SSUSB_R.14(STDA_SSRX-_2) U4.E11(USB3RN4) UU7.4(CH3) UU7.7(NC3)
USB3_RXDP1: F_USB3.6(STDA_SSRX+_1) U4.A7(USB3RP1) UU26.1(CH1) UU26.10(NC1)
USB3_RXDP2: F_USB3.15(STDA_SSRX+_2) U4.B8(USB3RP2) UU10.1(CH1) UU10.10(NC1)
USB3_RXDP3: SSUSB_R.6(STDA_SSRX+_1) U4.A9(USB3RP3) UU7.1(CH1) UU7.10(NC1)
USB3_RXDP4: SSUSB_R.15(STDA_SSRX+_2) U4.G11(USB3RP4) UU7.5(CH4) UU7.6(NC4)
USB3_TX1_PCH_DN_C: CO44.1 F_USB3.8(STDA_SSTX-_1) UU26.5(CH4) UU26.6(NC4)
USB3_TX1_PCH_DP_C: CO43.1 F_USB3.9(STDA_SSTX+_1) UU26.4(CH3) UU26.7(NC3)
USB3_TX2_PCH_DN_C: CO45.1 F_USB3.17(STDA_SSTX-_2) UU10.4(CH3) UU10.7(NC3)
USB3_TX2_PCH_DP_C: CO46.1 F_USB3.18(STDA_SSTX+_2) UU10.5(CH4) UU10.6(NC4)
USB3_TX3_PCH_DN_C: CO26.2 SSUSB_R.8(STDA_SSTX-_1) UU6.4(CH3) UU6.7(NC3)
USB3_TX3_PCH_DP_C: CO25.2 SSUSB_R.9(STDA_SSTX+_1) UU6.5(CH4) UU6.6(NC4)
USB3_TX4_PCH_DN_C: CO28.2 SSUSB_R.17(STDA_SSTX-_2) UU6.1(CH1) UU6.10(NC1)
USB3_TX4_PCH_DP_C: CO27.2 SSUSB_R.18(STDA_SSTX+_2) UU6.2(CH2) UU6.9(NC2)
USB3_TXDN1: CO44.2 U4.C11(USB3TN1)
USB3_TXDN2: CO45.2 U4.B12(USB3TN2)
USB3_TXDN3: CO26.1 U4.C13(USB3TN3)
USB3_TXDN4: CO28.1 U4.A14(USB3TN4)
USB3_TXDP1: CO43.2 U4.B11(USB3TP1)
USB3_TXDP2: CO46.2 U4.A12(USB3TP2)
USB3_TXDP3: CO25.1 U4.D13(USB3TP3)
USB3_TXDP4: CO27.1 U4.B13(USB3TP4)
USB_N9G_R: F_USB2.2 UL19.1 UR57.2 UU4.6(I/O_4)
USB_N10G_R: F_USB2.6 UL5.2 UR13.2 UU4.1(I/O_1)
USB_P9G_R: F_USB2.3 UL19.2 UR58.2 UU4.4(I/O_3)
USB_P10G_R: F_USB2.7 UL5.1 UR14.2 UU4.3(I/O_2)
USBPWR0_F_50: CU10.1 CU11.1 ECU6.1 ECU7.1 F_USB3.1(VBUS_1) F_USB3.10(VBUS_2) FU6.2 RU147.1 UU9.5(VDD)
USBPWR1_F_50: CU2.1 CU3.1 ECU2.1 ECU3.1 FU2.2 RU26.1 SSUSB_R.1(VBUS_1) SSUSB_R.10(VBUS_2) UU3.5(VDD)
USBPWR4_F_50: CU79.1 ECU10.1 F_USB2.1 F_USB2.5 FU5.1 RU134.1 UU4.5(VDD)
USBPWR5_F_50: CU14.1 ECU9.1 FU9.1 RU69.2 UU13.5(VDD) WF_BT_USB.1 WF_BT_USB.2
V_BLUE_R: CG8.1 DG2.3(CATH1ANOD2) LG1.2 VGA_COM.B3(3)
V_GPI_VGA_CBL_DET#: RG23.2 U4.BB33(GPP_H8_SRCCLKREQ14_N)
V_GREEN_R: CG10.1 DG3.3(CATH1ANOD2) LG2.2 VGA_COM.B2(2)
V_HDMI_CLK_DN: CV39.2 HDMI.12(CK-) RV74.1
V_HDMI_CLK_DP: CV38.2 HDMI.10(CK+) RV73.1
V_HDMI_SCL: C558.1 HDMI.15(SCL) RV76.2 UV7.1(CH1) UV7.10(NC1)
V_HDMI_SDA: CV42.1 HDMI.16(SDA) RV85.2 UV7.2(CH2) UV7.9(NC2)
V_HDMI_TX0_DN: CV37.2 HDMI.9(D0-) RV72.1
V_HDMI_TX0_DP: CV36.2 HDMI.7(D0+) RV49.1
V_HDMI_TX1_DN: CV35.2 HDMI.6(D1-) RV48.2
V_HDMI_TX1_DP: CV34.2 HDMI.4(D1+) RV45.2
V_HDMI_TX2_DN: CV33.2 HDMI.3(D2-) RV46.2
V_HDMI_TX2_DP: CV32.2 HDMI.1(D2+) RV47.2
V_HSYNC_5V_R: CG14.1 DG8.3(CATH1ANOD2) RG18.2 VGA_COM.B13(13)
V_RED_R: CG12.1 DG1.3(CATH1ANOD2) LG3.2 VGA_COM.B1(1)
V_VSYNC_5V_R: CG13.1 DG7.3(CATH1ANOD2) RG19.2 VGA_COM.B14(14)
VCORE_EN: PC2.1 PQ3.D1 PR198.2 PU7.27(EN) PU13.1(PGOOD)
VCORE_EN_FREQUENCE: PQ3.G1 PQ3.G2 PQ4.D1 PQ4.G2 PR15.1
VCORE_HSN_1: PC107.2 PR167.1
VCORE_HSN_2: PC114.2 PR176.1
VCORE_HSN_3: PC122.2 PR179.1
VCORE_PG: PQ4.D2 PR141.2 PU7.54(PGOOD) QO1.1(EMITTER) RX199.2 RX201.2
VCORE_PG_R: R6427.1 RX199.1 RX202.1 U4.AY1(SYS_PWROK)
VCT: CL23.1 NIC_USB.9(VCC)
VGA_5V_DDC_R: DG5.2(CATHODE2) DG6.2(CATHODE2) DG7.2(CATHODE2) DG8.2(CATHODE2) RG24.1
VGA_BLUE_P: CG7.1 LG1.1 RG15.1 RTK_VGA.10(BLUE_P)
VGA_GREEN_P: CG9.1 LG2.1 RG16.1 RTK_VGA.12(GREEN_P)
VGA_HSYNC: RG18.1 RTK_VGA.8(HSYNC)
VGA_PRX_PIN28: RG27.1 RTK_VGA.28(RRX)
VGA_RED_P: CG11.1 LG3.1 RG17.1 RTK_VGA.15(RED_P)
VGA_RGB_CV: DG1.2(CATHODE2) DG2.2(CATHODE2) DG3.2(CATHODE2) RG25.1
VGA_SCL: DG5.3(CATH1ANOD2) RG20.2 RTK_VGA.4(VGA_SCL) VGA_COM.B15(15)
VGA_SDA: DG6.3(CATH1ANOD2) RG21.2 RTK_VGA.6(VGA_SDA) VGA_COM.B12(12)
VGA_V_GPI_VGA_CBL_DET#_R: CG16.1 RG22.2 RG23.1 VGA_COM.B4(4)
VGA_VSYNC: RG19.1 RTK_VGA.7(VSYNC)
VGAPWR_F_20: CG15.2 FG1.2 VGA_COM.B9(9)
VGT_BOOT1_20: PC153.1 PU11.1(BOOT)
VGT_BOOT1_RC_20: PC153.2 PR188.1
VGT_BOOT2_20: PC173.1 PU12.1(BOOT)
VGT_BOOT2_RC_20: PC173.2 PR194.1
VGT_LG1_R_30: PQ39.4(G) PQ40.4(G) PU11.5(LGATE)
VGT_LG2_R_30: PQ42.4(G) PQ43.4(G) PU12.5(LGATE)
VGT_PHASE1_20: PC155.1 PJP15.1 PL9.1 PQ38.1(S1) PQ38.2(S2) PQ38.3(S3) PQ39.5(D1) PQ40.5(D1) PR185.2 PR188.2 PR189.2 PU11.7(PHASE)
VGT_PHASE2_20: PC175.1 PJP17.1 PL10.1 PQ41.1(S1) PQ41.2(S2) PQ41.3(S3) PQ42.5(D1) PQ43.5(D1) PR192.2 PR194.2 PR195.2 PU12.7(PHASE)
VGT_SN1_20: PC155.2 PR190.1
VGT_SN2_20: PC175.2 PR196.1
VGT_UG1_20: PR186.1 PU11.8(UGATE)
VGT_UG1_R_20: PQ38.4(G) PR186.2 PR189.1
VGT_UG2_20: PR191.1 PU12.8(UGATE)
VGT_UG2_R_20: PQ41.4(G) PR191.2 PR195.1
VGT_VCC1_20: PC154.1 PR187.1 PU11.4(VCC)
VGT_VCC2_20: PC174.1 PR193.1 PU12.4(VCC)
VIDALERT_#: CPU.E39(VIDALERT#) R2.2
VIDSCLK: CPU.E38(VIDSCLK) R6578.2
VIDSOUT: CPU.E40(VIDSOUT) R6577.2
VISACH1_D2_PCH_GPP_E_5: U4.AG43(GPP_E5_DEVSLP1) XDP_PCH.27(OBSDATA_B0)
VISACH1_D2_PCH_GPP_E_6: U4.AE45(GPP_E6_DEVSLP2) XDP_PCH.29(OBSDATA_B1)
VPP_PG: PQ16.G(GATE) PQ79.3(COLLECTOR) PR358.1 PR381.2
VR_HOT: PR69.1 PU7.23(V\R\_\H\O\T\) R52.2 R6523.2 R6576.1
VR_HOT_1V: CPU.C39(PROCHOT#) R6576.2
VRALERT_N: R6413.2 U4.BD23(GPP_B2_VRALERT_N)
VREF_R: PR124.1 PR125.1
VREF_RA: PR133.1 PR134.1
VREF_RC: PC94.1 PR127.2
VREG_PD33: BRIDGE.D12(VREG_PD33) RK31.2
VRM_ALERT#: PR132.1 PR140.1 R2.1 R7.2
VRM_ALERT#_R: PR140.2 PU7.24(A\L\E\R\T\)
VRM_BOOT1_20: PC109.1 PU8.1(BOOT)
VRM_BOOT1_RC_20: PC109.2 PR170.1
VRM_BOOT2_20: PC116.1 PU9.1(BOOT)
VRM_BOOT2_RC_20: PC116.2 PR175.1
VRM_BOOT3_20: PC123.1 PU10.1(BOOT)
VRM_BOOT3_RC_20: PC123.2 PR181.1
VRM_COMP: PC97.2 PR144.1 PU7.11(COMP)
VRM_DVD: PC83.1 PR91.2 PR92.1 PU7.45(DVD)
VRM_FB: PC96.2 PC97.1 PR142.2 PR143.1 PU7.10(FB)
VRM_IBIAS: PR122.2 PU7.31(IBIAS)
VRM_LG1_R_30: PQ30.4(G) PQ31.4(G) PU8.5(LGATE)
VRM_LG2_R_30: PQ33.4(G) PQ34.4(G) PU9.5(LGATE)
VRM_LG3_R_30: PQ36.4(G) PQ37.4(G) PU10.5(LGATE)
VRM_PHASE1_20: PC111.1 PJP9.1 PL5.1 PQ29.1(S1) PQ29.2(S2) PQ29.3(S3) PQ30.5(D1) PQ31.5(D1) PR167.2 PR170.2 PR171.2 PU8.7(PHASE)
VRM_PHASE2_20: PC119.1 PJP11.1 PL7.1 PQ32.1(S1) PQ32.2(S2) PQ32.3(S3) PQ33.5(D1) PQ34.5(D1) PR175.2 PR176.2 PR177.2 PU9.7(PHASE)
VRM_PHASE3_20: PC125.1 PJP13.1 PL8.1 PQ35.1(S1) PQ35.2(S2) PQ35.3(S3) PQ36.5(D1) PQ37.5(D1) PR179.2 PR181.2 PR183.2 PU10.7(PHASE)
VRM_PWM1_10: PU7.52(PWM1) PU8.2(PWM)
VRM_PWM2_10: PU7.51(PWM2) PU9.2(PWM)
VRM_PWM3_10: PU7.53(PWM3) PU10.2(PWM)
VRM_RGND: PC99.1 PC100.1 PR146.2 PR148.2 PU7.13(RGND)
VRM_SCLK: PR130.2 PR138.1 R9.2 R6578.1
VRM_SCLK_R: PR138.2 PU7.26(VCLK)
VRM_SDIO: PR131.1 PR139.1 R8.2 R6577.1
VRM_SDIO_R: PR139.2 PU7.25(VDIO)
VRM_SET1: PR105.2 PR108.2 PU7.14(SET1)
VRM_SET1_R: PR97.2 PR105.1
VRM_SET1_RR: PR107.2 PR108.1
VRM_SET2: PR104.2 PR110.2 PU7.15(SET2)
VRM_SET2_R: PR96.2 PR104.1
VRM_SET2_RR: PR109.2 PR110.1
VRM_SET3: PR99.2 PR112.2 PU7.17(SET3)
VRM_SET3_R: PR95.2 PR99.1
VRM_SET3_RR: PR111.2 PR112.1
VRM_SETA1: PR103.2 PR114.2 PU7.18(SETA1)
VRM_SETA1_R: PR94.2 PR103.1
VRM_SETA1_RR: PR113.2 PR114.1
VRM_SETA2: PR100.2 PR102.2 PU7.19(SETA2)
VRM_SETA2_R: PR93.2 PR102.1
VRM_SETA2_RR: PR100.1 PR115.2
VRM_SN1_20: PC111.2 PR172.1
VRM_SN2_20: PC119.2 PR178.1
VRM_SN3_20: PC125.2 PR184.1
VRM_TON: PR119.2 PU7.55(TONSET)
VRM_UG1_20: PR168.1 PU8.8(UGATE)
VRM_UG1_R_20: PQ29.4(G) PR168.2 PR171.1
VRM_UG2_20: PR173.1 PU9.8(UGATE)
VRM_UG2_R_20: PQ32.4(G) PR173.2 PR177.1
VRM_UG3_20: PR182.1 PU10.8(UGATE)
VRM_UG3_R_21: PQ35.4(G) PR182.2 PR183.1
VRM_VCC: PC84.2 PR98.1 PU7.29(VCC)
VRM_VCC1_20: PC110.1 PR169.1 PU8.4(VCC)
VRM_VCC2_20: PC117.1 PR174.1 PU9.4(VCC)
VRM_VCC3_20: PC124.1 PR180.1 PU10.4(VCC)
VRM_VREF: PR93.1 PR94.1 PR95.1 PR96.1 PR97.1 PR124.2 PR127.1 PR133.2 PRT1.1 PRT2.1 PU7.21(VREF)
VRM_VSEN: PC96.1 PC99.2 PR142.1 PR149.2 PR150.2 PU7.12(VSEN)
WAKE#_L: BRIDGE.M13(WAKE#) RK9.2
WAKE_SLOT1_N: RP40.1 SLOT1.B11(W\A\K\E\) U4.AG42(GPP_E4_DEVSLP0) XDP_PCH.17(OBSDATA_A3)
WAKE_SLOT_M2_N: R112.1 RM4.1 U4.AF41(GPP_E3_CPU_GP0) XDP_PCH.15(OBSDATA_A2)
X1_SMBCLK_R: RX19.2 SLOT2.B5(SMCLK)
X1_SMBDATA_R: RX20.2 SLOT2.B6(SMDAT)
X1_TCLK: RX18.2 SLOT2.B9(TRST#)
X1_TDI: RX16.2 SLOT2.A6(TDI)
X1_TRST: RX17.2 SLOT2.A5(TCK)
X16_RST_SLOT_PEG#: RX182.1 UX1.2(A)
X16_RST_SLOT_PEG#_R: RX182.2 U1.4(Y)
X16_SMBCLK_R: RX175.2 SLOT1.B5(SMCLK)
X16_SMBDATA_R: RX176.2 SLOT1.B6(SMDAT)
X16_TCLK: RNX4.5 SLOT1.B9(TRST#)
X16_TDI: RNX4.7 SLOT1.A6(TDI)
X16_TMS: RNX4.6 SLOT1.A8(TMS)
X16_TRST: RNX4.8 SLOT1.A5(TCK)
X16_X_RST_SLOT_PEG#_R: RX6.1 RX7.1 SLOT1.A11(P\E\R\S\T\)
X_EXP_A_TX_C_DN0: CX16.2 SLOT1.B15(PETN0)
X_EXP_A_TX_C_DN1: CX17.2 SLOT1.B20(PETN1)
X_EXP_A_TX_C_DN2: CX23.2 SLOT1.B24(PETN2)
X_EXP_A_TX_C_DN3: CX26.2 SLOT1.B28(PETN3)
X_EXP_A_TX_C_DN4: CX28.2 SLOT1.B34(PETN4)
X_EXP_A_TX_C_DN5: CX30.2 SLOT1.B38(PETN5)
X_EXP_A_TX_C_DN6: CX32.2 SLOT1.B42(PETN6)
X_EXP_A_TX_C_DN7: CX34.2 SLOT1.B46(PETN7)
X_EXP_A_TX_C_DN8: CX36.2 SLOT1.B51(PETN8)
X_EXP_A_TX_C_DN9: CX38.2 SLOT1.B55(PETN9)
X_EXP_A_TX_C_DN10: CX98.2 SLOT1.B59(PETN10)
X_EXP_A_TX_C_DN11: CX42.2 SLOT1.B63(PETN11)
X_EXP_A_TX_C_DN12: CX44.2 SLOT1.B67(PETN12)
X_EXP_A_TX_C_DN13: CX46.2 SLOT1.B71(PETN13)
X_EXP_A_TX_C_DN14: CX99.2 SLOT1.B75(PETN14)
X_EXP_A_TX_C_DN15: CX101.2 SLOT1.B79(PETN15)
X_EXP_A_TX_C_DP0: CX15.2 SLOT1.B14(PETP0)
X_EXP_A_TX_C_DP1: CX21.2 SLOT1.B19(PETP1)
X_EXP_A_TX_C_DP2: CX22.2 SLOT1.B23(PETP2)
X_EXP_A_TX_C_DP3: CX24.2 SLOT1.B27(PETP3)
X_EXP_A_TX_C_DP4: CX27.2 SLOT1.B33(PETP4)
X_EXP_A_TX_C_DP5: CX29.2 SLOT1.B37(PETP5)
X_EXP_A_TX_C_DP6: CX31.2 SLOT1.B41(PETP6)
X_EXP_A_TX_C_DP7: CX33.2 SLOT1.B45(PETP7)
X_EXP_A_TX_C_DP8: CX35.2 SLOT1.B50(PETP8)
X_EXP_A_TX_C_DP9: CX37.2 SLOT1.B54(PETP9)
X_EXP_A_TX_C_DP10: CX39.2 SLOT1.B58(PETP10)
X_EXP_A_TX_C_DP11: CX41.2 SLOT1.B62(PETP11)
X_EXP_A_TX_C_DP12: CX43.2 SLOT1.B66(PETP12)
X_EXP_A_TX_C_DP13: CX45.2 SLOT1.B70(PETP13)
X_EXP_A_TX_C_DP14: CX47.2 SLOT1.B74(PETP14)
X_EXP_A_TX_C_DP15: CX100.2 SLOT1.B78(PETP15)
X_PCI1_ACK64#_R: RK50.2 SLOT4.B60(ACK64#)
X_PCI1_K_AD17_R: RK55.1 SLOT4.A26(IDSEL)
X_PCI1_REQ64#_R: RK54.1 SLOT4.A60(REQ64#)
X_PCI1_SMBCLK_R: RK51.1 SLOT4.A40(SDONE)
X_PCI1_SMBDATA_R: RK52.1 SLOT4.A41(SBO#)
X_PCI_ACK64#_B60: RK4.2 SLOT3.B60(ACK64#)
X_PCI_REQ64#_A60: RK5.1 SLOT3.A60(REQ64#)
X_PCI_SMBCLK_R: RK10.1 SLOT3.A40(SDONE)
X_PCI_SMBDATA_R: RK19.1 SLOT3.A41(SBO#)
X_PLTRST_PCIE_SLOT#: CX54.1 M.2_SSD.50(PE_RST#) RO13.2 RO166.1 RO188.2 RX6.2 SLOT2.A11(P\E\R\S\T\)
X_RST_SLOT_PEG#: RX7.2 RX181.2
X_RST_SLOT_PEG#_R: RX181.1 UX1.4(Y)
XCLK_RCOMP: R6464.2 U4.E1(XCLK_BIASREF)
XDP_CPU_HOOK6: R96.1 RH1.1 RH2.1 RS16.1 RS169.1
XDP_CPU_HOOK6_R: R87.2 R96.2 XDP_CPU.46(HOOK6/RESET#)
XDP_FP_RST#: C75.2 R6659.2 XDP_CPU.48(HOOK7/DBR#)
XDP_HOOK2: R6682.2 RX21.2 XDP_CPU.45(HOOK2)
XDP_PCH_JTAGX: RS225.1 RS227.2 U4.AR3(JTAGX)
XDP_PRESENT#_CPU: R97.2 R6681.1 XDP_CPU.1(VSS1)
XDP_PRESENT#_R: R102.2 R121.1 XDP_CPU.60(VSS18/XDP_PRESENT#)
XDP_PWRBTN_OUT#: C74.2 R88.2 R92.2 XDP_CPU.41(HOOK1)
XDP_RSMRST#: R89.2 XDP_CPU.39(HOOK0)
XDP_SPI_MOSI: R86.2 R93.2 XDP_CPU.47(HOOK3)
XTAL_24M_IN: C1642.1 R6469.1 U4.A6(XTAL24_IN) Y1.3
XTAL_24M_OUT: C1643.1 R6469.2 U4.A5(XTAL24_OUT) Y1.1
XTAL_IN: CL36.1 RTK_LAN.28(CKXTAL1) XL1.2
XTAL_OUT: RL12.1 RTK_LAN.29(CKXTAL2)
XTAL_OUT_R: CL35.1 RL12.2 XL1.1
N120560027: M.2_SSD.53(REFCLKN) RM15.2
N120560030: M.2_SSD.55(REFCLKP) RM16.2
N120811996: Q3.G(GATE) RO188.1
N120812085: QV22.G(GATE) RI1.1
N120812204: Q99.G(GATE) RI2.1
N120812265: Q104.G(GATE) RI3.1
N120812340: QV49.G(GATE) RI4.1
N120964019: HDD_LED.1(LED+) RIO11.2
N121283078: CA17.1 UA1.12(PCBEEP)
N121341151: RH9.2 U4.U41(GPP_G2_FAN_TACH_2)
N121341154: RH10.2 U4.M44(GPP_G3_FAN_TACH_3)
N121428079: NIC_USB.18(GND0) RL44.2
N121488357: RG31.1 RG32.2 RTK_VGA.18(XO)
N121515008: QF2.B(BASE) RF12.2 RF15.2
N121515022: RF13.1 RF14.1 UF147.3(+IN)
N121515024: CF6.1 RF11.2 UF147.2(-IN)
N121515291: UF147.6(-IN) UF147.7(OUT)
N121515335: RF12.1 UF147.1(OUT)

Pads without a net: APS/PETS 7; BRIDGE A7 A9 A10 A11 B7 B8 B9 B10 M9 N9 N10 N11 N13; CPU A12 A14 A16 A18 AL15 AL25 AL26 AM15 AM25 AM26 AN17 AN20 AN21 AN25 AN26 AP15 AP19 AP20 AP25 AP26 AR25 AR26 AT16 AT33 AU12 AU16 AU29 AU31 AU32 AU33 AV10 AV13 AV16 AV24 AV25 AV31 AV32 AV33 AW16 AW29 AW31 AW33 AY10 AY31 B11 B12 B13 B14 B15 B16 B17 B18 C9 C11 C13 C15 C17 C19 D9 D10 D18 D19 D20 E10 E18 E20; D5 1; DIMM1 1 8 19 30 41 47 49 52 54 56 93 100 111 122 133 144 145 192 194 196 197 199 201 205 227 230 234 235 237; DIMM2 1 8 19 30 41 47 49 52 54 56 93 100 111 122 133 144 145 192 194 196 197 199 201 205 227 230 234 235 237; FM1 1; FM2 1; FM3 1; FM4 1; FM5 1; FM7 1; HDMI 13 14; KYBD_MOUSE 2 6 8 12; M.2_SSD 5 6 7 8 11 13 17 19 20 22 23 24 25 26 28 29 30 31 32 34 35 36 37 40 42 44 46 48 56 58 67 68; MH1 1 2 3 4 5 6 7 8 9 10; PPID 1; PR51 2; PR75 1; PR210 2; PR268 2; PR271 2; PR283 2; PU3 5 7 8; PU7 16 28 30 44 48 49 50 56; PU8 3; PU9 3; PU10 3; PU11 3; PU12 3; RNO2 1; RS232 1; RTK_VGA 17; SIO_5553 5 6 13 39 49 61 62 63 64 67 70 72 76 84 85 87 89 93 95 105 107 110 112; SLOT1 A7 A19 A32 A33 A50 B12 B30 B82; SLOT2 A7 A8 B12; SLOT3 A9 A11 B4 B9 B10 B11 B14; SLOT4 A9 A11 B4 B9 B10 B11 B14; U4 A16 A21 A35 AA44 AA45 AB33 AB35 AB39 AB42 AB43 AD2 AD3 AG44 AH43 AH44 AJ11 AJ13 AJ39 AJ42 AJ43 AJ44 AK45 AL27 AL35 AL36 AL39 AL42 AL43 AL44 AM43 AN24 AN36 AN38 AN41 AN42 AN44 AR17 AR27 AR29 AR31 AR38 AR39 AR41 AR44 AR45 AT33 AT42 AT43 AT44 AU41 AU43 AU44 AV4 AV15 AV29 AV43 AV44 AW24 AW27 AW31 AW33 AW35 AY2 AY44 B14 B15 B16 B21 B24 B31 B32 B33 B35 BA35 BA41 BB3 BB22 BB24 BB31 BB38 BB39 BC8 BC19 BC22 BC24 BC27 BC32 BC38 BD6 BD18 BD21 BD22 BD24 BD27 BD32 BD33 BD34 BD36 BD38 BD39 BE5 BE6 BE11 BE21 BE34 BE39 C14 C15 C24 C31 C32 C33 D5 D7 D8 E6 E20 E29 E45 F45 G13 G15 G19 G29 G31 G33 G37 G44 G45 H13 H15 H31 H33 H40 H42 H43 H44 J45 K13 K15 K24 K31 K37 K44 L5 L7 L24 L31 L37 L39 M45 N2 N3 N7 N8 N38 N39 P1 P43 R2 R7 R8 R11 R13 R35 R39 R41 R42 R44 T44 U2 U3 U5 U7 U42 U43 V1 V2 W2 W3 W7 W35 W36 W42 Y5; UA1 2 3 15 16 44 45 48; UF1 2 5 7 10 11 12 13 15 25 26 28 30 31; UF2 1 2 3 4 5 6 7 8 10 12 13 14 15 17 28 29 30 31; UF3 5 7; US1_1 1; UV7 5 6; UX1 1; XDP_PCH 3 5 21 22 23 24 40 41 42 45 46 47 48 51 52 53 54 55 56 57 58

## Via types
v1: diameter 0.508, hole 0.254, TOP to BOTTOM, 6278 vias
v2: diameter 0.762, hole 0.381, TOP to BOTTOM, 462 vias
v3: diameter 0.559, hole 0.305, TOP to BOTTOM, 760 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
3V_5V_PWROK: length 297.7
  TOP w0.102: v1(134.91,32.89) 134.84,32.89 133.98,33.75 133.98,34.56 133.02,35.53 132.21,35.53 122.58,45.15 122.02,45.15 121,46.16 v1(121,47.82) ; v1(11.59,78.23) 10.9,78.23 8.72,76.05 5.79,76.05 3.87,74.12 3.87,46.27 PR337.2 ; RO174.2 205.98,38.1 205.47,37.59 204.76,37.59 v1(204.38,37.21)
  BOTTOM w0.102: v1(121,47.82) 121.55,48.36 134.91,48.36 135.49,48.95 152.95,48.95 156.34,45.55 164.64,45.55 165.65,46.56 171.48,46.56 v2(172.85,47.93) 173.87,48.95 188.72,48.95 200.46,37.21 v1(204.38,37.21) ; v1(134.91,32.89) 134.34,32.33 130.9,32.33 130.16,33.07 117.5,33.07 117.25,32.82 99.16,32.82 91.17,40.81 89.8,40.81 83.9,46.71 82.21,46.71 79.01,49.91 72.59,49.91 67.12,55.38 61.63,55.38 61.07,55.94 59.3,55.94 58.86,56.37 44.73,56.37 44.13,56.97 37.11,56.97 30.24,63.84 25.46,63.84 20.85,68.45 20.85,69.07 15.63,74.29 15.63,75.51 13.67,77.47 12.35,77.47 v1(11.59,78.23)
5V_DUAL_USB_EN_M: length 12.1
  TOP w0.089: U4.BD14 46.78,129.1 46.69,129.19 46.69,129.19 46.64,129.23 45.57,129.23 v1(45.12,128.78) 44.66,128.78 43.98,128.1 43.19,128.1
  TOP w0.102: 43.19,128.1 40.78,128.1 39.53,126.85 37.92,126.85 R6658.2
  BOTTOM w0.089: v1(45.12,128.78) v2(44.35,128.78)
5V_SMART_USB_EN: length 374.6
  TOP w0.089: U4.N44 62.29,113.99 62.29,113.56 62.64,113.21 62.64,112.4 63.66,111.38 63.66,111.25
  TOP w0.102: 63.66,111.25 63.66,110.74 63.79,110.62 RH4.2 64.32,109.39 64.32,106.84 65.22,105.94 65.6,105.94 65.82,105.72 65.82,102.46 64.7,101.35 63.22,101.35 62.13,100.25 60.3,100.25 59.05,99 59.05,98.17 58.65,97.76 56.66,97.76 55.34,96.44 53.26,96.44 52.55,95.73 49.69,95.73 49.03,96.39 46.01,96.39 45.5,95.88 44.31,95.88 43.57,95.15 43.57,91.76 44.75,90.58 v1(45.96,90.58) ; v1(14.51,158.88) 14.51,159.18 13.85,159.84 13.55,159.84 10.54,162.85 10.54,182.03 9.63,182.93 7.01,182.93 5.06,184.88 5.06,206.81 v1(4.48,207.39) ; v1(46.86,81.67) 46.55,81.67 45.8,80.92 42.89,80.92 42.46,80.5 39.65,80.5 35.51,76.35 30.91,76.35 29.99,75.44 25.02,75.44 22.05,78.4 22.05,78.71 18.31,82.45 18.31,82.99 18.31,83.45 18.09,83.67 16.77,83.67 v1(16.64,83.79) ; v1(91.98,253.87) 91.47,253.37 91.47,249.68 92.03,249.12 PU20.4
  BOTTOM w0.102: v1(91.98,253.87) 91.83,253.72 89.86,253.72 86.4,257.18 76.86,257.18 72.92,253.24 66.71,253.24 63.03,249.56 52.37,249.56 51.43,250.49 45.77,250.49 44.32,251.94 39.69,251.94 34.23,246.48 32.37,246.48 30.87,247.98 23.3,247.98 22.28,246.96 19.92,246.96 18.68,245.72 18.68,244.04 17.97,243.33 17.97,241.33 17.35,240.71 15.16,240.71 13.44,238.99 6.47,238.99 3.84,236.36 3.84,208.03 v1(4.48,207.39) ; v1(46.86,81.67) 47.07,81.87 47.07,83.88 47.85,84.66 47.85,86.8 45.96,88.69 v1(45.96,90.58) ; v1(14.51,158.88) 15.07,158.32 15.07,157.3 v2(15.15,157.23) 15.58,156.79 15.58,152.2 15.14,151.76 15.14,150.69 14.87,150.42 14.43,150.42 14.21,150.19 14.21,149.33 14.36,149.17 14.36,140.85 11.18,137.67 11.18,126.36 13.22,124.32 13.22,111.52 12.68,110.99 12.68,103.06 6.48,96.86 6.48,90.51 10.97,86.03 15.21,86.03 16.11,85.13 16.11,84.33 v1(16.64,83.79)
+3V_5V_EN: length 35.3
  TOP w0.254: PR234.2 PC343.1 16.48,64.39 PR237.2 18.83,64.07 v1(19.5,63.4) 19.73,63.17 38.99,63.17 PQ52.D2 41.44,63.51 47.58,63.51 PR238.1
+3V_5V_EN_3V:
  vias: v1(52.48,61.98)
+3V_5V_EN_3V_R: length 4.4
  TOP w0.102: PR238.2 49.12,62.04 v1(49.06,61.98)
  TOP w0.356: PR239.2 51.09,62.93 PC347.1
  TOP w0.508: PC347.1 49.18,63.82 PR235.2 PR238.2
+3V_5V_EN_5V: length 6.6
  TOP w0.102: PR237.1 17.11,63.5 v1(17.43,63.5)
  TOP w0.508: PQ50.G 14.64,60.32 16.8,62.48 PR237.1
+3V_5V_EN_R:
  vias: v1(38.9,61.21)
+3V_BATT: length 292.5
  TOP w0.254: v1(49.49,124.18) 49.39,124.18 48.9,124.66 48.63,124.66 48.37,124.92 U4.BA22 ; v1(30.51,119.25) 30.31,119.46 27.03,119.46 26.07,118.49 v1(23.27,118.49)
  TOP w0.508: C1682.1 C1683.1 v1(43.98,122.24) ; v1(165.01,37.16) 165.01,42.16 168.92,46.08 168.92,48.62 169.96,49.66 D1.3 ; v1(23.02,131.22) 24.82,133.02 28.66,133.02 30.92,130.76 32.55,130.76 33.13,131.34 36.43,131.34 v1(37.22,130.56) 37.45,130.33 37.45,129.41 38.27,128.59 R6467.1 R6425.2 ; R6539.1 170.59,31.39 v1(170.59,37.16)
  TOP w0.762: 72.19,68.56 56.97,68.56 55.15,70.38 53.14,70.38 52.05,69.29 40.57,69.29 ; D1.3 169.58,51.82 169.58,55.8 C228.1
  BOTTOM w0.254: v1(49.49,124.18) 48.17,122.86 46.78,122.86 46.73,122.81 44.55,122.81 v1(43.98,122.24) 43.91,122.3 42.76,122.3 42.12,121.67 40.17,121.67 38.6,120.09 34.86,120.09 34.04,119.28 33.03,119.28 32.45,119.86 31.12,119.86 v1(30.51,119.25)
  BOTTOM w0.508: v1(170.59,37.16) v1(165.01,37.16) ; v1(23.27,118.49) 23.27,123.34 23.02,123.6 v1(23.02,131.22)
  BOTTOM w0.762: 167.04,55.88 165.89,55.88 165.32,56.45 159.7,56.45 158.98,55.73 155.47,55.73 154.78,56.41 148.47,56.41 147.37,55.31 145.79,55.31 144.77,54.29 133.54,54.29 132.72,53.48 114.49,53.48 111.95,56.03 92.17,56.03 88.16,60.04 86.29,60.04 79.98,66.35 75.72,66.35 74.7,67.37 73.68,67.37 ; v1(23.27,118.49) 22.02,117.23 22.02,116.41 18.93,113.33 18.93,106.96 27.13,98.76 27.13,96.14 30.22,93.05 30.22,88.27 31.22,87.26 31.22,83.84 30.54,83.15 30.54,81.07 34.55,77.05 34.55,74.4 39.66,69.29 39.73,69.29
  vias: v1(39.81,69.29) v1(40.5,69.29) v1(72.47,67.66) v1(72.47,67.03) v1(167.55,56.26) v1(168.18,56.26)
+3V_LAN: length 7.8
  TOP w0.203: v1(107.64,227.8) RTK_LAN.11
  TOP w0.406: UU17.5 102.47,230 v1(102.93,230.45) ; v1(123.46,238.63) 123.94,238.16 UU18.5
  TOP w0.508: RL43.2 67.15,254.38 v1(70.9,254.38) ; v1(103.13,234) 102.4,234 CL33.1
  vias: v1(71.66,254.38) v1(71.66,253.75) v1(72.42,254.38) v1(99.73,241.3) v1(99.73,240.54) v1(100.49,241.3) v1(100.49,240.54) v1(104,230.02) v1(113.62,222.76) v1(114.13,222.28) v1(116.95,232.05) v1(116.95,231.42) v1(117,229.74)
+3V_VA: length 16.3
  TOP w0.203: 184.31,27.59 184.58,27.32 UA1.9
  TOP w0.508: RA18.2 RA17.2 178.02,29.35 v1(177.96,29.42) ; 184.31,27.59 182.79,29.11 182.79,29.54
  BOTTOM w0.508: 187.87,26.5 185.07,26.5 v1(182.15,29.42) 182.13,29.39 177.99,29.39 v1(177.96,29.42)
  vias: v1(188.48,19.1) v1(188.69,27.77) v1(189.39,28.15) v1(189.64,28.78)
+5V_3P3V_PG: length 3.1
  TOP w0.203: 47.52,51.42 PU16.7
  TOP w0.254: PR269.2 v1(49.25,50.55) 49.12,50.67 48.27,50.67 47.52,51.42
+5V_AUX: length 738.4
  TOP w0.203: PC336.1 45.23,54.32 PU16.14
  TOP w0.254: v1(103.28,145.67) 103.28,146.08 105.67,148.46 108.46,148.46 109.62,149.63 111.73,149.63 115.77,153.67 117,153.67 117.89,154.56 117.89,155.89 PR212.1 ; v1(89.95,108.36) 89.95,111.82 91.4,113.27 91.4,126.99 91.27,127.12 91.27,129.24 90.36,130.15 v1(90.36,134.39) ; PU5.21 63.54,79.63 63.41,79.5 62.42,79.5 62.34,79.58
  TOP w0.406: PU3.6 149.31,70.48 PC48.1 v1(148.45,70.43)
  TOP w0.508: v1(113.06,71.5) 112.43,70.87 112.43,63.37 v1(112.05,62.99) ; v1(217.48,73.52) 218.01,73.52 PR347.1 ; v1(111.36,45.11) 111.36,42.73 107.03,38.39 107.03,36.51 PQ54.D ; PR232.1 14.64,33.48 v1(14.64,33.15) ; v1(220.69,70.53) 221.4,69.82 v1(221.86,69.82) ; v1(87.92,76.58) 86.39,78.1 86.39,85.7 85.43,86.67 85.43,88.16 87.39,90.13 89.17,90.13 94.42,95.38 94.42,100.69 ; 150.14,63.69 PR54.2 ; 150.14,63.69 150.14,65.26 148.88,66.53 148.88,66.62 148.45,67.06 v1(148.45,70.43) ; 150.14,63.69 150.14,62.06 148.7,60.62 v1(148.7,58.45) ; v1(207.14,73.86) 207.75,74.47 PR39.2 ; v1(74.48,76.45) 74.48,73.86 73.82,73.21 73.82,62.6 77.57,58.86 77.57,58.36 v1(78.27,57.66) ; v1(44.72,35.34) 44.56,35.18 CS179.1 ; PC336.1 44.28,55.4 43.64,56.04 32.11,56.04 30.23,57.91 28.61,57.91 ; 94.42,100.69 94.42,102.23 v1(93.58,103.07) ; 94.42,100.69 94.44,100.71 95.23,100.71 96.11,101.59 PR77.1 ; 62.34,79.58 61.32,80.59 PC63.2 59.77,80.01 v1(59.77,77.6) 59.77,75.45 PR353.1 ; v1(219.05,63.91) 217.44,65.53 210.98,65.53 202.22,56.77 199.55,56.77 196.63,53.85 v1(193.96,53.85) 193.07,52.96 193.07,43.52 206.03,30.56 206.03,23.88 207.02,22.88 207.02,18.33 v1(207.63,17.72)
  TOP w0.889: 18.72,59.64 PCE35.1 ; PCE35.1 18.72,61.52 ; PCE35.1 17.78,60.58 ; PCE35.1 19.66,60.58 ; PCE36.1 26.52,60.58 ; PCE36.1 25.58,59.64 ; PCE36.1 25.58,61.52 ; PCE36.1 24.64,60.58
  TOP w2.032: 11.82,32.41 5.54,32.41 2.47,35.48 2.47,40.69 3.69,41.91 ; 2.57,43.81 2.57,238 4.73,240.16 7.53,240.16
  BOTTOM w0.254: PCE35.1 18.83,60.47 PJP30.1 ; v1(103.28,145.67) 102.88,145.67 v2(102.09,144.88) 102.09,142.6 103.79,140.89 103.79,137.81 103.17,137.19 102.67,137.19 101.96,136.47 100.21,136.47 99.78,136.91 98.08,136.91 97.39,137.59 96.09,137.59 93.58,135.08 93.57,135.08 93.36,134.86 91,134.86 90.53,134.39 v1(90.36,134.39)
  BOTTOM w0.508: v1(112.05,62.99) 111.41,63.63 110.26,63.63 109.01,62.38 103.85,62.38 102.71,63.53 101.76,63.53 100.62,62.38 98.34,62.38 97.17,63.55 93.99,63.55 88.86,68.68 88.86,69.75 87.92,70.69 v1(87.92,76.58) 87.28,76.58 86.27,75.56 75.37,75.56 v1(74.48,76.45) 74.3,76.63 69.71,76.63 68.03,74.96 66.81,74.96 66.2,75.56 63.86,75.56 62.16,77.27 60.8,77.27 60.52,77.55 59.83,77.55 v1(59.77,77.6) ; v1(78.27,57.66) 79.29,56.63 81.7,56.63 84.32,54.01 86.21,54.01 92.6,47.62 98.19,47.62 99.34,48.77 101.21,48.77 101.87,48.11 103.14,48.11 103.67,48.64 109.55,48.64 111.36,46.83 v1(111.36,45.11) ; 216.75,18.14 215.04,18.14 214.63,17.73 207.64,17.73 v1(207.63,17.72) ; v1(113.06,71.5) 113.4,71.84 127.4,71.84 129.62,69.62 131.14,69.62 133.22,71.7 147.18,71.7 v1(148.45,70.43) ; v1(148.7,58.45) 148.7,58.44 155.83,58.44 156.43,57.85 158.21,57.85 158.88,58.52 166.1,58.52 166.26,58.67 178.48,58.67 179.39,57.76 190.05,57.76 v1(193.96,53.85) ; v1(219.05,63.91) 219.14,63.91 221.86,66.64 v1(221.86,69.82) ; v1(89.95,108.36) 91.4,108.36 91.9,107.85 91.9,105.82 93.58,104.14 v1(93.58,103.07) ; v1(220.69,70.53) 219.72,71.5 219.5,71.5 v1(217.48,73.52) 215.82,73.52 214.82,74.52 207.81,74.52 v1(207.14,73.86)
  vias: v1(11.46,55.37) v1(11.84,46.3) v1(12.23,55.37) v1(12.61,46.3) v1(12.86,33.15) v1(12.99,55.37) v1(13.22,32.49) v1(13.37,46.3) v1(13.75,55.37) v1(13.75,33.15) v1(14.13,46.3) v1(14.13,32.51) v1(14.51,55.37) v1(15.02,32.51) v1(15.53,33.15) v1(15.65,54.36) v1(15.65,53.59) v1(15.65,52.83) v1(15.65,50.42) v1(15.65,49.66) v1(15.65,48.9) v1(15.88,32.49) v1(16.42,33.15) v1(16.77,32.49) v1(17.05,54.23) v1(17.05,49.28) v1(17.31,48.13) v1(17.31,46.86) v1(17.31,33.15) v1(17.69,32.51) v1(17.81,54.23) v1(17.81,49.28) v1(17.94,59.82) v1(18.45,48.13) v1(18.45,46.86) v1(18.58,54.23) v1(18.58,49.28) v1(18.58,32.51) v1(19.08,33.15) v1(19.85,61.09) v1(19.85,59.94) v1(20.1,48.13) v1(20.1,46.86) v1(20.23,52.45) v1(20.23,51.69) v1(20.23,50.93) v1(20.35,59.44) v1(20.35,58.55) v1(21.24,48.13) v1(21.24,46.86) v1(21.5,59.44) v1(21.5,58.55) v1(22.64,59.56) v1(22.64,58.55) v1(23.78,59.56) v1(23.78,58.55) v1(24.42,60.71) v1(25.05,59.56) v1(25.05,58.55) v1(26.2,59.56) v1(26.2,58.55) v1(26.7,60.71) v1(100.49,35.81) v1(100.49,27.05) v1(101.38,35.81) v1(101.38,27.05) v1(102.27,35.81) v1(102.27,27.05) v1(103.16,35.81) v1(103.16,27.05) v1(104.05,35.81) v1(104.05,27.05) v1(104.94,27.05) v1(105.82,27.05) v1(216.77,18.16) v1(224.13,18.34) v1(224.13,17.57)
+5V_DDC: length 35.8
  TOP w0.508: CG18.2 v1(157.39,233.93) 156.31,232.85 RG20.1 RG21.1 ; DG4.2 186.42,236.14 185.33,237.24 175.44,237.24 v3(174.81,236.61) ; RG24.2 161.72,234.43 v1(161.45,234.7)
  BOTTOM w0.508: v1(157.39,233.93) 160.69,233.93 v1(161.45,234.7) 161.7,234.95 173.15,234.95 v2(174.13,235.93) v3(174.81,236.61)
+5V_DUAL_USB: length 31.6
  TOP w0.508: CS145.1 238.22,114.14 v1(238.16,114.2) ; CS143.1 228.97,117.03 229.47,116.54 v1(229.47,116.38) ; v1(69.76,48.39) 70.2,48.39 CS161.1 ; CS212.1 132.3,33.21 v1(131.73,33.78) ; v1(229.17,59.82) 229.08,59.74 PR388.2
  TOP w2.032: 93.51,41.66 72.93,41.66
  BOTTOM w0.508: v1(231.61,65.31) 231.61,64.06 229.17,61.62 v1(229.17,59.82)
  vias: v1(66.2,71.78) v1(66.84,71.78) v1(67.47,71.78) v1(68.11,71.78) v1(69.25,41.02) v1(69.76,41.53) v1(70.26,42.04) v1(70.77,42.54) v1(71.15,48.39) v1(71.92,48.39) v1(72.68,48.39) v1(94.65,42.42) v1(97.19,42.42) v1(97.32,39.5) v1(97.7,40.13) v1(107.86,35.94) v1(108.87,35.94) v1(109.89,35.94) v1(110.9,35.94) v1(111.79,36.7) v1(111.79,35.94) v1(112.56,36.7) v1(112.56,35.94) v1(113.57,36.45) v1(114.59,36.45) v1(126.71,21.44) v1(127.47,21.44) v1(128.24,21.44) v1(129,21.44) v1(133.38,5.67) v1(134.15,5.67) v1(134.91,5.67) v1(135.67,7.07) v1(135.67,6.3) v1(135.67,5.67) v1(145.96,243.08) v1(145.96,242.32) v1(145.96,241.55) v1(146.72,243.08) v1(146.72,242.32) v1(146.72,241.55) v1(147.48,242.32) v1(147.48,241.55) v1(153.47,9.48) v1(153.47,8.59) v1(154.49,9.48) v1(154.49,8.59) v1(155.51,9.48) v1(155.51,8.59) v1(155.86,239.52) v1(155.86,238.89) v1(164.63,240.92) v1(164.63,240.16) v1(164.9,6.05) v1(164.9,5.16) v1(165.39,240.92) v1(165.39,240.16) v1(165.92,6.05) v1(165.92,5.16) v1(166.78,42.67) v1(166.94,6.05) v1(166.94,5.16) v1(167.04,255.91) v1(167.04,255.14) v1(167.04,254) v1(167.04,253.24) v1(167.42,25.86) v1(167.42,25.1) v1(167.55,42.67) v1(167.8,255.91) v1(167.8,255.14) v1(167.8,254) v1(167.8,253.24) v1(168.18,25.86) v1(168.18,25.1) v1(168.31,42.67) v1(168.94,25.86) v1(168.94,25.1) v1(169.07,42.67) v1(169.83,42.67) v1(170.59,42.67) v1(170.87,5.92) v1(170.87,5.03) v1(171.36,42.67) v1(171.89,5.92) v1(171.89,5.03) v1(172.12,42.67) v1(172.88,42.67) v1(172.91,5.92) v1(172.91,5.03) v1(184.46,54.86) v1(185.48,54.86) v1(186.75,54.86) v1(187.76,54.86) v1(199.55,59.56) v1(199.55,58.93) v1(200.19,59.56) v1(200.19,58.93) v1(200.82,59.56) v1(200.82,58.93) v1(201.46,59.56) v1(201.46,58.93) v1(204.88,256.03) v1(204.88,255.27) v1(204.88,254.51) v1(204.88,253.75) v1(205.65,256.03) v1(205.65,255.27) v1(205.65,254.51) v1(205.65,253.75) v1(219.57,67.49) v1(219.57,66.85) v1(219.57,66.22) v1(220.2,67.49) v1(220.2,66.85) v1(220.2,66.22) v1(220.84,67.49) v1(220.84,66.85) v1(226.47,236.6) v1(226.47,235.84) v1(226.47,235.08) v1(226.47,234.31) v1(227.24,236.6) v1(227.24,235.84) v1(227.24,235.08) v1(227.24,234.31) v2(156.17,238.12)
+5V_HDMI:
  vias: v1(220.63,253.24)
+5V_MAIN: length 759
  TOP w0.356: v1(204.42,48.35) 204.42,48.05 203.98,47.61 QO2.1
  TOP w0.381: RK4.1 RK5.2 45.15,169.05 SLOT3.A59 ; v1(70.47,181.03) 70.47,180.34 67.8,177.67 59.14,177.67 v1(58.73,178.08) ; RK49.2 v1(61.63,185.17) ; RK37.2 62.72,183.27 62.72,181.36 v1(61.35,179.98)
  TOP w0.508: 57.1,207.88 57.1,208.96 58.71,210.57 61.76,210.57 ; CK60.1 CK67.1 v1(26.45,223.9) ; RIO11.1 196.55,12.45 v1(197.2,13.1) ; ECK1.1 29.9,171.2 ; ECK1.1 29.01,170.31 ; ECK1.1 29.9,169.42 ; ECK1.1 30.79,170.31 ; v1(226.5,184.81) 226.5,184.43 227.47,183.46 228.43,183.46 229.19,184.22 PR98.2 ; CK33.1 45.82,167.64 SLOT3.A61 ; PD6.2 v1(9.81,39.75) ; v1(196.13,54.7) 195.99,54.56 191,54.56 185.66,49.22 185.66,45.21 ; v1(223.93,226.01) 223.93,225.79 223.43,225.28 220.23,225.28 218.6,223.65 v1(218.6,221.54) ; CK30.1 37.12,165.29 SLOT3.B62 ; v1(67.92,209.17) 66.53,210.57 61.76,210.57 ; RK4.1 47.95,169.05 v1(48.24,169.34) ; CB3.1 10,149.99 LPC_DEBUG.8 ; RF5.1 218.37,231.39 v1(218.35,231.37) ; CK59.1 25.49,237.82 24.64,237.82 SLOT4.A5 ; 61.76,210.57 RK32.2 RK24.2 ; v1(142.65,217.35) RG29.1 143.54,218.12 144.05,218.63 QG1.G ; PR197.2 145.19,204.55 143.68,206.06 142.51,206.06 139.3,209.27 v1(139.3,217.91) ; v3(226.3,199.09) 226.3,198.42 228.76,195.96 PR160.2 ; PR137.2 v3(215.45,190.18)
  TOP w0.762: v1(205.14,246.63) 204.15,245.64 FG1.1 199.12,243.31 194.77,243.31 191.84,240.37 191.84,237.69 190.08,235.93 DG4.1 ; F2.2 225.54,247.4 D41.3 v1(225.41,246.07)
  TOP w0.889: PCE31.1 11.61,63.75 ; PCE31.1 10.72,62.87 ; PCE31.1 11.61,61.98 ; PCE31.1 12.5,62.87
  TOP w1.016: 65.44,242.57 51.94,242.57 50.92,243.59 49.44,243.59 ; v1(91.98,235.58) 86.75,240.82 76.59,240.82 v1(76.24,241.17) v1(75.47,241.94) ; v1(109.89,42.54) 108.8,42.54 105.11,38.86 102.01,38.86 ; v1(180.07,42.53) v1(181.08,42.53) 182.97,42.53 185.91,45.47 188.85,45.47 202.34,31.97 202.34,25.4
  TOP w1.27: 100.16,39.86 SATA_PWR.2 101.37,41.07
  TOP w3.048: 48.67,27.81 68.49,27.81 71.41,30.73 71.41,33.91 76.49,38.99 84.87,38.99
  BOTTOM w0.381: v1(70.47,181.03) 70.47,191.95 v1(70.26,192.15) ; v1(61.63,185.17) 61.35,184.89 v2(61.35,184.4) v1(61.35,179.98) 61.35,179.38 60.05,178.08 v1(58.73,178.08) 58.55,177.9 51.7,177.9 48.17,174.37 48.17,169.42 v1(48.24,169.34)
  BOTTOM w0.508: v1(204.42,48.35) 200.33,48.35 199.81,48.87 199.81,51.81 197.06,54.56 196.27,54.56 v1(196.13,54.7) ; v1(196.76,23.7) 196.12,23.07 196.12,20.57 197.2,19.49 v1(197.2,13.1) ; 188.5,231.9 189.8,230.61 212.86,230.61 213.77,231.52 218.19,231.52 v1(218.35,231.37) 219.03,230.68 223.08,230.68 224.42,229.35 224.42,226.49 v1(223.93,226.01) ; v1(226.5,184.81) 225.48,185.83 224.19,185.83 223.6,186.41 223.6,187.53 222.62,188.51 216.67,188.51 215.45,189.74 v3(215.45,190.18) 218.51,190.18 219.08,190.75 219.08,192.96 219.79,193.68 220.76,193.68 221.6,194.51 221.6,195.66 222.16,196.22 222.79,196.22 225.66,199.09 v3(226.3,199.09) 226.3,200.93 227.44,202.07 231.21,202.07 232.72,203.58 232.72,209.55 222.61,219.67 221.33,219.67 219.46,221.54 v1(218.6,221.54) ; v1(67.92,209.17) 67.98,209.11 v1(67.98,205.99) v1(67.98,205.1)
  BOTTOM w0.762: v1(225.41,246.07) 222.55,246.07 222.02,246.61 220.19,246.61 219.39,245.81 205.96,245.81 v1(205.14,246.63)
  BOTTOM w0.889: SLOT3.B59 38.87,169.28 ; SLOT3.B59 40.81,169.28 ; SLOT3.B59 39.84,168.32 ; SLOT3.B59 39.84,170.25 ; ECK5.1 30.28,231.9 ; ECK5.1 31.17,231.01 ; ECK5.1 29.39,231.01 ; ECK5.1 30.28,230.12 ; 25.57,169.28 SLOT4.A59 ; SLOT4.A59 24.6,168.32 ; SLOT4.A59 23.63,169.28 ; SLOT4.A59 24.6,170.25 ; 38.27,165.47 SLOT3.B62 ; SLOT3.B62 37.3,166.44 ; SLOT3.B62 37.3,164.51 ; SLOT3.B62 36.33,165.47 ; SLOT3.A62 41.41,165.47 ; SLOT3.A62 43.35,165.47 ; SLOT3.A62 42.38,166.44 ; SLOT3.A62 42.38,164.51 ; 24.6,236.9 SLOT4.A5 ; SLOT4.A5 25.57,237.86 ; SLOT4.A5 23.63,237.86 ; 44.92,168.32 SLOT3.A59 ; SLOT3.A59 44.92,170.25 ; SLOT3.A59 43.95,169.28 ; SLOT3.A61 44.92,167.71 ; SLOT3.A61 44.92,165.78 ; SLOT3.A61 43.95,166.74 ; SLOT3.B6 37.3,237.56 ; SLOT3.B6 36.33,236.59 ; SLOT3.B6 37.3,235.63 ; SLOT3.B6 38.27,236.59 ; SLOT4.B59 20.49,169.28 ; SLOT4.B59 18.55,169.28 ; SLOT4.B59 19.52,168.32 ; SLOT4.B59 19.52,170.25 ; ECK1.1 29.9,171.2 ; ECK1.1 29.01,170.31 ; ECK1.1 29.9,169.42 ; ECK1.1 30.79,170.31 ; 19.52,219.12 SLOT4.B19 ; SLOT4.B19 20.49,220.08 ; SLOT4.B19 18.55,220.08 ; SLOT4.B19 19.52,221.05 ; SLOT4.A10 22.06,232.48 ; SLOT4.A10 21.09,231.51 ; SLOT4.A10 23.03,231.51 ; SLOT4.A10 22.06,230.55 ; 42.38,233.09 SLOT3.A8 ; SLOT3.A8 42.38,235.02 ; SLOT3.A8 41.41,234.05 ; SLOT3.A8 43.35,234.05 ; 16.98,235.63 SLOT4.B6 17.95,236.59 ; 19.52,165.78 SLOT4.B61 ; SLOT4.B61 20.49,166.74 ; SLOT4.B61 19.52,167.71 ; SLOT4.B61 18.55,166.74 ; 11.61,61.98 PCE31.1 ; PCE31.1 10.72,62.87 ; PCE31.1 12.5,62.87 ; PCE31.1 11.61,63.75 ; SLOT4.A61 23.63,166.74 ; SLOT4.A61 24.6,167.71 ; SLOT4.A61 24.6,165.78 ; SLOT4.A61 25.57,166.74 ; SLOT3.A10 42.38,232.48 ; SLOT3.A10 41.41,231.51 ; SLOT3.A10 43.35,231.51 ; SLOT3.A10 42.38,230.55 ; 16.98,164.51 SLOT4.B62 ; SLOT4.B62 17.95,165.47 ; SLOT4.B62 16.98,166.44 ; SLOT4.B62 16.01,165.47 ; SLOT3.A16 42.38,224.86 ; SLOT3.A16 43.35,223.89 ; SLOT3.A16 41.41,223.89 ; SLOT3.A16 42.38,222.93 ; SLOT4.A8 22.06,235.02 ; SLOT4.A8 23.03,234.05 ; SLOT4.A8 22.06,233.09 ; SLOT4.A8 21.09,234.05 ; 22.06,164.51 SLOT4.A62 ; SLOT4.A62 21.09,165.47 ; SLOT4.A62 22.06,166.44 ; SLOT4.A62 23.03,165.47 ; SLOT4.A16 22.06,224.86 ; SLOT4.A16 22.06,222.93 ; SLOT4.A16 23.03,223.89 ; SLOT4.A16 21.09,223.89 ; 20.49,237.86 SLOT4.B5 19.52,236.9 ; 43.95,237.86 SLOT3.A5 44.92,236.9 ; 39.84,221.05 SLOT3.B19 38.87,220.08 ; SLOT3.B61 39.84,167.71 ; SLOT3.B61 40.81,166.74 ; SLOT3.B61 39.84,165.78 ; SLOT3.B61 38.87,166.74
  BOTTOM w1.016: v1(181.08,42.53) v1(180.07,42.53) 175.64,38.1 173.9,38.1 172.05,36.25 154.48,36.25 152.21,38.52 138.48,38.52 137.5,39.5 124.08,39.5 123.31,40.26 118.78,40.26 117.19,41.85 113.26,41.85 112.56,42.54 v1(109.89,42.54) ; v1(91.98,235.58) v1(92.87,234.7) 93.08,234.49 93.08,228.96 99.38,222.66 104.78,222.66 105.6,221.84 107.96,221.84 108.54,221.26 110.11,221.26 113,218.36 117.21,218.36 117.85,219 126.98,219 129.09,221.11 136.1,221.11 v1(139.3,217.91) 142.1,217.91 v1(142.65,217.35) 142.73,217.27 153.32,217.27 156.97,220.92 159.63,220.92 161.58,222.87 162.69,222.87 164,224.18 166.48,224.18 167.88,222.78 172.52,222.78 174.4,224.66 177.01,224.66 177.67,224 180.47,224 186.47,230 186.47,231.78 ; 64.8,242.57 71.53,242.57 72.17,241.94 v1(75.47,241.94)
  vias: v1(7.53,64.26) v1(7.53,58.55) v1(8.16,58.55) v1(8.29,61.09) v1(8.54,64.26) v1(8.92,61.09) v1(10.42,120.6) v1(10.93,120.09) v1(11.21,61.59) v1(11.21,59.06) v1(11.21,58.29) v1(11.21,57.53) v1(11.44,119.58) v1(11.59,83.06) v1(11.59,82.42) v1(11.97,61.59) v1(25.56,167.89) v1(26.2,169.8) v1(26.7,166.5) v1(27.59,239.78) v1(27.97,165.61) v1(27.97,164.59) v1(28.74,170.31) v1(29.88,169.16) v1(44.74,28.83) v1(44.74,27.94) v1(44.74,27.05) v1(45.63,28.83) v1(45.63,27.94) v1(45.63,27.05) v1(46.52,28.83) v1(46.52,27.94) v1(46.52,27.05) v1(64.93,242.44) v1(65.69,242.44) v1(186.22,232.66) v1(188.76,232.66) v1(197.9,25.1) v1(198.53,24.59) v1(202.47,24.38) v1(202.47,23.75)
+5V_PS2: length 13.3
  TOP w0.508: v1(149,235.97) 149,235.59 148.75,235.33 UU27.5 ; C414.1 158.13,239.38 157.13,238.38 v1(157.13,236.6)
  BOTTOM w0.508: v1(149,235.97) 149,236.22 149.39,236.6 v1(157.13,236.6)
  vias: v1(163.48,250.19)
+5V_SMART_USB: length 14.7
  TOP w0.406: UU1.5 101.08,243.64 v1(101.53,243.18)
  TOP w0.508: 95.89,251.33 ECU13.1 ; ECU13.1 96.78,250.44 ; ECU13.1 97.67,251.33 ; ECU13.1 96.78,252.22
  BOTTOM w0.508: ECU13.1 99.96,248.15 99.96,247.01 101.53,245.44 v1(101.53,243.18)
  vias: v1(95.66,251.33) v1(96.81,252.48) v1(96.81,250.19) v1(98.08,251.33)
+5V_USB_EN_L: length 3.8
  TOP w0.508: PR246.1 110.75,31.62 v1(110.57,31.44) 110.57,30.9 109.89,30.23 PQ54.G
  BOTTOM w0.102: v1(110.57,31.44) v2(109.68,31.44)
